# Allegro board Dell_Inspiron_15_7577_Compal_CKA50_CKF50_LA_E992P_Rev_1_0_BoardView.brd (continued)
## Library data of the parts (continued)
U5603 = LNG2DMTR_LGA12_2X2
UA1 = G9090-180T11U_SOT23-5
UC1 = 74AUP1G07GW_TSSOP5: room: CPU
UC16 = 74AUP1G07GW_TSSOP5: room: PCH
UE1 = MEC1404-NU-TR_VTQFP128_14X14: room: EC
UE3 = TCS40DLR_SOT23F3
UE4 = SY6288D20AAC_SOT23-5: room: TOUCH PAD
UE6 = SN74LVC1G06DCKR_SC70-5: room: EC
UG1-UG6 = H5GQ1H24AFR-T2L_BGA_170P
UG9 = N17E-G1_BGA_2152P
UG10 UG22 UG26 UG29 UG31 = NL17SZ08DFT2G_SC70-5
UG11 = INA3221AIRGVR_VQFN16_4X4
UG12 = TPS22966DPUR_SON14_2X3
UG13 = W25Q80EWSSIG_SO8
UG14 = TPS22961DNYR_WSON8
UG25 UG27 = 74LVC1G32GW_TSSOP5
UG30 = TC7SH08FU_SSOP5
UH1 = SKL-H_BGA_1440P-T: room: CPU
UH2 = SKY-S-PCH_BGA_837P-T: room: PCH
UH7 UH14 = MC74VHC1G08DFT2G_SC70-5: room: PCH
UH8 = W25Q128FVSIQ_SO8: room: PCH
UI3 = SN65LVPE502ARGER_VQFN24_4X4-S
UL1 = RTL8111H-CG_QFN32_4X4-S: room: LAN
UL2 = SY6288C20AAC_SOT23-5: room: LAN
UP2 = PS8409QFN48GTR2-A0_QFN48_6X6-S
UR1 = RTS5176E-GR_QFN24_4X4-S
US1 = TPS2544RTER_WQFN16_3X3-S: room: USB1
US2 = SY6288D20AAC_SOT23-5
UT1 = ALPINE-RIDGE_BGA_337P
UT2 = W25Q80DVSSIG_SO8
UT4 = TPS65982DAZQZR-ES_BGA_96P
UT5 = W25X20CLSNIG_SO8
UTH1 = F75303M_MSOP10
UTPM1 = NPCT650JB2YX_QFN32_5X5
UV17 = AP2330W-7_SC59-3: room: HDMI
UVGA1 = RTD2166-CG_QFN32_4X4-S
UZ1 = EM5209VF_DFN14_3X2: room: 3V_5V_DC_DC
UZ8 = SY6288C20AAC_SOT23-5: room: EDP_DC_DC
UZ9 = TPS22961DNYR_WSON8: room: CPU
UZ15 = TPS22961DNYR_WSON8: room: CPU_DC_DC
UZ16 = APE8937GN2_DFN8_2X2: room: CPU
UZ21 = MC74VHC1G08DFT2G_SC70-5: room: CPU
Y1 = Y_X1A000141000200_2P: room: EC
YG1 = Y_5YEA27000163IF50Q5_4P
YH1 = Y_CM31532768DZFT_2P: room: PCH
YH2 = Y_X3G024000DC1H_4P: room: PCH
YL2 = Y_7V25000014_4P: room: LAN
YT1 = Y_7V25000012_4P

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
2N7002DW-7-F_SOT363-6
  oval 0.432x0.61 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0.65,1.9) 6(0,1.9)
2N7002K_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
74AUP1G07GW_TSSOP5
  oval 0.381x1.346 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.79) 5(0,1.79)
74LVC1G32GW_TSSOP5
  oval 0.381x1.346 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.79) 5(0,1.79)
ACES_50228-0067N-001_6P
  oval 0.61x1.549 smd: 1(0,0) 2(-1,0) 3(-2,0) 4(-3,0) 5(-4,0) 6(-5,0)
  rect 1.194x1.803 smd: 7(1.3,2.525) 8(-6.3,2.525)
ACES_50273-0020N-001_2P-T
  oval 0.787x1.6 smd: 1(0,0) 2(1.25,0)
  rect 2.108x2.997 smd: 3(-2.55,-2.9) 4(3.8,-2.9)
ACES_50278-0040N-001_4P
  oval 0.787x1.905 smd: 1(0,0) 2(1.25,0) 3(2.5,0) 4(3.75,0)
  rect 1.295x3.353 smd: 5(-2.85,-4.925) 6(6.6,-4.925)
ACES_50458-01001-P01_10P-T
  oval 0.559x1.803 smd: 1(0,0) 2(2,0) 3(4,0) 4(6,0) 5(8,0) 6(10,0) 7(12,0) 8(14,0) 9(16,0) 10(18,0)
  rect 1.295x2.057 smd: 11(-3.1,-5.275) 12(21.1,-5.275)
ACES_50699-03001-P01_30P
  oval 0.229x1.143 smd: 1(0,0) 2(0.8,0) 3(1.6,0) 4(2.4,0) 5(3.2,0) 6(4,0) 7(4.8,0) 8(5.6,0) 9(6.4,0) 10(7.2,0) 11(8,0) 12(8.8,0) 13(9.6,0) 14(10.4,0) 15(11.2,0) 16(12,0) 17(12.8,0) 18(13.6,0) 19(14.4,0) 20(15.2,0) 21(16,0) 22(16.8,0) 23(17.6,0) 24(18.4,0) 25(19.2,0) 26(20,0) 27(20.8,0) 28(21.6,0) 29(22.4,0) 30(23.2,0)
  rect 0.559x1.295 smd: 31(-1.475,-3.475) 32(24.675,-3.475)
ACES_51202-00901-001_9P-T
  rect 0.66x5.004 smd: 1(0,0) 2(1.5,0) 3(3,0) 4(4.5,0) 5(6,0) 6(7.5,0) 7(9,0) 8(10.5,0) 9(12,0)
  rect 2.489x2.997 smd: 10(-2.5,-4.45) 11(14.5,-4.45)
ACES_51524-0080N-001_8P
  oval 0.61x1.295 smd: 1(0,0) 2(1,0) 3(2,0) 4(3,0) 5(4,0) 6(5,0) 7(6,0) 8(7,0)
  rect 2.489x2.21 smd: 9(10,-3.05) 10(-3,-3.05)
ACES_51530-01001-P01_10P-T
  oval 0.305x0.838 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0)
  rect 0.787x2.007 smd: 11(-1.7,-3.175) 12(6.2,-3.175)
ACES_51575-00401-001_4P-T
  oval 0.406x1.194 smd: 1(0,0) 2(1,0) 3(2,0) 4(3,0)
  rect 0.787x2.007 smd: 5(-2.2,-3.4) 6(5.2,-3.4)
ACES_51625-01201-001_12P
  oval 0.305x1.092 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0)
  rect 0.991x2.489 smd: 13(-1.8,-3.6) 14(7.3,-3.6)
ACES_59003-04006-001_40P
  round 0.889 hole 0.889 unplated: (-20.25,2.125) (0.75,2.125)
  oval 0.254x1.143 smd: 1(0,0) 2(-0.5,0) 3(-1,0) 4(-1.5,0) 5(-2,0) 6(-2.5,0) 7(-3,0) 8(-3.5,0) 9(-4,0) 10(-4.5,0) 11(-5,0) 12(-5.5,0) 13(-6,0) 14(-6.5,0) 15(-7,0) 16(-7.5,0) 17(-8,0) 18(-8.5,0) 19(-9,0) 20(-9.5,0) 21(-10,0) 22(-10.5,0) 23(-11,0) 24(-11.5,0) 25(-12,0) 26(-12.5,0) 27(-13,0) 28(-13.5,0) 29(-14,0) 30(-14.5,0) 31(-15,0) 32(-15.5,0) 33(-16,0) 34(-16.5,0) 35(-17,0) 36(-17.5,0) 37(-18,0) 38(-18.5,0) 39(-19,0) 40(-19.5,0)
  rect 1.499x2.997 smd: 41(-22,2.125) 42(2.5,2.125)
  rect 2.794x1.499 smd: 43(-15.45,4.175) 44(-4.05,4.175)
ACON_TCRA2-9R1394_9P
  round 1.295 hole 0.711: 1(0,0) 2(-2.5,0) 3(-4.5,0) 4(-7,0) 5(-7.5,-1.5) 6(-5.5,-1.5) 7(-3.5,-1.5) 8(-1.5,-1.5) 9(0.5,-1.5)
  oval 1.295x2.311 hole 0.711x1.702: 10(2.9,0.3) 11(-9.9,0.3)
  oval 1.295x2.007 hole 0.711x1.397: 12(4.2,-8.95) 13(-11.2,-8.95)
ALC3246-CG_MQFN48_6X6-S
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 9(0,-3.2) 10(0,-3.6) 11(0,-4) 12(0,-4.4) 25(6.1,-4.4) 26(6.1,-4) 27(6.1,-3.6) 28(6.1,-3.2) 29(6.1,-2.8) 30(6.1,-2.4) 31(6.1,-2) 32(6.1,-1.6) 33(6.1,-1.2) 34(6.1,-0.8) 35(6.1,-0.4) 36(6.1,0)
  oval 0.203x0.889 smd: 13(0.85,-5.25) 14(1.25,-5.25) 15(1.65,-5.25) 16(2.05,-5.25) 17(2.45,-5.25) 18(2.85,-5.25) 19(3.25,-5.25) 20(3.65,-5.25) 21(4.05,-5.25) 22(4.45,-5.25) 23(4.85,-5.25) 24(5.25,-5.25) 37(5.25,0.85) 38(4.85,0.85) 39(4.45,0.85) 40(4.05,0.85) 41(3.65,0.85) 42(3.25,0.85) 43(2.85,0.85) 44(2.45,0.85) 45(2.05,0.85) 46(1.65,0.85) 47(1.25,0.85) 48(0.85,0.85)
  rect 4.394x4.394 smd: 49(3.05,-2.2)
ALPINE-RIDGE_BGA_337P
  round 0.254 smd: A1(0,0) A23(10.12,0) AA2(0.46,-9.2) AA22(9.66,-9.2) AB2(0.46,-9.66) AB3(0.92,-9.66) AB4(1.38,-9.66) AB5(1.84,-9.66) AB6(2.3,-9.66) AB7(2.76,-9.66) AB8(3.22,-9.66) AB9(3.68,-9.66) AB10(4.14,-9.66) AB11(4.6,-9.66) AB12(5.06,-9.66) AB13(5.52,-9.66) AB14(5.98,-9.66) AB15(6.44,-9.66) AB16(6.9,-9.66) AB17(7.36,-9.66) AB18(7.82,-9.66) AB19(8.28,-9.66) AB20(8.74,-9.66) AB21(9.2,-9.66) AB22(9.66,-9.66) AC1(0,-10.12) AC23(10.12,-10.12) B2(0.46,-0.46) B3(0.92,-0.46) B4(1.38,-0.46) B5(1.84,-0.46) B6(2.3,-0.46) B7(2.76,-0.46) B8(3.22,-0.46) B9(3.68,-0.46) B10(4.14,-0.46) B11(4.6,-0.46) B12(5.06,-0.46) B13(5.52,-0.46) B14(5.98,-0.46) B15(6.44,-0.46) B16(6.9,-0.46) B17(7.36,-0.46) B18(7.82,-0.46) B19(8.28,-0.46) B20(8.74,-0.46) B21(9.2,-0.46) B22(9.66,-0.46) C2(0.46,-0.92) C22(9.66,-0.92) D2(0.46,-1.38) D4(1.16,-1.16) D5(1.81,-1.16) D6(2.46,-1.16) D8(3.11,-1.16) D9(3.76,-1.16) D11(4.41,-1.16) D12(5.06,-1.16) D13(5.71,-1.16) D15(6.36,-1.16) D16(7.01,-1.16) D18(7.66,-1.16) D19(8.31,-1.16) D20(8.96,-1.16) D22(9.66,-1.38) E2(0.46,-1.84) E4(1.16,-1.81) E5(1.81,-1.81) E6(2.46,-1.81) E8(3.11,-1.81) E9(3.76,-1.81) E11(4.41,-1.81) E12(5.06,-1.81) E13(5.71,-1.81) E15(6.36,-1.81) E16(7.01,-1.81) E18(7.66,-1.81) E19(8.31,-1.81) E20(8.96,-1.81) E22(9.66,-1.84) F2(0.46,-2.3) F4(1.16,-2.46) F5(1.81,-2.46) F6(2.46,-2.46) F8(3.11,-2.46) F9(3.76,-2.46) F11(4.41,-2.46) F12(5.06,-2.46) F13(5.71,-2.46) F15(6.36,-2.46) F16(7.01,-2.46) F18(7.66,-2.46) F19(8.31,-2.46) F20(8.96,-2.46) F22(9.66,-2.3) G2(0.46,-2.76) G22(9.66,-2.76) H2(0.46,-3.22) H4(1.16,-3.11) H5(1.81,-3.11) H6(2.46,-3.11) H8(3.11,-3.11) H9(3.76,-3.11) H11(4.41,-3.11) H12(5.06,-3.11) H13(5.71,-3.11) H15(6.36,-3.11) H16(7.01,-3.11) H18(7.66,-3.11) H19(8.31,-3.11) H20(8.96,-3.11) H22(9.66,-3.22) J2(0.46,-3.68) J4(1.16,-3.76) J5(1.81,-3.76) J6(2.46,-3.76) J8(3.11,-3.76) J9(3.76,-3.76) J11(4.41,-3.76) J12(5.06,-3.76) J13(5.71,-3.76) J15(6.36,-3.76) J16(7.01,-3.76) J18(7.66,-3.76) J19(8.31,-3.76) J20(8.96,-3.76) J22(9.66,-3.68) K2(0.46,-4.14) K22(9.66,-4.14) L2(0.46,-4.6) L4(1.16,-4.41) L5(1.81,-4.41) L6(2.46,-4.41) L8(3.11,-4.41) L9(3.76,-4.41) L11(4.41,-4.41) L12(5.06,-4.41) L13(5.71,-4.41) L15(6.36,-4.41) L16(7.01,-4.41) L18(7.66,-4.41) L19(8.31,-4.41) L20(8.96,-4.41) L22(9.66,-4.6) M2(0.46,-5.06) M4(1.16,-5.06) M5(1.81,-5.06) M6(2.46,-5.06) M8(3.11,-5.06) M9(3.76,-5.06) M11(4.41,-5.06) M12(5.06,-5.06) M13(5.71,-5.06) M15(6.36,-5.06) M16(7.01,-5.06) M18(7.66,-5.06) M19(8.31,-5.06) M20(8.96,-5.06) M22(9.66,-5.06) N2(0.46,-5.52) N4(1.16,-5.71) N5(1.81,-5.71) N6(2.46,-5.71) N8(3.11,-5.71) N9(3.76,-5.71) N11(4.41,-5.71) N12(5.06,-5.71) N13(5.71,-5.71) N15(6.36,-5.71) N16(7.01,-5.71) N18(7.66,-5.71) N19(8.31,-5.71) N20(8.96,-5.71) N22(9.66,-5.52) P2(0.46,-5.98) P22(9.66,-5.98) R2(0.46,-6.44) R4(1.16,-6.36) R5(1.81,-6.36) R6(2.46,-6.36) R8(3.11,-6.36) R9(3.76,-6.36) R11(4.41,-6.36) R12(5.06,-6.36) R13(5.71,-6.36) R15(6.36,-6.36) R16(7.01,-6.36) R18(7.66,-6.36) R19(8.31,-6.36) R20(8.96,-6.36) R22(9.66,-6.44) T2(0.46,-6.9) T4(1.16,-7.01) T5(1.81,-7.01) T6(2.46,-7.01) T8(3.11,-7.01) T9(3.76,-7.01) T11(4.41,-7.01) T12(5.06,-7.01) T13(5.71,-7.01) T15(6.36,-7.01) T16(7.01,-7.01) T18(7.66,-7.01) T19(8.31,-7.01) T20(8.96,-7.01) T22(9.66,-6.9) U2(0.46,-7.36) U22(9.66,-7.36) V2(0.46,-7.82) V4(1.16,-7.66) V5(1.81,-7.66) V6(2.46,-7.66) V8(3.11,-7.66) V9(3.76,-7.66) V11(4.41,-7.66) V12(5.06,-7.66) V13(5.71,-7.66) V15(6.36,-7.66) V16(7.01,-7.66) V18(7.66,-7.66) V19(8.31,-7.66) V20(8.96,-7.66) V22(9.66,-7.82) W2(0.46,-8.28) W4(1.16,-8.31) W5(1.81,-8.31) W6(2.46,-8.31) W8(3.11,-8.31) W9(3.76,-8.31) W11(4.41,-8.31) W12(5.06,-8.31) W13(5.71,-8.31) W15(6.36,-8.31) W16(7.01,-8.31) W18(7.66,-8.31) W19(8.31,-8.31) W20(8.96,-8.31) W22(9.66,-8.28) Y2(0.46,-8.74) Y4(1.16,-8.96) Y5(1.81,-8.96) Y6(2.46,-8.96) Y8(3.11,-8.96) Y9(3.76,-8.96) Y11(4.41,-8.96) Y12(5.06,-8.96) Y13(5.71,-8.96) Y15(6.36,-8.96) Y16(7.01,-8.96) Y18(7.66,-8.96) Y19(8.31,-8.96) Y20(8.96,-8.96) Y22(9.66,-8.74)
  oval 0.178x0.33 smd: A2(0.46,0) A3(0.92,0) A4(1.38,0) A5(1.84,0) A6(2.3,0) A7(2.76,0) A8(3.22,0) A9(3.68,0) A10(4.14,0) A11(4.6,0) A12(5.06,0) A13(5.52,0) A14(5.98,0) A15(6.44,0) A16(6.9,0) A17(7.36,0) A18(7.82,0) A19(8.28,0) A20(8.74,0) A21(9.2,0) A22(9.66,0) AC2(0.46,-10.12) AC3(0.92,-10.12) AC4(1.38,-10.12) AC5(1.84,-10.12) AC6(2.3,-10.12) AC7(2.76,-10.12) AC8(3.22,-10.12) AC9(3.68,-10.12) AC10(4.14,-10.12) AC11(4.6,-10.12) AC12(5.06,-10.12) AC13(5.52,-10.12) AC14(5.98,-10.12) AC15(6.44,-10.12) AC16(6.9,-10.12) AC17(7.36,-10.12) AC18(7.82,-10.12) AC19(8.28,-10.12) AC20(8.74,-10.12) AC21(9.2,-10.12) AC22(9.66,-10.12)
  oval 0.33x0.178 smd: AA1(0,-9.2) AA23(10.12,-9.2) AB1(0,-9.66) AB23(10.12,-9.66) B1(0,-0.46) B23(10.12,-0.46) C1(0,-0.92) C23(10.12,-0.92) D1(0,-1.38) D23(10.12,-1.38) E1(0,-1.84) E23(10.12,-1.84) F1(0,-2.3) F23(10.12,-2.3) G1(0,-2.76) G23(10.12,-2.76) H1(0,-3.22) H23(10.12,-3.22) J1(0,-3.68) J23(10.12,-3.68) K1(0,-4.14) K23(10.12,-4.14) L1(0,-4.6) L23(10.12,-4.6) M1(0,-5.06) M23(10.12,-5.06) N1(0,-5.52) N23(10.12,-5.52) P1(0,-5.98) P23(10.12,-5.98) R1(0,-6.44) R23(10.12,-6.44) T1(0,-6.9) T23(10.12,-6.9) U1(0,-7.36) U23(10.12,-7.36) V1(0,-7.82) V23(10.12,-7.82) W1(0,-8.28) W23(10.12,-8.28) Y1(0,-8.74) Y23(10.12,-8.74)
AON6366E_DFN5X6-8-5
  oval 0.61x1.27 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0)
  custom 1.105x1.105 smd: 5(1.905,3.715)
AON6380_DFN5X6-8-5
  oval 0.508x0.66 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0)
  custom 1.15x1.15 smd: 5(1.905,2.755)
AON6796_DFN5X6-8-5
  oval 0.508x0.66 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0)
  custom 1.15x1.15 smd: 5(1.905,2.755)
AON6992_DFN5X6D-8-7
  oval 0.66x0.635 smd: 1(0,0) 3(3.81,5.67) 4(2.54,5.67) 5(1.27,5.67) 6(0,5.67)
  custom 0.485x0.485 smd: 2(1.905,0.655)
  rect 3.988x2.667 smd: 7(1.905,3.62)
AON7380_DFN3X3-8-5
  oval 0.406x0.991 smd: 1(0,0) 2(0.66,0) 3(1.32,0) 4(1.98,0)
  custom 0.559x0.559 smd: 5(0.99,2.247)
AON7408L_DFN8-5
  oval 0.406x0.991 smd: 1(0,0) 2(0.66,0) 3(1.32,0) 4(1.98,0)
  custom 0.559x0.559 smd: 5(0.99,2.247)
AON7506_DFN33-8-5
  oval 0.406x0.991 smd: 1(0,0) 2(0.66,0) 3(1.32,0) 4(1.98,0)
  custom 0.559x0.559 smd: 5(0.99,2.247)
AP2330W-7_SC59-3
  oval 0.787x0.991 smd: 1(0,0) 2(-0.95,-2.4) 3(0.95,-2.4)
APE8937GN2_DFN8_2X2
  oval 0.254x0.787 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(1.5,2.2) 6(1,2.2) 7(0.5,2.2) 8(0,2.2)
  rect 1.6x0.889 smd: 9(0.75,1.1)
AZ5123-02SPR7G_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
AZ5125-01HPR7G_SOD523-2
  rect 0.61x0.787 smd: 1(0,0) 2(1.5,0)
AZ5125-02SPR7G_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
AZC099-04SPR7G_SOT23-6
  oval 0.559x1.092 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.5) 5(0.95,2.5) 6(0,2.5)
AZC199-02SPR7G_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
BAT54A-7-F_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
BAT54C-7-F_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
BAT54CW-7-F_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
BAT54CW_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
BELLW_SD-80159-4221_67P-T
  round 1.092 hole 1.092 unplated: (-0.75,-5.275)
  round 1.6 hole 1.6 unplated: (19.25,-5.275)
  oval 0.305x1.549 smd: 1(0,0) 2(0.25,-7.55) 3(0.5,0) 4(0.75,-7.55) 5(1,0) 6(1.25,-7.55) 7(1.5,0) 8(1.75,-7.55) 9(2,0) 10(2.25,-7.55) 11(2.5,0) 12(2.75,-7.55) 13(3,0) 14(3.25,-7.55) 15(3.5,0) 16(3.75,-7.55) 17(4,0) 18(4.25,-7.55) 19(4.5,0) 20(4.75,-7.55) 21(5,0) 22(5.25,-7.55) 23(5.5,0) 24(5.75,-7.55) 25(6,0) 26(6.25,-7.55) 27(6.5,0) 28(6.75,-7.55) 29(7,0) 30(7.25,-7.55) 31(7.5,0) 32(7.75,-7.55) 33(8,0) 34(8.25,-7.55) 35(8.5,0) 36(8.75,-7.55) 37(9,0) 38(9.25,-7.55) 39(9.5,0) 40(9.75,-7.55) 41(10,0) 42(10.25,-7.55) 43(10.5,0) 44(10.75,-7.55) 45(11,0) 46(11.25,-7.55) 47(11.5,0) 48(11.75,-7.55) 49(12,0) 50(12.25,-7.55) 51(12.5,0) 52(12.75,-7.55) 53(13,0) 54(13.25,-7.55) 55(13.5,0) 56(13.75,-7.55) 57(14,0) 58(14.25,-7.55) 59(16.5,0) 60(16.75,-7.55) 61(17,0) 62(17.25,-7.55) 63(17.5,0) 64(17.75,-7.55) 65(18,0) 66(18.25,-7.55) 67(18.5,0)
  rect 1.194x2.743 smd: 68(-1.1,-0.775) 69(19.6,-0.775)
BQ24780RUYR_WQFN28_4X4-S
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 15(4.1,-2.4) 16(4.1,-2) 17(4.1,-1.6) 18(4.1,-1.2) 19(4.1,-0.8) 20(4.1,-0.4) 21(4.1,0)
  oval 0.203x0.889 smd: 8(0.85,-3.25) 9(1.25,-3.25) 10(1.65,-3.25) 11(2.05,-3.25) 12(2.45,-3.25) 13(2.85,-3.25) 14(3.25,-3.25) 22(3.25,0.85) 23(2.85,0.85) 24(2.45,0.85) 25(2.05,0.85) 26(1.65,0.85) 27(1.25,0.85) 28(0.85,0.85)
  rect 2.591x2.591 smd: 29(2.05,-1.2)
BSS138W-7-F_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
BSS138W_SOT323-3
  oval 0.66x0.864 smd: 1(0,0) 2(-0.65,-1.85) 3(0.65,-1.85)
C-K_80454-5K1-152_15P
  round 0.965 hole 0.711: 1(0,0) 2(2.29,0) 3(4.58,0) 4(6.87,0) 5(9.16,0) 6(-1.145,0) 7(1.145,0) 8(3.435,0) 9(5.725,0) 10(8.015,0) 11(0,1.4) 12(2.29,1.4) 13(4.58,1.4) 14(6.87,1.4) 15(9.16,1.4)
  oval 1.372x3.251 hole 0.61x2.489: 16(-5.47,-0.1) 17(14.63,-0.1)
C_0201
  rect 0.381x0.356 smd: 1(0,0) 2(0.584,0)
C_0402
  rect 0.508x0.584 smd: 1(0,0) 2(0.914,0)
C_0603
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
C_0805
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
C_1206
  rect 1.016x1.778 smd: 1(0,0) 2(2.667,0)
C_APXK2R5ARA331MF451
  oval 3.15x1.6 smd: 1(0,0) 2(-5.05,0)
C_APXK6R3ARA221MF451
  oval 3.15x1.6 smd: 1(0,0) 2(5.05,0)
C_D1
  rect 1.803x2.794 smd: 1(0,0) 2(6.5,0)
C_D2
  rect 2.388x2.794 smd: 1(0,0) 2(6.4,0)
C_D2E
  rect 2.388x2.896 smd: 1(0,0) 2(6.1,0)
C_D3
  rect 2.388x2.794 smd: 1(0,0) 2(6.4,0)
C_ECST250ADA101MF611
  oval 3.505x1.6 smd: 1(0,0) 2(-5.4,0)
C_EEFSS0D221R
  rect 2.388x2.794 smd: 1(0,0) 2(6.4,0)
CHILI_PBY160808T-300Y-N_2P
  rect 0.559x1.041 smd: 1(0,0) 2(1.3,0)
CONCR_099A3AC19JBLCNF_19P
  round 0.813 hole 0.559: 1(0,0) 2(0.5,1.55) 3(1,0) 4(1.5,1.55) 5(2,0) 6(2.5,1.55) 7(3,0) 8(3.5,1.55) 9(4,0) 10(4.5,1.55) 11(5,0) 12(5.5,1.55) 13(6,0) 14(6.5,1.55) 15(7,0) 16(7.5,1.55) 17(8,0) 18(8.5,1.55) 19(9,0)
  oval 1.6x3.099 hole 0.991x2.489: 20(-4.25,-8.2) 21(13.25,-8.2)
  oval 1.6x2.311 hole 0.991x1.702: 22(-2.75,0.15) 23(11.75,0.15)
CONCR_213EAAA32FA_67P
  round 1.092 hole 1.092 unplated: (-0.75,-5.275)
  round 1.6 hole 1.6 unplated: (19.25,-5.275)
  oval 0.305x1.549 smd: 1(0,0) 2(0.25,-7.55) 3(0.5,0) 4(0.75,-7.55) 5(1,0) 6(1.25,-7.55) 7(1.5,0) 8(1.75,-7.55) 9(2,0) 10(2.25,-7.55) 11(2.5,0) 12(2.75,-7.55) 13(3,0) 14(3.25,-7.55) 15(3.5,0) 16(3.75,-7.55) 17(4,0) 18(4.25,-7.55) 19(4.5,0) 20(4.75,-7.55) 21(5,0) 22(5.25,-7.55) 23(5.5,0) 24(7.75,-7.55) 25(8,0) 26(8.25,-7.55) 27(8.5,0) 28(8.75,-7.55) 29(9,0) 30(9.25,-7.55) 31(9.5,0) 32(9.75,-7.55) 33(10,0) 34(10.25,-7.55) 35(10.5,0) 36(10.75,-7.55) 37(11,0) 38(11.25,-7.55) 39(11.5,0) 40(11.75,-7.55) 41(12,0) 42(12.25,-7.55) 43(12.5,0) 44(12.75,-7.55) 45(13,0) 46(13.25,-7.55) 47(13.5,0) 48(13.75,-7.55) 49(14,0) 50(14.25,-7.55) 51(14.5,0) 52(14.75,-7.55) 53(15,0) 54(15.25,-7.55) 55(15.5,0) 56(15.75,-7.55) 57(16,0) 58(16.25,-7.55) 59(16.5,0) 60(16.75,-7.55) 61(17,0) 62(17.25,-7.55) 63(17.5,0) 64(17.75,-7.55) 65(18,0) 66(18.25,-7.55) 67(18.5,0)
  rect 1.194x2.743 smd: 68(-1.1,-0.775) 69(19.6,-0.775)
CYNTE_PCMB042T-1R0MS_2P
  rect 1.499x2.489 smd: 1(0,0) 2(3.7,0)
CYNTE_PCMB063T-1R0MS_2P
  rect 2.362x3.505 smd: 1(0,0) 2(6.05,0)
CYNTE_PCMC104T-R88MN_2P
  rect 4.089x4.089 smd: 1(0,0) 2(9.5,0)
CYNTE_PCME064T-R15MS0R667_2P
  rect 2.159x3.505 smd: 1(0,0) 2(5.85,0)
DEREN_40-42271-26001RHF_260P-T
  round 1.6 hole 1.6 unplated: (-1.025,4.1)
  round 1.092 hole 1.092 unplated: (67.775,4.1)
  oval 0.305x1.753 smd: 1(0,0) 2(0.25,8.2) 3(0.5,0) 4(0.75,8.2) 5(1,0) 6(1.25,8.2) 7(1.5,0) 8(1.75,8.2) 9(2,0) 10(2.25,8.2) 11(2.5,0) 12(2.75,8.2) 13(3,0) 14(3.25,8.2) 15(3.5,0) 16(3.75,8.2) 17(4,0) 18(4.25,8.2) 19(4.5,0) 20(4.75,8.2) 21(5,0) 22(5.25,8.2) 23(5.5,0) 24(5.75,8.2) 25(6,0) 26(6.25,8.2) 27(6.5,0) 28(6.75,8.2) 29(7,0) 30(7.25,8.2) 31(7.5,0) 32(7.75,8.2) 33(8,0) 34(8.25,8.2) 35(8.5,0) 36(8.75,8.2) 37(9,0) 38(9.25,8.2) 39(9.5,0) 40(9.75,8.2) 41(10,0) 42(10.25,8.2) 43(10.5,0) 44(10.75,8.2) 45(11,0) 46(11.25,8.2) 47(11.5,0) 48(11.75,8.2) 49(12,0) 50(12.25,8.2) 51(12.5,0) 52(12.75,8.2) 53(13,0) 54(13.25,8.2) 55(13.5,0) 56(13.75,8.2) 57(14,0) 58(14.25,8.2) 59(14.5,0) 60(14.75,8.2) 61(15,0) 62(15.25,8.2) 63(15.5,0) 64(15.75,8.2) 65(16,0) 66(16.25,8.2) 67(16.5,0) 68(16.75,8.2) 69(17,0) 70(17.25,8.2) 71(17.5,0) 72(17.75,8.2) 73(18,0) 74(18.25,8.2) 75(18.5,0) 76(18.75,8.2) 77(19,0) 78(19.25,8.2) 79(19.5,0) 80(19.75,8.2) 81(20,0) 82(20.25,8.2) 83(20.5,0) 84(20.75,8.2) 85(21,0) 86(21.25,8.2) 87(21.5,0) 88(21.75,8.2) 89(22,0) 90(22.25,8.2) 91(22.5,0) 92(22.75,8.2) 93(23,0) 94(23.25,8.2) 95(23.5,0) 96(23.75,8.2) 97(24,0) 98(24.25,8.2) 99(24.5,0) 100(24.75,8.2) 101(25,0) 102(25.25,8.2) 103(25.5,0) 104(25.75,8.2) 105(26,0) 106(26.25,8.2) 107(26.5,0) 108(26.75,8.2) 109(27,0) 110(27.25,8.2) 111(27.5,0) 112(27.75,8.2) 113(28,0) 114(28.25,8.2) 115(28.5,0) 116(28.75,8.2) 117(29,0) 118(29.25,8.2) 119(29.5,0) 120(29.75,8.2) 121(30,0) 122(30.25,8.2) 123(30.5,0) 124(30.75,8.2) 125(31,0) 126(31.25,8.2) 127(31.5,0) 128(31.75,8.2) 129(32,0) 130(32.25,8.2) 131(32.5,0) 132(32.75,8.2) 133(33,0) 134(33.25,8.2) 135(33.5,0) 136(33.75,8.2) 137(34,0) 138(34.25,8.2) 139(34.5,0) 140(34.75,8.2) 141(35,0) 142(35.25,8.2) 143(35.5,0) 144(35.75,8.2) 145(38,0) 146(38.25,8.2) 147(38.5,0) 148(38.75,8.2) 149(39,0) 150(39.25,8.2) 151(39.5,0) 152(39.75,8.2) 153(40,0) 154(40.25,8.2) 155(40.5,0) 156(40.75,8.2) 157(41,0) 158(41.25,8.2) 159(41.5,0) 160(41.75,8.2) 161(42,0) 162(42.25,8.2) 163(42.5,0) 164(42.75,8.2) 165(43,0) 166(43.25,8.2) 167(43.5,0) 168(43.75,8.2) 169(44,0) 170(44.25,8.2) 171(44.5,0) 172(44.75,8.2) 173(45,0) 174(45.25,8.2) 175(45.5,0) 176(45.75,8.2) 177(46,0) 178(46.25,8.2) 179(46.5,0) 180(46.75,8.2) 181(47,0) 182(47.25,8.2) 183(47.5,0) 184(47.75,8.2) 185(48,0) 186(48.25,8.2) 187(48.5,0) 188(48.75,8.2) 189(49,0) 190(49.25,8.2) 191(49.5,0) 192(49.75,8.2) 193(50,0) 194(50.25,8.2) 195(50.5,0) 196(50.75,8.2) 197(51,0) 198(51.25,8.2) 199(51.5,0) 200(51.75,8.2) 201(52,0) 202(52.25,8.2) 203(52.5,0) 204(52.75,8.2) 205(53,0) 206(53.25,8.2) 207(53.5,0) 208(53.75,8.2) 209(54,0) 210(54.25,8.2) 211(54.5,0) 212(54.75,8.2) 213(55,0) 214(55.25,8.2) 215(55.5,0) 216(55.75,8.2) 217(56,0) 218(56.25,8.2) 219(56.5,0) 220(56.75,8.2) 221(57,0) 222(57.25,8.2) 223(57.5,0) 224(57.75,8.2) 225(58,0) 226(58.25,8.2) 227(58.5,0) 228(58.75,8.2) 229(59,0) 230(59.25,8.2) 231(59.5,0) 232(59.75,8.2) 233(60,0) 234(60.25,8.2) 235(60.5,0) 236(60.75,8.2) 237(61,0) 238(61.25,8.2) 239(61.5,0) 240(61.75,8.2) 241(62,0) 242(62.25,8.2) 243(62.5,0) 244(62.75,8.2) 245(63,0) 246(63.25,8.2) 247(63.5,0) 248(63.75,8.2) 249(64,0) 250(64.25,8.2) 251(64.5,0) 252(64.75,8.2) 253(65,0) 254(65.25,8.2) 255(65.5,0) 256(65.75,8.2) 257(66,0) 258(66.25,8.2) 259(66.5,0) 260(66.75,8.2)
  rect 3.505x4.597 smd: 261(-0.425,-7.9) 262(67.175,-7.9)
DMG2301U-7_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
DMN65D8LDW-7_SOT363-6
  oval 0.432x0.61 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0.65,1.9) 6(0,1.9)
EM5209VF_DFN14_3X2
  oval 0.203x0.711 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.4,2) 9(2,2) 10(1.6,2) 11(1.2,2) 12(0.8,2) 13(0.4,2) 14(0,2)
  rect 2.591x0.991 smd: 15(1.2,1)
EMIST_SUL-12A2M_1P
  rect 6.909x1.194 smd: 1(0,0)
ESD8011MUT5G_X3DFN2-2
  rect 0.33x0.356 smd: 1(0,0) 2(0.43,0)
F75303M_MSOP10
  oval 0.254x1.626 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2,4.3) 7(1.5,4.3) 8(1,4.3) 9(0.5,4.3) 10(0,4.3)
F_NANOSMDC050F-13P2-2
  rect 0.991x1.6 smd: 1(0,0) 2(3,0)
F_SMD1812P110TF-24
  rect 1.778x3.15 smd: 1(0,0) 2(5.23,0)
F_SPR-P110
  rect 0.991x1.499 smd: 1(0,0) 2(2.2,0)
FDV301N_NL_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
FIDUCIAL_C40M80
  round 1.016 smd: 1(0,0)
G9090-180T11U_SOT23-5
  oval 0.533x1.194 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,3) 5(0,3)
H5GQ1H24AFR-T2L_BGA_170P
  round 0.343 smd: A1(0,0) A2(0.8,0) A3(1.6,0) A4(2.4,0) A5(3.2,0) A10(7.201,0) A11(8.001,0) A12(8.801,0) A13(9.601,0) A14(10.401,0) B1(0,-0.8) B2(0.8,-0.8) B3(1.6,-0.8) B4(2.4,-0.8) B5(3.2,-0.8) B10(7.201,-0.8) B11(8.001,-0.8) B12(8.801,-0.8) B13(9.601,-0.8) B14(10.401,-0.8) C1(0,-1.6) C2(0.8,-1.6) C3(1.6,-1.6) C4(2.4,-1.6) C5(3.2,-1.6) C10(7.201,-1.6) C11(8.001,-1.6) C12(8.801,-1.6) C13(9.601,-1.6) C14(10.401,-1.6) D1(0,-2.4) D2(0.8,-2.4) D3(1.6,-2.4) D4(2.4,-2.4) D5(3.2,-2.4) D10(7.201,-2.4) D11(8.001,-2.4) D12(8.801,-2.4) D13(9.601,-2.4) D14(10.401,-2.4) E1(0,-3.2) E2(0.8,-3.2) E3(1.6,-3.2) E4(2.4,-3.2) E5(3.2,-3.2) E10(7.201,-3.2) E11(8.001,-3.2) E12(8.801,-3.2) E13(9.601,-3.2) E14(10.401,-3.2) F1(0,-4) F2(0.8,-4) F3(1.6,-4) F4(2.4,-4) F5(3.2,-4) F10(7.201,-4) F11(8.001,-4) F12(8.801,-4) F13(9.601,-4) F14(10.401,-4) G1(0,-4.801) G2(0.8,-4.801) G3(1.6,-4.801) G4(2.4,-4.801) G5(3.2,-4.801) G10(7.201,-4.801) G11(8.001,-4.801) G12(8.801,-4.801) G13(9.601,-4.801) G14(10.401,-4.801) H1(0,-5.601) H2(0.8,-5.601) H3(1.6,-5.601) H4(2.4,-5.601) H5(3.2,-5.601) H10(7.201,-5.601) H11(8.001,-5.601) H12(8.801,-5.601) H13(9.601,-5.601) H14(10.401,-5.601) J1(0,-6.401) J2(0.8,-6.401) J3(1.6,-6.401) J4(2.4,-6.401) J5(3.2,-6.401) J10(7.201,-6.401) J11(8.001,-6.401) J12(8.801,-6.401) J13(9.601,-6.401) J14(10.401,-6.401) K1(0,-7.201) K2(0.8,-7.201) K3(1.6,-7.201) K4(2.4,-7.201) K5(3.2,-7.201) K10(7.201,-7.201) K11(8.001,-7.201) K12(8.801,-7.201) K13(9.601,-7.201) K14(10.401,-7.201) L1(0,-8.001) L2(0.8,-8.001) L3(1.6,-8.001) L4(2.4,-8.001) L5(3.2,-8.001) L10(7.201,-8.001) L11(8.001,-8.001) L12(8.801,-8.001) L13(9.601,-8.001) L14(10.401,-8.001) M1(0,-8.801) M2(0.8,-8.801) M3(1.6,-8.801) M4(2.4,-8.801) M5(3.2,-8.801) M10(7.201,-8.801) M11(8.001,-8.801) M12(8.801,-8.801) M13(9.601,-8.801) M14(10.401,-8.801) N1(0,-9.601) N2(0.8,-9.601) N3(1.6,-9.601) N4(2.4,-9.601) N5(3.2,-9.601) N10(7.201,-9.601) N11(8.001,-9.601) N12(8.801,-9.601) N13(9.601,-9.601) N14(10.401,-9.601) P1(0,-10.401) P2(0.8,-10.401) P3(1.6,-10.401) P4(2.4,-10.401) P5(3.2,-10.401) P10(7.201,-10.401) P11(8.001,-10.401) P12(8.801,-10.401) P13(9.601,-10.401) P14(10.401,-10.401) R1(0,-11.201) R2(0.8,-11.201) R3(1.6,-11.201) R4(2.4,-11.201) R5(3.2,-11.201) R10(7.201,-11.201) R11(8.001,-11.201) R12(8.801,-11.201) R13(9.601,-11.201) R14(10.401,-11.201) T1(0,-12.002) T2(0.8,-12.002) T3(1.6,-12.002) T4(2.4,-12.002) T5(3.2,-12.002) T10(7.201,-12.002) T11(8.001,-12.002) T12(8.801,-12.002) T13(9.601,-12.002) T14(10.401,-12.002) U1(0,-12.802) U2(0.8,-12.802) U3(1.6,-12.802) U4(2.4,-12.802) U5(3.2,-12.802) U10(7.201,-12.802) U11(8.001,-12.802) U12(8.801,-12.802) U13(9.601,-12.802) U14(10.401,-12.802)
H_2P8-G
  round 3.302 hole 2.794: 1(0,0)
H_2P8N
  round 2.794 hole 2.794 unplated: (0,0)
H_2P8X3P4-G
  oval 3.302x3.912 hole 2.794x3.404: 1(0,0)
H_2P8X3P4N
  oval 2.794x3.404 hole 2.794x3.404 unplated: (0,0)
H_3P0-G
  round 3.505 hole 2.997: 1(0,0)
H_3P3
  round 3.81 hole 3.302: 1(0,0)
H_3P7-G
  round 4.216 hole 3.708: 1(0,0)
H_4P0-G
  round 4.496 hole 3.988: 1(0,0)
H_4P5N
  round 4.496 hole 4.496 unplated: (0,0)
INA3221AIRGVR_VQFN16_4X4
  oval 0.457x1.041 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 9(1.95,3.95) 10(1.3,3.95) 11(0.65,3.95) 12(0,3.95)
  oval 1.041x0.457 smd: 5(2.95,1) 6(2.95,1.65) 7(2.95,2.3) 8(2.95,2.95) 13(-1,2.95) 14(-1,2.3) 15(-1,1.65) 16(-1,1)
  rect 2.108x2.108 smd: 17(0.975,1.975)
INPAQ_MCM1012B900F06BP_4P
  rect 0.711x0.305 smd: 1(0,0) 2(1.25,0) 3(1.25,-0.5) 4(0,-0.5)
ISL95855HRTZ-T_TQFN48_6X6-S
  oval 0.94x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 9(0,-3.2) 10(0,-3.6) 11(0,-4) 12(0,-4.4) 25(6.05,-4.4) 26(6.05,-4) 27(6.05,-3.6) 28(6.05,-3.2) 29(6.05,-2.8) 30(6.05,-2.4) 31(6.05,-2) 32(6.05,-1.6) 33(6.05,-1.2) 34(6.05,-0.8) 35(6.05,-0.4) 36(6.05,0)
  oval 0.203x0.94 smd: 13(0.825,-5.225) 14(1.225,-5.225) 15(1.625,-5.225) 16(2.025,-5.225) 17(2.425,-5.225) 18(2.825,-5.225) 19(3.225,-5.225) 20(3.625,-5.225) 21(4.025,-5.225) 22(4.425,-5.225) 23(4.825,-5.225) 24(5.225,-5.225) 37(5.225,0.825) 38(4.825,0.825) 39(4.425,0.825) 40(4.025,0.825) 41(3.625,0.825) 42(3.225,0.825) 43(2.825,0.825) 44(2.425,0.825) 45(2.025,0.825) 46(1.625,0.825) 47(1.225,0.825) 48(0.825,0.825)
  rect 4.394x4.394 smd: 49(3.025,-2.2)
JAE_DX07S024JJ7R1200_24P-T
  round 0.711 hole 0.711 unplated: (-0.975,-2.7)
  oval 0.838x0.711 hole 0.838x0.711 unplated: (6.225,-2.635)
  oval 1.194x2.108 hole 0.61x1.702: 1(-1.695,-0.7) 4(6.945,-0.7)
  oval 1.651x1.092 hole 1.245x0.711: 2(-1.37,-1.2) 5(6.62,-1.2)
  oval 1.295x2.489 hole 0.711x1.905: 3(-1.695,-5.75) 6(6.945,-5.75)
  oval 0.279x0.889 smd: A1(0,0) A2(0.5,0) A3(1,0) A4(1.5,0) A5(2,0) A6(2.5,0) A7(3,0) A8(3.5,0) A9(4,0) A10(4.5,0) A11(5,0) A12(5.5,0)
  oval 0.279x0.787 smd: B1(5.25,-1.6) B2(4.75,-1.6) B3(4.25,-1.6) B4(3.75,-1.6) B5(3.25,-1.6) B6(2.75,-1.6) B7(2.25,-1.6) B8(1.75,-1.6) B9(1.25,-1.6) B10(0.75,-1.6) B11(0.25,-1.6) B12(-0.25,-1.6)
JUMP_43X39
  custom 0.191x0.191 smd: 1(0,0) 2(0.914,0)
JUMP_43X79
  custom 0.188x0.188 smd: 1(0,0) 2(1.1,0)
JUMP_43X118
  custom 0.187x0.187 smd: 1(0,0) 2(1.1,0)
JXT_FP241AH-010GAAM_10P
  oval 0.305x1.092 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0)
  rect 0.406x0.787 smd: 11(-1,-2.65) 12(5.5,-2.65)
KC_FBMA-L11-322513151LMA50T_2P
  rect 0.991x2.997 smd: 1(0,0) 2(2.7,0)
KC_FBMA-L11-453215800LMA90T_2P
  rect 1.803x3.404 smd: 1(0,0) 2(3.8,0)
L2N7002WT1G_SC70-3
  oval 0.711x0.889 smd: 1(0,0) 2(0.65,1.9) 3(-0.65,1.9)
L2N7002WT1G_SC-70-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
L03ESDL5V0CC3-2_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
L30ESD24VC3-2_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
L_7X7X3_M_2P
  rect 2.362x3.505 smd: 1(0,0) 2(6.05,0)
L_7X7X4_M
  custom 0.591x0.591 smd: 1(0,0) 4(6.05,0)
  rect 0.762x0.508 smd: 2(0.8,0) 3(5.25,0)
LED_HT-F196BP5_2P
  rect 0.787x0.787 smd: 1(0,0) 2(1.5,0)
LN2306LT1G_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
LNG2DMTR_LGA12_2X2
  oval 0.406x0.305 smd: 1(0,0) 4(0,-1.5) 7(1.602,-1.5) 10(1.602,0)
  oval 0.508x0.305 smd: 2(0.051,-0.5) 3(0.051,-1) 8(1.551,-1) 9(1.551,-0.5)
  oval 0.305x0.508 smd: 5(0.551,-1.5) 6(1.051,-1.5) 11(1.051,0) 12(0.551,0)
LP2301ALT1G_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
LRB551V-30T1G_SOD323-2
  rect 0.635x0.838 smd: 1(0,0) 2(2.225,0)
MAG_MMD05CZR47M_4P
  custom 0.54x0.54 smd: 1(0,0) 4(4.35,0)
  rect 0.762x0.508 smd: 2(0.699,0) 3(3.652,0)
MAG_MMD-10DZ-4R7M-X2_2P
  rect 3.505x3.988 smd: 1(0,0) 2(9.5,0)
MAG_MND-04ABIR60M-XGL_2P
  rect 1.448x3.708 smd: 1(0,0) 2(2.845,0)
MC74VHC1G08DFT2G_SC70-5
  oval 0.381x0.711 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0,1.9)
MEC1404-NU-TR_VTQFP128_14X14
  oval 1.753x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 9(0,-3.2) 10(0,-3.6) 11(0,-4) 12(0,-4.4) 13(0,-4.8) 14(0,-5.2) 15(0,-5.6) 16(0,-6) 17(0,-6.4) 18(0,-6.8) 19(0,-7.2) 20(0,-7.6) 21(0,-8) 22(0,-8.4) 23(0,-8.8) 24(0,-9.2) 25(0,-9.6) 26(0,-10) 27(0,-10.4) 28(0,-10.8) 29(0,-11.2) 30(0,-11.6) 31(0,-12) 32(0,-12.4) 65(15.654,-12.4) 66(15.654,-12) 67(15.654,-11.6) 68(15.654,-11.2) 69(15.654,-10.8) 70(15.654,-10.4) 71(15.654,-10) 72(15.654,-9.6) 73(15.654,-9.2) 74(15.654,-8.8) 75(15.654,-8.4) 76(15.654,-8) 77(15.654,-7.6) 78(15.654,-7.2) 79(15.654,-6.8) 80(15.654,-6.4) 81(15.654,-6) 82(15.654,-5.6) 83(15.654,-5.2) 84(15.654,-4.8) 85(15.654,-4.4) 86(15.654,-4) 87(15.654,-3.6) 88(15.654,-3.2) 89(15.654,-2.8) 90(15.654,-2.4) 91(15.654,-2) 92(15.654,-1.6) 93(15.654,-1.2) 94(15.654,-0.8) 95(15.654,-0.4) 96(15.654,0)
  oval 0.203x1.753 smd: 33(1.627,-14.027) 34(2.027,-14.027) 35(2.427,-14.027) 36(2.827,-14.027) 37(3.227,-14.027) 38(3.627,-14.027) 39(4.027,-14.027) 40(4.427,-14.027) 41(4.827,-14.027) 42(5.227,-14.027) 43(5.627,-14.027) 44(6.027,-14.027) 45(6.427,-14.027) 46(6.827,-14.027) 47(7.227,-14.027) 48(7.627,-14.027) 49(8.027,-14.027) 50(8.427,-14.027) 51(8.827,-14.027) 52(9.227,-14.027) 53(9.627,-14.027) 54(10.027,-14.027) 55(10.427,-14.027) 56(10.827,-14.027) 57(11.227,-14.027) 58(11.627,-14.027) 59(12.027,-14.027) 60(12.427,-14.027) 61(12.827,-14.027) 62(13.227,-14.027) 63(13.627,-14.027) 64(14.027,-14.027) 97(14.027,1.627) 98(13.627,1.627) 99(13.227,1.627) 100(12.827,1.627) 101(12.427,1.627) 102(12.027,1.627) 103(11.627,1.627) 104(11.227,1.627) 105(10.827,1.627) 106(10.427,1.627) 107(10.027,1.627) 108(9.627,1.627) 109(9.227,1.627) 110(8.827,1.627) 111(8.427,1.627) 112(8.027,1.627) 113(7.627,1.627) 114(7.227,1.627) 115(6.827,1.627) 116(6.427,1.627) 117(6.027,1.627) 118(5.627,1.627) 119(5.227,1.627) 120(4.827,1.627) 121(4.427,1.627) 122(4.027,1.627) 123(3.627,1.627) 124(3.227,1.627) 125(2.827,1.627) 126(2.427,1.627) 127(2.027,1.627) 128(1.627,1.627)
MESS138W-G_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
MHPC_NS892407_24P
  oval 0.635x1.778 smd: 1(0,0) 2(0.99,0) 3(1.98,0) 4(2.97,0) 5(3.96,0) 6(4.95,0) 7(5.94,0) 8(6.93,0) 9(7.92,0) 10(8.91,0) 11(9.9,0) 12(10.89,0) 13(10.89,8.99) 14(9.9,8.99) 15(8.91,8.99) 16(7.92,8.99) 17(6.93,8.99) 18(5.94,8.99) 19(4.95,8.99) 20(3.96,8.99) 21(2.97,8.99) 22(1.98,8.99) 23(0.99,8.99) 24(0,8.99)
MMST3904-7-F_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(0.65,1.9) 3(-0.65,1.9)
MURAT_BLM15AX700SN1D_2P
  rect 0.457x0.508 smd: 1(0,0) 2(0.85,0)
MURAT_BLM15BD601SN1D_2P
  rect 0.508x0.762 smd: 1(0,0) 2(0.75,0)
MURAT_BLM15HG601SN1D_2P
  rect 0.508x0.762 smd: 1(0,0) 2(0.75,0)
MURAT_BLM15PX181SN1D_2P
  rect 0.508x0.762 smd: 1(0,0) 2(0.75,0)
MURAT_BLM15PX221SN1D_2P
  rect 0.457x0.508 smd: 1(0,0) 2(0.85,0)
MURAT_BLM15PX471SN1D_2P
  rect 0.508x0.762 smd: 1(0,0) 2(0.75,0)
N17E-G1_BGA_2152P
  round 0.381 smd: A2(0.7,0) A3(1.4,0) A4(2.1,0) A49(33.6,0) A50(34.3,0) A51(35,0) B1(0,-0.7) B2(0.7,-0.7) B3(1.4,-0.7) B50(34.3,-0.7) B51(35,-0.7) B52(35.7,-0.7) BJ1(0,-33.6) BJ52(35.7,-33.6) BK1(0,-34.3) BK2(0.7,-34.3) BK51(35,-34.3) BK52(35.7,-34.3) BL1(0,-35) BL2(0.7,-35) BL3(1.4,-35) BL50(34.3,-35) BL51(35,-35) BL52(35.7,-35) BM2(0.7,-35.7) BM3(1.4,-35.7) BM4(2.1,-35.7) BM49(33.6,-35.7) BM50(34.3,-35.7) BM51(35,-35.7) C1(0,-1.4) C2(0.7,-1.4) C51(35,-1.4) C52(35.7,-1.4) D1(0,-2.1) D52(35.7,-2.1)
  round 0.356 smd: A5(2.8,0) A6(3.5,0) A8(4.9,0) A9(5.6,0) A11(7,0) A12(7.7,0) A14(9.1,0) A15(9.8,0) A17(11.2,0) A18(11.9,0) A20(13.3,0) A21(14,0) A23(15.4,0) A24(16.1,0) A26(17.5,0) A27(18.2,0) A29(19.6,0) A30(20.3,0) A32(21.7,0) A33(22.4,0) A35(23.8,0) A36(24.5,0) A38(25.9,0) A39(26.6,0) A41(28,0) A42(28.7,0) A44(30.1,0) A45(30.8,0) A47(32.2,0) A48(32.9,0) AA1(0,-14) AA2(0.7,-14) AA3(1.4,-14) AA4(2.1,-14) AA5(2.8,-14) AA6(3.5,-14) AA7(4.2,-14) AA8(4.9,-14) AA9(5.6,-14) AA10(6.3,-14) AA11(7,-14) AA14(9.1,-14) AA15(9.8,-14) AA16(10.5,-14) AA17(11.2,-14) AA18(11.9,-14) AA19(12.6,-14) AA20(13.3,-14) AA21(14,-14) AA22(14.7,-14) AA23(15.4,-14) AA24(16.1,-14) AA25(16.8,-14) AA26(17.5,-14) AA27(18.2,-14) AA28(18.9,-14) AA29(19.6,-14) AA30(20.3,-14) AA31(21,-14) AA32(21.7,-14) AA33(22.4,-14) AA34(23.1,-14) AA35(23.8,-14) AA36(24.5,-14) AA37(25.2,-14) AA38(25.9,-14) AA39(26.6,-14) AA42(28.7,-14) AA43(29.4,-14) AA44(30.1,-14) AA45(30.8,-14) AA46(31.5,-14) AA47(32.2,-14) AA48(32.9,-14) AA49(33.6,-14) AA50(34.3,-14) AA51(35,-14) AA52(35.7,-14) AB2(0.7,-14.7) AB4(2.1,-14.7) AB6(3.5,-14.7) AB8(4.9,-14.7) AB10(6.3,-14.7) AB13(8.4,-14.7) AB14(9.1,-14.7) AB15(9.8,-14.7) AB16(10.5,-14.7) AB17(11.2,-14.7) AB18(11.9,-14.7) AB19(12.6,-14.7) AB20(13.3,-14.7) AB21(14,-14.7) AB22(14.7,-14.7) AB23(15.4,-14.7) AB24(16.1,-14.7) AB25(16.8,-14.7) AB26(17.5,-14.7) AB27(18.2,-14.7) AB28(18.9,-14.7) AB29(19.6,-14.7) AB30(20.3,-14.7) AB31(21,-14.7) AB32(21.7,-14.7) AB33(22.4,-14.7) AB34(23.1,-14.7) AB35(23.8,-14.7) AB36(24.5,-14.7) AB37(25.2,-14.7) AB38(25.9,-14.7) AB39(26.6,-14.7) AB40(27.3,-14.7) AB43(29.4,-14.7) AB45(30.8,-14.7) AB47(32.2,-14.7) AB49(33.6,-14.7) AB51(35,-14.7) AC1(0,-15.4) AC2(0.7,-15.4) AC3(1.4,-15.4) AC4(2.1,-15.4) AC5(2.8,-15.4) AC6(3.5,-15.4) AC7(4.2,-15.4) AC8(4.9,-15.4) AC9(5.6,-15.4) AC10(6.3,-15.4) AC11(7,-15.4) AC14(9.1,-15.4) AC15(9.8,-15.4) AC16(10.5,-15.4) AC17(11.2,-15.4) AC18(11.9,-15.4) AC19(12.6,-15.4) AC20(13.3,-15.4) AC21(14,-15.4) AC22(14.7,-15.4) AC23(15.4,-15.4) AC24(16.1,-15.4) AC25(16.8,-15.4) AC26(17.5,-15.4) AC27(18.2,-15.4) AC28(18.9,-15.4) AC29(19.6,-15.4) AC30(20.3,-15.4) AC31(21,-15.4) AC32(21.7,-15.4) AC33(22.4,-15.4) AC34(23.1,-15.4) AC35(23.8,-15.4) AC36(24.5,-15.4) AC37(25.2,-15.4) AC38(25.9,-15.4) AC39(26.6,-15.4) AC42(28.7,-15.4) AC43(29.4,-15.4) AC44(30.1,-15.4) AC45(30.8,-15.4) AC46(31.5,-15.4) AC47(32.2,-15.4) AC48(32.9,-15.4) AC49(33.6,-15.4) AC50(34.3,-15.4) AC51(35,-15.4) AC52(35.7,-15.4) AD1(0,-16.1) AD2(0.7,-16.1) AD3(1.4,-16.1) AD4(2.1,-16.1) AD5(2.8,-16.1) AD6(3.5,-16.1) AD7(4.2,-16.1) AD8(4.9,-16.1) AD9(5.6,-16.1) AD10(6.3,-16.1) AD11(7,-16.1) AD14(9.1,-16.1) AD15(9.8,-16.1) AD16(10.5,-16.1) AD17(11.2,-16.1) AD18(11.9,-16.1) AD19(12.6,-16.1) AD20(13.3,-16.1) AD21(14,-16.1) AD22(14.7,-16.1) AD23(15.4,-16.1) AD24(16.1,-16.1) AD25(16.8,-16.1) AD26(17.5,-16.1) AD27(18.2,-16.1) AD28(18.9,-16.1) AD29(19.6,-16.1) AD30(20.3,-16.1) AD31(21,-16.1) AD32(21.7,-16.1) AD33(22.4,-16.1) AD34(23.1,-16.1) AD35(23.8,-16.1) AD36(24.5,-16.1) AD37(25.2,-16.1) AD38(25.9,-16.1) AD39(26.6,-16.1) AD42(28.7,-16.1) AD43(29.4,-16.1) AD44(30.1,-16.1) AD45(30.8,-16.1) AD46(31.5,-16.1) AD47(32.2,-16.1) AD48(32.9,-16.1) AD49(33.6,-16.1) AD50(34.3,-16.1) AD51(35,-16.1) AD52(35.7,-16.1) AE2(0.7,-16.8) AE4(2.1,-16.8) AE6(3.5,-16.8) AE8(4.9,-16.8) AE10(6.3,-16.8) AE14(9.1,-16.8) AE15(9.8,-16.8) AE16(10.5,-16.8) AE17(11.2,-16.8) AE18(11.9,-16.8) AE19(12.6,-16.8) AE20(13.3,-16.8) AE21(14,-16.8) AE22(14.7,-16.8) AE23(15.4,-16.8) AE24(16.1,-16.8) AE25(16.8,-16.8) AE26(17.5,-16.8) AE27(18.2,-16.8) AE28(18.9,-16.8) AE29(19.6,-16.8) AE30(20.3,-16.8) AE31(21,-16.8) AE32(21.7,-16.8) AE33(22.4,-16.8) AE34(23.1,-16.8) AE35(23.8,-16.8) AE36(24.5,-16.8) AE37(25.2,-16.8) AE38(25.9,-16.8) AE39(26.6,-16.8) AE43(29.4,-16.8) AE45(30.8,-16.8) AE47(32.2,-16.8) AE49(33.6,-16.8) AE51(35,-16.8) AF1(0,-17.5) AF2(0.7,-17.5) AF3(1.4,-17.5) AF4(2.1,-17.5) AF5(2.8,-17.5) AF6(3.5,-17.5) AF7(4.2,-17.5) AF8(4.9,-17.5) AF9(5.6,-17.5) AF10(6.3,-17.5) AF11(7,-17.5) AF13(8.4,-17.5) AF14(9.1,-17.5) AF15(9.8,-17.5) AF16(10.5,-17.5) AF17(11.2,-17.5) AF18(11.9,-17.5) AF19(12.6,-17.5) AF20(13.3,-17.5) AF21(14,-17.5) AF22(14.7,-17.5) AF23(15.4,-17.5) AF24(16.1,-17.5) AF25(16.8,-17.5) AF26(17.5,-17.5) AF27(18.2,-17.5) AF28(18.9,-17.5) AF29(19.6,-17.5) AF30(20.3,-17.5) AF31(21,-17.5) AF32(21.7,-17.5) AF33(22.4,-17.5) AF34(23.1,-17.5) AF35(23.8,-17.5) AF36(24.5,-17.5) AF37(25.2,-17.5) AF38(25.9,-17.5) AF39(26.6,-17.5) AF40(27.3,-17.5) AF42(28.7,-17.5) AF43(29.4,-17.5) AF44(30.1,-17.5) AF45(30.8,-17.5) AF46(31.5,-17.5) AF47(32.2,-17.5) AF48(32.9,-17.5) AF49(33.6,-17.5) AF50(34.3,-17.5) AF51(35,-17.5) AF52(35.7,-17.5) AG1(0,-18.2) AG2(0.7,-18.2) AG3(1.4,-18.2) AG4(2.1,-18.2) AG5(2.8,-18.2) AG6(3.5,-18.2) AG7(4.2,-18.2) AG8(4.9,-18.2) AG9(5.6,-18.2) AG10(6.3,-18.2) AG11(7,-18.2) AG13(8.4,-18.2) AG14(9.1,-18.2) AG15(9.8,-18.2) AG16(10.5,-18.2) AG17(11.2,-18.2) AG18(11.9,-18.2) AG19(12.6,-18.2) AG20(13.3,-18.2) AG21(14,-18.2) AG22(14.7,-18.2) AG23(15.4,-18.2) AG24(16.1,-18.2) AG25(16.8,-18.2) AG26(17.5,-18.2) AG27(18.2,-18.2) AG28(18.9,-18.2) AG29(19.6,-18.2) AG30(20.3,-18.2) AG31(21,-18.2) AG32(21.7,-18.2) AG33(22.4,-18.2) AG34(23.1,-18.2) AG35(23.8,-18.2) AG36(24.5,-18.2) AG37(25.2,-18.2) AG38(25.9,-18.2) AG39(26.6,-18.2) AG40(27.3,-18.2) AG42(28.7,-18.2) AG43(29.4,-18.2) AG44(30.1,-18.2) AG45(30.8,-18.2) AG46(31.5,-18.2) AG47(32.2,-18.2) AG48(32.9,-18.2) AG49(33.6,-18.2) AG50(34.3,-18.2) AG51(35,-18.2) AG52(35.7,-18.2) AH2(0.7,-18.9) AH4(2.1,-18.9) AH6(3.5,-18.9) AH8(4.9,-18.9) AH10(6.3,-18.9) AH14(9.1,-18.9) AH15(9.8,-18.9) AH16(10.5,-18.9) AH17(11.2,-18.9) AH18(11.9,-18.9) AH19(12.6,-18.9) AH20(13.3,-18.9) AH21(14,-18.9) AH22(14.7,-18.9) AH23(15.4,-18.9) AH24(16.1,-18.9) AH25(16.8,-18.9) AH26(17.5,-18.9) AH27(18.2,-18.9) AH28(18.9,-18.9) AH29(19.6,-18.9) AH30(20.3,-18.9) AH31(21,-18.9) AH32(21.7,-18.9) AH33(22.4,-18.9) AH34(23.1,-18.9) AH35(23.8,-18.9) AH36(24.5,-18.9) AH37(25.2,-18.9) AH38(25.9,-18.9) AH39(26.6,-18.9) AH43(29.4,-18.9) AH45(30.8,-18.9) AH47(32.2,-18.9) AH49(33.6,-18.9) AH51(35,-18.9) AJ1(0,-19.6) AJ2(0.7,-19.6) AJ3(1.4,-19.6) AJ4(2.1,-19.6) AJ5(2.8,-19.6) AJ6(3.5,-19.6) AJ7(4.2,-19.6) AJ8(4.9,-19.6) AJ9(5.6,-19.6) AJ10(6.3,-19.6) AJ11(7,-19.6) AJ14(9.1,-19.6) AJ15(9.8,-19.6) AJ16(10.5,-19.6) AJ17(11.2,-19.6) AJ18(11.9,-19.6) AJ19(12.6,-19.6) AJ20(13.3,-19.6) AJ21(14,-19.6) AJ22(14.7,-19.6) AJ23(15.4,-19.6) AJ24(16.1,-19.6) AJ25(16.8,-19.6) AJ26(17.5,-19.6) AJ27(18.2,-19.6) AJ28(18.9,-19.6) AJ29(19.6,-19.6) AJ30(20.3,-19.6) AJ31(21,-19.6) AJ32(21.7,-19.6) AJ33(22.4,-19.6) AJ34(23.1,-19.6) AJ35(23.8,-19.6) AJ36(24.5,-19.6) AJ37(25.2,-19.6) AJ38(25.9,-19.6) AJ39(26.6,-19.6) AJ42(28.7,-19.6) AJ43(29.4,-19.6) AJ44(30.1,-19.6) AJ45(30.8,-19.6) AJ46(31.5,-19.6) AJ47(32.2,-19.6) AJ48(32.9,-19.6) AJ49(33.6,-19.6) AJ50(34.3,-19.6) AJ51(35,-19.6) AJ52(35.7,-19.6) AK1(0,-20.3) AK2(0.7,-20.3) AK3(1.4,-20.3) AK4(2.1,-20.3) AK5(2.8,-20.3) AK6(3.5,-20.3) AK7(4.2,-20.3) AK8(4.9,-20.3) AK9(5.6,-20.3) AK10(6.3,-20.3) AK11(7,-20.3) AK14(9.1,-20.3) AK15(9.8,-20.3) AK16(10.5,-20.3) AK17(11.2,-20.3) AK18(11.9,-20.3) AK19(12.6,-20.3) AK20(13.3,-20.3) AK21(14,-20.3) AK22(14.7,-20.3) AK23(15.4,-20.3) AK24(16.1,-20.3) AK25(16.8,-20.3) AK26(17.5,-20.3) AK27(18.2,-20.3) AK28(18.9,-20.3) AK29(19.6,-20.3) AK30(20.3,-20.3) AK31(21,-20.3) AK32(21.7,-20.3) AK33(22.4,-20.3) AK34(23.1,-20.3) AK35(23.8,-20.3) AK36(24.5,-20.3) AK37(25.2,-20.3) AK38(25.9,-20.3) AK39(26.6,-20.3) AK42(28.7,-20.3) AK43(29.4,-20.3) AK44(30.1,-20.3) AK45(30.8,-20.3) AK46(31.5,-20.3) AK47(32.2,-20.3) AK48(32.9,-20.3) AK49(33.6,-20.3) AK50(34.3,-20.3) AK51(35,-20.3) AK52(35.7,-20.3) AL2(0.7,-21) AL4(2.1,-21) AL6(3.5,-21) AL8(4.9,-21) AL10(6.3,-21) AL13(8.4,-21) AL14(9.1,-21) AL15(9.8,-21) AL16(10.5,-21) AL17(11.2,-21) AL18(11.9,-21) AL19(12.6,-21) AL20(13.3,-21) AL21(14,-21) AL22(14.7,-21) AL23(15.4,-21) AL24(16.1,-21) AL25(16.8,-21) AL26(17.5,-21) AL27(18.2,-21) AL28(18.9,-21) AL29(19.6,-21) AL30(20.3,-21) AL31(21,-21) AL32(21.7,-21) AL33(22.4,-21) AL34(23.1,-21) AL35(23.8,-21) AL36(24.5,-21) AL37(25.2,-21) AL38(25.9,-21) AL39(26.6,-21) AL40(27.3,-21) AL43(29.4,-21) AL45(30.8,-21) AL47(32.2,-21) AL49(33.6,-21) AL51(35,-21) AM1(0,-21.7) AM2(0.7,-21.7) AM3(1.4,-21.7) AM4(2.1,-21.7) AM5(2.8,-21.7) AM6(3.5,-21.7) AM7(4.2,-21.7) AM8(4.9,-21.7) AM9(5.6,-21.7) AM10(6.3,-21.7) AM11(7,-21.7) AM14(9.1,-21.7) AM15(9.8,-21.7) AM16(10.5,-21.7) AM17(11.2,-21.7) AM18(11.9,-21.7) AM19(12.6,-21.7) AM20(13.3,-21.7) AM21(14,-21.7) AM22(14.7,-21.7) AM23(15.4,-21.7) AM24(16.1,-21.7) AM25(16.8,-21.7) AM26(17.5,-21.7) AM27(18.2,-21.7) AM28(18.9,-21.7) AM29(19.6,-21.7) AM30(20.3,-21.7) AM31(21,-21.7) AM32(21.7,-21.7) AM33(22.4,-21.7) AM34(23.1,-21.7) AM35(23.8,-21.7) AM36(24.5,-21.7) AM37(25.2,-21.7) AM38(25.9,-21.7) AM39(26.6,-21.7) AM42(28.7,-21.7) AM43(29.4,-21.7) AM44(30.1,-21.7) AM45(30.8,-21.7) AM46(31.5,-21.7) AM47(32.2,-21.7) AM48(32.9,-21.7) AM49(33.6,-21.7) AM50(34.3,-21.7) AM51(35,-21.7) AM52(35.7,-21.7) AN1(0,-22.4) AN2(0.7,-22.4) AN3(1.4,-22.4) AN4(2.1,-22.4) AN5(2.8,-22.4) AN6(3.5,-22.4) AN7(4.2,-22.4) AN8(4.9,-22.4) AN9(5.6,-22.4) AN10(6.3,-22.4) AN11(7,-22.4) AN14(9.1,-22.4) AN15(9.8,-22.4) AN16(10.5,-22.4) AN17(11.2,-22.4) AN18(11.9,-22.4) AN19(12.6,-22.4) AN20(13.3,-22.4) AN21(14,-22.4) AN22(14.7,-22.4) AN23(15.4,-22.4) AN24(16.1,-22.4) AN25(16.8,-22.4) AN26(17.5,-22.4) AN27(18.2,-22.4) AN28(18.9,-22.4) AN29(19.6,-22.4) AN30(20.3,-22.4) AN31(21,-22.4) AN32(21.7,-22.4) AN33(22.4,-22.4) AN34(23.1,-22.4) AN35(23.8,-22.4) AN36(24.5,-22.4) AN37(25.2,-22.4) AN38(25.9,-22.4) AN39(26.6,-22.4) AN42(28.7,-22.4) AN43(29.4,-22.4) AN44(30.1,-22.4) AN45(30.8,-22.4) AN46(31.5,-22.4) AN47(32.2,-22.4) AN48(32.9,-22.4) AN49(33.6,-22.4) AN50(34.3,-22.4) AN51(35,-22.4) AN52(35.7,-22.4) AP2(0.7,-23.1) AP4(2.1,-23.1) AP6(3.5,-23.1) AP8(4.9,-23.1) AP10(6.3,-23.1) AP14(9.1,-23.1) AP15(9.8,-23.1) AP16(10.5,-23.1) AP17(11.2,-23.1) AP18(11.9,-23.1) AP19(12.6,-23.1) AP20(13.3,-23.1) AP21(14,-23.1) AP22(14.7,-23.1) AP23(15.4,-23.1) AP24(16.1,-23.1) AP25(16.8,-23.1) AP26(17.5,-23.1) AP27(18.2,-23.1) AP28(18.9,-23.1) AP29(19.6,-23.1) AP30(20.3,-23.1) AP31(21,-23.1) AP32(21.7,-23.1) AP33(22.4,-23.1) AP34(23.1,-23.1) AP35(23.8,-23.1) AP36(24.5,-23.1) AP37(25.2,-23.1) AP38(25.9,-23.1) AP39(26.6,-23.1) AP43(29.4,-23.1) AP45(30.8,-23.1) AP47(32.2,-23.1) AP49(33.6,-23.1) AP51(35,-23.1) AR1(0,-23.8) AR2(0.7,-23.8) AR3(1.4,-23.8) AR4(2.1,-23.8) AR5(2.8,-23.8) AR6(3.5,-23.8) AR7(4.2,-23.8) AR8(4.9,-23.8) AR9(5.6,-23.8) AR10(6.3,-23.8) AR11(7,-23.8) AR13(8.4,-23.8) AR14(9.1,-23.8) AR15(9.8,-23.8) AR16(10.5,-23.8) AR17(11.2,-23.8) AR18(11.9,-23.8) AR19(12.6,-23.8) AR20(13.3,-23.8) AR21(14,-23.8) AR22(14.7,-23.8) AR23(15.4,-23.8) AR24(16.1,-23.8) AR25(16.8,-23.8) AR26(17.5,-23.8) AR27(18.2,-23.8) AR28(18.9,-23.8) AR29(19.6,-23.8) AR30(20.3,-23.8) AR31(21,-23.8) AR32(21.7,-23.8) AR33(22.4,-23.8) AR34(23.1,-23.8) AR35(23.8,-23.8) AR36(24.5,-23.8) AR37(25.2,-23.8) AR38(25.9,-23.8) AR39(26.6,-23.8) AR40(27.3,-23.8) AR42(28.7,-23.8) AR43(29.4,-23.8) AR44(30.1,-23.8) AR45(30.8,-23.8) AR46(31.5,-23.8) AR47(32.2,-23.8) AR48(32.9,-23.8) AR49(33.6,-23.8) AR50(34.3,-23.8) AR51(35,-23.8) AR52(35.7,-23.8) AT1(0,-24.5) AT2(0.7,-24.5) AT3(1.4,-24.5) AT4(2.1,-24.5) AT5(2.8,-24.5) AT6(3.5,-24.5) AT7(4.2,-24.5) AT8(4.9,-24.5) AT9(5.6,-24.5) AT10(6.3,-24.5) AT11(7,-24.5) AT14(9.1,-24.5) AT15(9.8,-24.5) AT16(10.5,-24.5) AT17(11.2,-24.5) AT18(11.9,-24.5) AT19(12.6,-24.5) AT20(13.3,-24.5) AT21(14,-24.5) AT22(14.7,-24.5) AT23(15.4,-24.5) AT24(16.1,-24.5) AT25(16.8,-24.5) AT26(17.5,-24.5) AT27(18.2,-24.5) AT28(18.9,-24.5) AT29(19.6,-24.5) AT30(20.3,-24.5) AT31(21,-24.5) AT32(21.7,-24.5) AT33(22.4,-24.5) AT34(23.1,-24.5) AT35(23.8,-24.5) AT36(24.5,-24.5) AT37(25.2,-24.5) AT38(25.9,-24.5) AT39(26.6,-24.5) AT42(28.7,-24.5) AT43(29.4,-24.5) AT44(30.1,-24.5) AT45(30.8,-24.5) AT46(31.5,-24.5) AT47(32.2,-24.5) AT48(32.9,-24.5) AT49(33.6,-24.5) AT50(34.3,-24.5) AT51(35,-24.5) AT52(35.7,-24.5) AU2(0.7,-25.2) AU4(2.1,-25.2) AU6(3.5,-25.2) AU8(4.9,-25.2) AU10(6.3,-25.2) AU14(9.1,-25.2) AU15(9.8,-25.2) AU16(10.5,-25.2) AU17(11.2,-25.2) AU18(11.9,-25.2) AU19(12.6,-25.2) AU20(13.3,-25.2) AU21(14,-25.2) AU22(14.7,-25.2) AU23(15.4,-25.2) AU24(16.1,-25.2) AU25(16.8,-25.2) AU26(17.5,-25.2) AU27(18.2,-25.2) AU28(18.9,-25.2) AU29(19.6,-25.2) AU30(20.3,-25.2) AU31(21,-25.2) AU32(21.7,-25.2) AU33(22.4,-25.2) AU34(23.1,-25.2) AU35(23.8,-25.2) AU36(24.5,-25.2) AU37(25.2,-25.2) AU38(25.9,-25.2) AU39(26.6,-25.2) AU43(29.4,-25.2) AU45(30.8,-25.2) AU47(32.2,-25.2) AU49(33.6,-25.2) AU51(35,-25.2) AV1(0,-25.9) AV2(0.7,-25.9) AV3(1.4,-25.9) AV4(2.1,-25.9) AV5(2.8,-25.9) AV6(3.5,-25.9) AV7(4.2,-25.9) AV8(4.9,-25.9) AV9(5.6,-25.9) AV10(6.3,-25.9) AV11(7,-25.9) AV14(9.1,-25.9) AV15(9.8,-25.9) AV16(10.5,-25.9) AV17(11.2,-25.9) AV18(11.9,-25.9) AV19(12.6,-25.9) AV20(13.3,-25.9) AV21(14,-25.9) AV22(14.7,-25.9) AV23(15.4,-25.9) AV24(16.1,-25.9) AV25(16.8,-25.9) AV26(17.5,-25.9) AV27(18.2,-25.9) AV28(18.9,-25.9) AV29(19.6,-25.9) AV30(20.3,-25.9) AV31(21,-25.9) AV32(21.7,-25.9) AV33(22.4,-25.9) AV34(23.1,-25.9) AV35(23.8,-25.9) AV36(24.5,-25.9) AV37(25.2,-25.9) AV38(25.9,-25.9) AV39(26.6,-25.9) AV42(28.7,-25.9) AV43(29.4,-25.9) AV44(30.1,-25.9) AV45(30.8,-25.9) AV46(31.5,-25.9) AV47(32.2,-25.9) AV48(32.9,-25.9) AV49(33.6,-25.9) AV50(34.3,-25.9) AV51(35,-25.9) AV52(35.7,-25.9) AW1(0,-26.6) AW2(0.7,-26.6) AW3(1.4,-26.6) AW4(2.1,-26.6) AW5(2.8,-26.6) AW6(3.5,-26.6) AW7(4.2,-26.6) AW8(4.9,-26.6) AW9(5.6,-26.6) AW10(6.3,-26.6) AW11(7,-26.6) AW13(8.4,-26.6) AW14(9.1,-26.6) AW15(9.8,-26.6) AW16(10.5,-26.6) AW17(11.2,-26.6) AW18(11.9,-26.6) AW19(12.6,-26.6) AW20(13.3,-26.6) AW21(14,-26.6) AW22(14.7,-26.6) AW23(15.4,-26.6) AW24(16.1,-26.6) AW25(16.8,-26.6) AW26(17.5,-26.6) AW27(18.2,-26.6) AW28(18.9,-26.6) AW29(19.6,-26.6) AW30(20.3,-26.6) AW31(21,-26.6) AW32(21.7,-26.6) AW33(22.4,-26.6) AW34(23.1,-26.6) AW35(23.8,-26.6) AW36(24.5,-26.6) AW37(25.2,-26.6) AW38(25.9,-26.6) AW39(26.6,-26.6) AW40(27.3,-26.6) AW42(28.7,-26.6) AW43(29.4,-26.6) AW44(30.1,-26.6) AW45(30.8,-26.6) AW46(31.5,-26.6) AW47(32.2,-26.6) AW48(32.9,-26.6) AW49(33.6,-26.6) AW50(34.3,-26.6) AW51(35,-26.6) AW52(35.7,-26.6) AY2(0.7,-27.3) AY4(2.1,-27.3) AY6(3.5,-27.3) AY8(4.9,-27.3) AY10(6.3,-27.3) AY14(9.1,-27.3) AY18(11.9,-27.3) AY22(14.7,-27.3) AY26(17.5,-27.3) AY27(18.2,-27.3) AY31(21,-27.3) AY35(23.8,-27.3) AY39(26.6,-27.3) AY43(29.4,-27.3) AY45(30.8,-27.3) AY47(32.2,-27.3) AY49(33.6,-27.3) AY51(35,-27.3) B4(2.1,-0.7) B5(2.8,-0.7) B6(3.5,-0.7) B7(4.2,-0.7) B8(4.9,-0.7) B9(5.6,-0.7) B10(6.3,-0.7) B11(7,-0.7) B12(7.7,-0.7) B13(8.4,-0.7) B14(9.1,-0.7) B15(9.8,-0.7) B16(10.5,-0.7) B17(11.2,-0.7) B18(11.9,-0.7) B19(12.6,-0.7) B20(13.3,-0.7) B21(14,-0.7) B22(14.7,-0.7) B23(15.4,-0.7) B24(16.1,-0.7) B25(16.8,-0.7) B26(17.5,-0.7) B27(18.2,-0.7) B28(18.9,-0.7) B29(19.6,-0.7) B30(20.3,-0.7) B31(21,-0.7) B32(21.7,-0.7) B33(22.4,-0.7) B34(23.1,-0.7) B35(23.8,-0.7) B36(24.5,-0.7) B37(25.2,-0.7) B38(25.9,-0.7) B39(26.6,-0.7) B40(27.3,-0.7) B41(28,-0.7) B42(28.7,-0.7) B43(29.4,-0.7) B44(30.1,-0.7) B45(30.8,-0.7) B46(31.5,-0.7) B47(32.2,-0.7) B48(32.9,-0.7) B49(33.6,-0.7) BA1(0,-28) BA2(0.7,-28) BA3(1.4,-28) BA4(2.1,-28) BA5(2.8,-28) BA6(3.5,-28) BA7(4.2,-28) BA8(4.9,-28) BA9(5.6,-28) BA10(6.3,-28) BA43(29.4,-28) BA44(30.1,-28) BA45(30.8,-28) BA46(31.5,-28) BA47(32.2,-28) BA48(32.9,-28) BA49(33.6,-28) BA50(34.3,-28) BA51(35,-28) BA52(35.7,-28) BB1(0,-28.7) BB2(0.7,-28.7) BB3(1.4,-28.7) BB4(2.1,-28.7) BB5(2.8,-28.7) BB6(3.5,-28.7) BB7(4.2,-28.7) BB8(4.9,-28.7) BB14(9.1,-28.7) BB15(9.8,-28.7) BB17(11.2,-28.7) BB18(11.9,-28.7) BB20(13.3,-28.7) BB21(14,-28.7) BB23(15.4,-28.7) BB24(16.1,-28.7) BB26(17.5,-28.7) BB27(18.2,-28.7) BB29(19.6,-28.7) BB30(20.3,-28.7) BB32(21.7,-28.7) BB33(22.4,-28.7) BB35(23.8,-28.7) BB36(24.5,-28.7) BB38(25.9,-28.7) BB39(26.6,-28.7) BB45(30.8,-28.7) BB46(31.5,-28.7) BB47(32.2,-28.7) BB48(32.9,-28.7) BB49(33.6,-28.7) BB50(34.3,-28.7) BB51(35,-28.7) BB52(35.7,-28.7) BC2(0.7,-29.4) BC4(2.1,-29.4) BC6(3.5,-29.4) BC8(4.9,-29.4) BC12(7.7,-29.4) BC13(8.4,-29.4) BC14(9.1,-29.4) BC15(9.8,-29.4) BC16(10.5,-29.4) BC17(11.2,-29.4) BC18(11.9,-29.4) BC19(12.6,-29.4) BC20(13.3,-29.4) BC21(14,-29.4) BC22(14.7,-29.4) BC23(15.4,-29.4) BC24(16.1,-29.4) BC25(16.8,-29.4) BC26(17.5,-29.4) BC27(18.2,-29.4) BC28(18.9,-29.4) BC29(19.6,-29.4) BC30(20.3,-29.4) BC31(21,-29.4) BC32(21.7,-29.4) BC33(22.4,-29.4) BC34(23.1,-29.4) BC35(23.8,-29.4) BC36(24.5,-29.4) BC37(25.2,-29.4) BC38(25.9,-29.4) BC39(26.6,-29.4) BC40(27.3,-29.4) BC41(28,-29.4) BC45(30.8,-29.4) BC47(32.2,-29.4) BC49(33.6,-29.4) BC51(35,-29.4) BD1(0,-30.1) BD2(0.7,-30.1) BD3(1.4,-30.1) BD4(2.1,-30.1) BD5(2.8,-30.1) BD6(3.5,-30.1) BD7(4.2,-30.1) BD12(7.7,-30.1) BD14(9.1,-30.1) BD15(9.8,-30.1) BD17(11.2,-30.1) BD18(11.9,-30.1) BD20(13.3,-30.1) BD21(14,-30.1) BD23(15.4,-30.1) BD24(16.1,-30.1) BD26(17.5,-30.1) BD27(18.2,-30.1) BD29(19.6,-30.1) BD30(20.3,-30.1) BD32(21.7,-30.1) BD33(22.4,-30.1) BD35(23.8,-30.1) BD36(24.5,-30.1) BD38(25.9,-30.1) BD39(26.6,-30.1) BD41(28,-30.1) BD46(31.5,-30.1) BD47(32.2,-30.1) BD48(32.9,-30.1) BD49(33.6,-30.1) BD50(34.3,-30.1) BD51(35,-30.1) BD52(35.7,-30.1) BE1(0,-30.8) BE2(0.7,-30.8) BE3(1.4,-30.8) BE4(2.1,-30.8) BE5(2.8,-30.8) BE6(3.5,-30.8) BE7(4.2,-30.8) BE10(6.3,-30.8) BE11(7,-30.8) BE12(7.7,-30.8) BE13(8.4,-30.8) BE14(9.1,-30.8) BE15(9.8,-30.8) BE16(10.5,-30.8) BE17(11.2,-30.8) BE18(11.9,-30.8) BE19(12.6,-30.8) BE20(13.3,-30.8) BE21(14,-30.8) BE22(14.7,-30.8) BE23(15.4,-30.8) BE24(16.1,-30.8) BE25(16.8,-30.8) BE26(17.5,-30.8) BE27(18.2,-30.8) BE28(18.9,-30.8) BE29(19.6,-30.8) BE30(20.3,-30.8) BE31(21,-30.8) BE32(21.7,-30.8) BE33(22.4,-30.8) BE34(23.1,-30.8) BE35(23.8,-30.8) BE36(24.5,-30.8) BE37(25.2,-30.8) BE38(25.9,-30.8) BE39(26.6,-30.8) BE40(27.3,-30.8) BE41(28,-30.8) BE42(28.7,-30.8) BE43(29.4,-30.8) BE46(31.5,-30.8) BE47(32.2,-30.8) BE48(32.9,-30.8) BE49(33.6,-30.8) BE50(34.3,-30.8) BE51(35,-30.8) BE52(35.7,-30.8) BF2(0.7,-31.5) BF4(2.1,-31.5) BF6(3.5,-31.5) BF8(4.9,-31.5) BF9(5.6,-31.5) BF11(7,-31.5) BF12(7.7,-31.5) BF14(9.1,-31.5) BF15(9.8,-31.5) BF17(11.2,-31.5) BF18(11.9,-31.5) BF20(13.3,-31.5) BF21(14,-31.5) BF23(15.4,-31.5) BF24(16.1,-31.5) BF26(17.5,-31.5) BF27(18.2,-31.5) BF29(19.6,-31.5) BF30(20.3,-31.5) BF32(21.7,-31.5) BF33(22.4,-31.5) BF35(23.8,-31.5) BF36(24.5,-31.5) BF38(25.9,-31.5) BF39(26.6,-31.5) BF41(28,-31.5) BF42(28.7,-31.5) BF44(30.1,-31.5) BF45(30.8,-31.5) BF47(32.2,-31.5) BF49(33.6,-31.5) BF51(35,-31.5) BG1(0,-32.2) BG2(0.7,-32.2) BG3(1.4,-32.2) BG4(2.1,-32.2) BG5(2.8,-32.2) BG6(3.5,-32.2) BG7(4.2,-32.2) BG8(4.9,-32.2) BG9(5.6,-32.2) BG10(6.3,-32.2) BG11(7,-32.2) BG12(7.7,-32.2) BG13(8.4,-32.2) BG14(9.1,-32.2) BG15(9.8,-32.2) BG16(10.5,-32.2) BG17(11.2,-32.2) BG18(11.9,-32.2) BG19(12.6,-32.2) BG20(13.3,-32.2) BG21(14,-32.2) BG22(14.7,-32.2) BG23(15.4,-32.2) BG24(16.1,-32.2) BG25(16.8,-32.2) BG26(17.5,-32.2) BG27(18.2,-32.2) BG28(18.9,-32.2) BG29(19.6,-32.2) BG30(20.3,-32.2) BG31(21,-32.2) BG32(21.7,-32.2) BG33(22.4,-32.2) BG34(23.1,-32.2) BG35(23.8,-32.2) BG36(24.5,-32.2) BG37(25.2,-32.2) BG38(25.9,-32.2) BG39(26.6,-32.2) BG40(27.3,-32.2) BG41(28,-32.2) BG42(28.7,-32.2) BG43(29.4,-32.2) BG44(30.1,-32.2) BG45(30.8,-32.2) BG46(31.5,-32.2) BG47(32.2,-32.2) BG48(32.9,-32.2) BG49(33.6,-32.2) BG50(34.3,-32.2) BG51(35,-32.2) BG52(35.7,-32.2) BH1(0,-32.9) BH2(0.7,-32.9) BH3(1.4,-32.9) BH4(2.1,-32.9) BH5(2.8,-32.9) BH6(3.5,-32.9) BH8(4.9,-32.9) BH9(5.6,-32.9) BH11(7,-32.9) BH12(7.7,-32.9) BH14(9.1,-32.9) BH15(9.8,-32.9) BH17(11.2,-32.9) BH18(11.9,-32.9) BH20(13.3,-32.9) BH21(14,-32.9) BH23(15.4,-32.9) BH24(16.1,-32.9) BH26(17.5,-32.9) BH27(18.2,-32.9) BH29(19.6,-32.9) BH30(20.3,-32.9) BH32(21.7,-32.9) BH33(22.4,-32.9) BH35(23.8,-32.9) BH36(24.5,-32.9) BH38(25.9,-32.9) BH39(26.6,-32.9) BH41(28,-32.9) BH42(28.7,-32.9) BH44(30.1,-32.9) BH45(30.8,-32.9) BH47(32.2,-32.9) BH48(32.9,-32.9) BH49(33.6,-32.9) BH50(34.3,-32.9) BH51(35,-32.9) BH52(35.7,-32.9) BJ2(0.7,-33.6) BJ3(1.4,-33.6) BJ4(2.1,-33.6) BJ5(2.8,-33.6) BJ6(3.5,-33.6) BJ7(4.2,-33.6) BJ8(4.9,-33.6) BJ9(5.6,-33.6) BJ10(6.3,-33.6) BJ11(7,-33.6) BJ12(7.7,-33.6) BJ13(8.4,-33.6) BJ14(9.1,-33.6) BJ15(9.8,-33.6) BJ16(10.5,-33.6) BJ17(11.2,-33.6) BJ18(11.9,-33.6) BJ19(12.6,-33.6) BJ20(13.3,-33.6) BJ21(14,-33.6) BJ22(14.7,-33.6) BJ23(15.4,-33.6) BJ24(16.1,-33.6) BJ25(16.8,-33.6) BJ26(17.5,-33.6) BJ27(18.2,-33.6) BJ28(18.9,-33.6) BJ29(19.6,-33.6) BJ30(20.3,-33.6) BJ31(21,-33.6) BJ32(21.7,-33.6) BJ33(22.4,-33.6) BJ34(23.1,-33.6) BJ35(23.8,-33.6) BJ36(24.5,-33.6) BJ37(25.2,-33.6) BJ38(25.9,-33.6) BJ39(26.6,-33.6) BJ40(27.3,-33.6) BJ41(28,-33.6) BJ42(28.7,-33.6) BJ43(29.4,-33.6) BJ44(30.1,-33.6) BJ45(30.8,-33.6) BJ46(31.5,-33.6) BJ47(32.2,-33.6) BJ48(32.9,-33.6) BJ49(33.6,-33.6) BJ50(34.3,-33.6) BJ51(35,-33.6) BK3(1.4,-34.3) BK4(2.1,-34.3) BK5(2.8,-34.3) BK6(3.5,-34.3) BK8(4.9,-34.3) BK9(5.6,-34.3) BK11(7,-34.3) BK12(7.7,-34.3) BK14(9.1,-34.3) BK15(9.8,-34.3) BK17(11.2,-34.3) BK18(11.9,-34.3) BK20(13.3,-34.3) BK21(14,-34.3) BK23(15.4,-34.3) BK24(16.1,-34.3) BK26(17.5,-34.3) BK27(18.2,-34.3) BK29(19.6,-34.3) BK30(20.3,-34.3) BK32(21.7,-34.3) BK33(22.4,-34.3) BK35(23.8,-34.3) BK36(24.5,-34.3) BK38(25.9,-34.3) BK39(26.6,-34.3) BK41(28,-34.3) BK42(28.7,-34.3) BK44(30.1,-34.3) BK45(30.8,-34.3) BK47(32.2,-34.3) BK48(32.9,-34.3) BK49(33.6,-34.3) BK50(34.3,-34.3) BL4(2.1,-35) BL5(2.8,-35) BL6(3.5,-35) BL7(4.2,-35) BL8(4.9,-35) BL9(5.6,-35) BL10(6.3,-35) BL11(7,-35) BL12(7.7,-35) BL13(8.4,-35) BL14(9.1,-35) BL15(9.8,-35) BL16(10.5,-35) BL17(11.2,-35) BL18(11.9,-35) BL19(12.6,-35) BL20(13.3,-35) BL21(14,-35) BL22(14.7,-35) BL23(15.4,-35) BL24(16.1,-35) BL25(16.8,-35) BL26(17.5,-35) BL27(18.2,-35) BL28(18.9,-35) BL29(19.6,-35) BL30(20.3,-35) BL31(21,-35) BL32(21.7,-35) BL33(22.4,-35) BL34(23.1,-35) BL35(23.8,-35) BL36(24.5,-35) BL37(25.2,-35) BL38(25.9,-35) BL39(26.6,-35) BL40(27.3,-35) BL41(28,-35) BL42(28.7,-35) BL43(29.4,-35) BL44(30.1,-35) BL45(30.8,-35) BL46(31.5,-35) BL47(32.2,-35) BL48(32.9,-35) BL49(33.6,-35) BM5(2.8,-35.7) BM6(3.5,-35.7) BM8(4.9,-35.7) BM9(5.6,-35.7) BM11(7,-35.7) BM12(7.7,-35.7) BM14(9.1,-35.7) BM15(9.8,-35.7) BM17(11.2,-35.7) BM18(11.9,-35.7) BM20(13.3,-35.7) BM21(14,-35.7) BM23(15.4,-35.7) BM24(16.1,-35.7) BM26(17.5,-35.7) BM27(18.2,-35.7) BM29(19.6,-35.7) BM30(20.3,-35.7) BM32(21.7,-35.7) BM33(22.4,-35.7) BM35(23.8,-35.7) BM36(24.5,-35.7) BM38(25.9,-35.7) BM39(26.6,-35.7) BM41(28,-35.7) BM42(28.7,-35.7) BM44(30.1,-35.7) BM45(30.8,-35.7) BM47(32.2,-35.7) BM48(32.9,-35.7) C3(1.4,-1.4) C4(2.1,-1.4) C5(2.8,-1.4) C6(3.5,-1.4) C8(4.9,-1.4) C9(5.6,-1.4) C11(7,-1.4) C12(7.7,-1.4) C14(9.1,-1.4) C15(9.8,-1.4) C17(11.2,-1.4) C18(11.9,-1.4) C20(13.3,-1.4) C21(14,-1.4) C23(15.4,-1.4) C24(16.1,-1.4) C26(17.5,-1.4) C27(18.2,-1.4) C29(19.6,-1.4) C30(20.3,-1.4) C32(21.7,-1.4) C33(22.4,-1.4) C35(23.8,-1.4) C36(24.5,-1.4) C38(25.9,-1.4) C39(26.6,-1.4) C41(28,-1.4) C42(28.7,-1.4) C44(30.1,-1.4) C45(30.8,-1.4) C47(32.2,-1.4) C48(32.9,-1.4) C49(33.6,-1.4) C50(34.3,-1.4) D2(0.7,-2.1) D3(1.4,-2.1) D4(2.1,-2.1) D5(2.8,-2.1) D6(3.5,-2.1) D7(4.2,-2.1) D8(4.9,-2.1) D9(5.6,-2.1) D10(6.3,-2.1) D11(7,-2.1) D12(7.7,-2.1) D13(8.4,-2.1) D14(9.1,-2.1) D15(9.8,-2.1) D16(10.5,-2.1) D17(11.2,-2.1) D18(11.9,-2.1) D19(12.6,-2.1) D20(13.3,-2.1) D21(14,-2.1) D22(14.7,-2.1) D23(15.4,-2.1) D24(16.1,-2.1) D25(16.8,-2.1) D26(17.5,-2.1) D27(18.2,-2.1) D28(18.9,-2.1) D29(19.6,-2.1) D30(20.3,-2.1) D31(21,-2.1) D32(21.7,-2.1) D33(22.4,-2.1) D34(23.1,-2.1) D35(23.8,-2.1) D36(24.5,-2.1) D37(25.2,-2.1) D38(25.9,-2.1) D39(26.6,-2.1) D40(27.3,-2.1) D41(28,-2.1) D42(28.7,-2.1) D43(29.4,-2.1) D44(30.1,-2.1) D45(30.8,-2.1) D46(31.5,-2.1) D47(32.2,-2.1) D48(32.9,-2.1) D49(33.6,-2.1) D50(34.3,-2.1) D51(35,-2.1) E1(0,-2.8) E2(0.7,-2.8) E3(1.4,-2.8) E4(2.1,-2.8) E5(2.8,-2.8) E6(3.5,-2.8) E8(4.9,-2.8) E9(5.6,-2.8) E11(7,-2.8) E12(7.7,-2.8) E14(9.1,-2.8) E15(9.8,-2.8) E17(11.2,-2.8) E18(11.9,-2.8) E20(13.3,-2.8) E21(14,-2.8) E23(15.4,-2.8) E24(16.1,-2.8) E26(17.5,-2.8) E27(18.2,-2.8) E29(19.6,-2.8) E30(20.3,-2.8) E32(21.7,-2.8) E33(22.4,-2.8) E35(23.8,-2.8) E36(24.5,-2.8) E38(25.9,-2.8) E39(26.6,-2.8) E41(28,-2.8) E42(28.7,-2.8) E44(30.1,-2.8) E45(30.8,-2.8) E47(32.2,-2.8) E48(32.9,-2.8) E49(33.6,-2.8) E50(34.3,-2.8) E51(35,-2.8) E52(35.7,-2.8) F1(0,-3.5) F2(0.7,-3.5) F3(1.4,-3.5) F4(2.1,-3.5) F5(2.8,-3.5) F6(3.5,-3.5) F7(4.2,-3.5) F8(4.9,-3.5) F9(5.6,-3.5) F10(6.3,-3.5) F11(7,-3.5) F12(7.7,-3.5) F13(8.4,-3.5) F14(9.1,-3.5) F15(9.8,-3.5) F16(10.5,-3.5) F17(11.2,-3.5) F18(11.9,-3.5) F19(12.6,-3.5) F20(13.3,-3.5) F21(14,-3.5) F22(14.7,-3.5) F23(15.4,-3.5) F24(16.1,-3.5) F25(16.8,-3.5) F26(17.5,-3.5) F27(18.2,-3.5) F28(18.9,-3.5) F29(19.6,-3.5) F30(20.3,-3.5) F31(21,-3.5) F32(21.7,-3.5) F33(22.4,-3.5) F34(23.1,-3.5) F35(23.8,-3.5) F36(24.5,-3.5) F37(25.2,-3.5) F38(25.9,-3.5) F39(26.6,-3.5) F40(27.3,-3.5) F41(28,-3.5) F42(28.7,-3.5) F43(29.4,-3.5) F44(30.1,-3.5) F45(30.8,-3.5) F46(31.5,-3.5) F47(32.2,-3.5) F48(32.9,-3.5) F49(33.6,-3.5) F50(34.3,-3.5) F51(35,-3.5) F52(35.7,-3.5) G2(0.7,-4.2) G4(2.1,-4.2) G6(3.5,-4.2) G8(4.9,-4.2) G9(5.6,-4.2) G11(7,-4.2) G12(7.7,-4.2) G14(9.1,-4.2) G15(9.8,-4.2) G17(11.2,-4.2) G18(11.9,-4.2) G20(13.3,-4.2) G21(14,-4.2) G23(15.4,-4.2) G24(16.1,-4.2) G26(17.5,-4.2) G27(18.2,-4.2) G29(19.6,-4.2) G30(20.3,-4.2) G32(21.7,-4.2) G33(22.4,-4.2) G35(23.8,-4.2) G36(24.5,-4.2) G38(25.9,-4.2) G39(26.6,-4.2) G41(28,-4.2) G42(28.7,-4.2) G44(30.1,-4.2) G45(30.8,-4.2) G47(32.2,-4.2) G49(33.6,-4.2) G51(35,-4.2) H1(0,-4.9) H2(0.7,-4.9) H3(1.4,-4.9) H4(2.1,-4.9) H5(2.8,-4.9) H6(3.5,-4.9) H7(4.2,-4.9) H10(6.3,-4.9) H11(7,-4.9) H12(7.7,-4.9) H13(8.4,-4.9) H14(9.1,-4.9) H15(9.8,-4.9) H16(10.5,-4.9) H17(11.2,-4.9) H18(11.9,-4.9) H19(12.6,-4.9) H20(13.3,-4.9) H21(14,-4.9) H22(14.7,-4.9) H23(15.4,-4.9) H24(16.1,-4.9) H25(16.8,-4.9) H26(17.5,-4.9) H27(18.2,-4.9) H28(18.9,-4.9) H29(19.6,-4.9) H30(20.3,-4.9) H31(21,-4.9) H32(21.7,-4.9) H33(22.4,-4.9) H34(23.1,-4.9) H35(23.8,-4.9) H36(24.5,-4.9) H37(25.2,-4.9) H38(25.9,-4.9) H39(26.6,-4.9) H40(27.3,-4.9) H41(28,-4.9) H42(28.7,-4.9) H43(29.4,-4.9) H46(31.5,-4.9) H47(32.2,-4.9) H48(32.9,-4.9) H49(33.6,-4.9) H50(34.3,-4.9) H51(35,-4.9) H52(35.7,-4.9) J1(0,-5.6) J2(0.7,-5.6) J3(1.4,-5.6) J4(2.1,-5.6) J5(2.8,-5.6) J6(3.5,-5.6) J7(4.2,-5.6) J12(7.7,-5.6) J14(9.1,-5.6) J15(9.8,-5.6) J17(11.2,-5.6) J18(11.9,-5.6) J20(13.3,-5.6) J21(14,-5.6) J23(15.4,-5.6) J24(16.1,-5.6) J26(17.5,-5.6) J27(18.2,-5.6) J29(19.6,-5.6) J30(20.3,-5.6) J32(21.7,-5.6) J33(22.4,-5.6) J35(23.8,-5.6) J36(24.5,-5.6) J38(25.9,-5.6) J39(26.6,-5.6) J41(28,-5.6) J46(31.5,-5.6) J47(32.2,-5.6) J48(32.9,-5.6) J49(33.6,-5.6) J50(34.3,-5.6) J51(35,-5.6) J52(35.7,-5.6) K2(0.7,-6.3) K4(2.1,-6.3) K6(3.5,-6.3) K8(4.9,-6.3) K12(7.7,-6.3) K13(8.4,-6.3) K14(9.1,-6.3) K15(9.8,-6.3) K16(10.5,-6.3) K17(11.2,-6.3) K18(11.9,-6.3) K19(12.6,-6.3) K20(13.3,-6.3) K21(14,-6.3) K22(14.7,-6.3) K23(15.4,-6.3) K24(16.1,-6.3) K25(16.8,-6.3) K26(17.5,-6.3) K27(18.2,-6.3) K28(18.9,-6.3) K29(19.6,-6.3) K30(20.3,-6.3) K31(21,-6.3) K32(21.7,-6.3) K33(22.4,-6.3) K34(23.1,-6.3) K35(23.8,-6.3) K36(24.5,-6.3) K37(25.2,-6.3) K38(25.9,-6.3) K39(26.6,-6.3) K40(27.3,-6.3) K41(28,-6.3) K45(30.8,-6.3) K47(32.2,-6.3) K49(33.6,-6.3) K51(35,-6.3) L1(0,-7) L2(0.7,-7) L3(1.4,-7) L4(2.1,-7) L5(2.8,-7) L6(3.5,-7) L7(4.2,-7) L8(4.9,-7) L14(9.1,-7) L15(9.8,-7) L17(11.2,-7) L18(11.9,-7) L20(13.3,-7) L21(14,-7) L23(15.4,-7) L24(16.1,-7) L26(17.5,-7) L27(18.2,-7) L29(19.6,-7) L30(20.3,-7) L32(21.7,-7) L33(22.4,-7) L35(23.8,-7) L36(24.5,-7) L38(25.9,-7) L39(26.6,-7) L45(30.8,-7) L46(31.5,-7) L47(32.2,-7) L48(32.9,-7) L49(33.6,-7) L50(34.3,-7) L51(35,-7) L52(35.7,-7) M1(0,-7.7) M2(0.7,-7.7) M3(1.4,-7.7) M4(2.1,-7.7) M5(2.8,-7.7) M6(3.5,-7.7) M7(4.2,-7.7) M8(4.9,-7.7) M9(5.6,-7.7) M10(6.3,-7.7) M43(29.4,-7.7) M44(30.1,-7.7) M45(30.8,-7.7) M46(31.5,-7.7) M47(32.2,-7.7) M48(32.9,-7.7) M49(33.6,-7.7) M50(34.3,-7.7) M51(35,-7.7) M52(35.7,-7.7) N2(0.7,-8.4) N4(2.1,-8.4) N6(3.5,-8.4) N8(4.9,-8.4) N10(6.3,-8.4) N14(9.1,-8.4) N18(11.9,-8.4) N22(14.7,-8.4) N26(17.5,-8.4) N27(18.2,-8.4) N31(21,-8.4) N35(23.8,-8.4) N39(26.6,-8.4) N43(29.4,-8.4) N45(30.8,-8.4) N47(32.2,-8.4) N49(33.6,-8.4) N51(35,-8.4) P1(0,-9.1) P2(0.7,-9.1) P3(1.4,-9.1) P4(2.1,-9.1) P5(2.8,-9.1) P6(3.5,-9.1) P7(4.2,-9.1) P8(4.9,-9.1) P9(5.6,-9.1) P10(6.3,-9.1) P11(7,-9.1) P13(8.4,-9.1) P14(9.1,-9.1) P15(9.8,-9.1) P16(10.5,-9.1) P17(11.2,-9.1) P18(11.9,-9.1) P19(12.6,-9.1) P20(13.3,-9.1) P21(14,-9.1) P22(14.7,-9.1) P23(15.4,-9.1) P24(16.1,-9.1) P25(16.8,-9.1) P26(17.5,-9.1) P27(18.2,-9.1) P28(18.9,-9.1) P29(19.6,-9.1) P30(20.3,-9.1) P31(21,-9.1) P32(21.7,-9.1) P33(22.4,-9.1) P34(23.1,-9.1) P35(23.8,-9.1) P36(24.5,-9.1) P37(25.2,-9.1) P38(25.9,-9.1) P39(26.6,-9.1) P40(27.3,-9.1) P42(28.7,-9.1) P43(29.4,-9.1) P44(30.1,-9.1) P45(30.8,-9.1) P46(31.5,-9.1) P47(32.2,-9.1) P48(32.9,-9.1) P49(33.6,-9.1) P50(34.3,-9.1) P51(35,-9.1) P52(35.7,-9.1) R1(0,-9.8) R2(0.7,-9.8) R3(1.4,-9.8) R4(2.1,-9.8) R5(2.8,-9.8) R6(3.5,-9.8) R7(4.2,-9.8) R8(4.9,-9.8) R9(5.6,-9.8) R10(6.3,-9.8) R11(7,-9.8) R14(9.1,-9.8) R15(9.8,-9.8) R16(10.5,-9.8) R17(11.2,-9.8) R18(11.9,-9.8) R19(12.6,-9.8) R20(13.3,-9.8) R21(14,-9.8) R22(14.7,-9.8) R23(15.4,-9.8) R24(16.1,-9.8) R25(16.8,-9.8) R26(17.5,-9.8) R27(18.2,-9.8) R28(18.9,-9.8) R29(19.6,-9.8) R30(20.3,-9.8) R31(21,-9.8) R32(21.7,-9.8) R33(22.4,-9.8) R34(23.1,-9.8) R35(23.8,-9.8) R36(24.5,-9.8) R37(25.2,-9.8) R38(25.9,-9.8) R39(26.6,-9.8) R42(28.7,-9.8) R43(29.4,-9.8) R44(30.1,-9.8) R45(30.8,-9.8) R46(31.5,-9.8) R47(32.2,-9.8) R48(32.9,-9.8) R49(33.6,-9.8) R50(34.3,-9.8) R51(35,-9.8) R52(35.7,-9.8) T2(0.7,-10.5) T4(2.1,-10.5) T6(3.5,-10.5) T8(4.9,-10.5) T10(6.3,-10.5) T14(9.1,-10.5) T15(9.8,-10.5) T16(10.5,-10.5) T17(11.2,-10.5) T18(11.9,-10.5) T19(12.6,-10.5) T20(13.3,-10.5) T21(14,-10.5) T22(14.7,-10.5) T23(15.4,-10.5) T24(16.1,-10.5) T25(16.8,-10.5) T26(17.5,-10.5) T27(18.2,-10.5) T28(18.9,-10.5) T29(19.6,-10.5) T30(20.3,-10.5) T31(21,-10.5) T32(21.7,-10.5) T33(22.4,-10.5) T34(23.1,-10.5) T35(23.8,-10.5) T36(24.5,-10.5) T37(25.2,-10.5) T38(25.9,-10.5) T39(26.6,-10.5) T43(29.4,-10.5) T45(30.8,-10.5) T47(32.2,-10.5) T49(33.6,-10.5) T51(35,-10.5) U1(0,-11.2) U2(0.7,-11.2) U3(1.4,-11.2) U4(2.1,-11.2) U5(2.8,-11.2) U6(3.5,-11.2) U7(4.2,-11.2) U8(4.9,-11.2) U9(5.6,-11.2) U10(6.3,-11.2) U11(7,-11.2) U14(9.1,-11.2) U15(9.8,-11.2) U16(10.5,-11.2) U17(11.2,-11.2) U18(11.9,-11.2) U19(12.6,-11.2) U20(13.3,-11.2) U21(14,-11.2) U22(14.7,-11.2) U23(15.4,-11.2) U24(16.1,-11.2) U25(16.8,-11.2) U26(17.5,-11.2) U27(18.2,-11.2) U28(18.9,-11.2) U29(19.6,-11.2) U30(20.3,-11.2) U31(21,-11.2) U32(21.7,-11.2) U33(22.4,-11.2) U34(23.1,-11.2) U35(23.8,-11.2) U36(24.5,-11.2) U37(25.2,-11.2) U38(25.9,-11.2) U39(26.6,-11.2) U42(28.7,-11.2) U43(29.4,-11.2) U44(30.1,-11.2) U45(30.8,-11.2) U46(31.5,-11.2) U47(32.2,-11.2) U48(32.9,-11.2) U49(33.6,-11.2) U50(34.3,-11.2) U51(35,-11.2) U52(35.7,-11.2) V1(0,-11.9) V2(0.7,-11.9) V3(1.4,-11.9) V4(2.1,-11.9) V5(2.8,-11.9) V6(3.5,-11.9) V7(4.2,-11.9) V8(4.9,-11.9) V9(5.6,-11.9) V10(6.3,-11.9) V11(7,-11.9) V13(8.4,-11.9) V14(9.1,-11.9) V15(9.8,-11.9) V16(10.5,-11.9) V17(11.2,-11.9) V18(11.9,-11.9) V19(12.6,-11.9) V20(13.3,-11.9) V21(14,-11.9) V22(14.7,-11.9) V23(15.4,-11.9) V24(16.1,-11.9) V25(16.8,-11.9) V26(17.5,-11.9) V27(18.2,-11.9) V28(18.9,-11.9) V29(19.6,-11.9) V30(20.3,-11.9) V31(21,-11.9) V32(21.7,-11.9) V33(22.4,-11.9) V34(23.1,-11.9) V35(23.8,-11.9) V36(24.5,-11.9) V37(25.2,-11.9) V38(25.9,-11.9) V39(26.6,-11.9) V40(27.3,-11.9) V42(28.7,-11.9) V43(29.4,-11.9) V44(30.1,-11.9) V45(30.8,-11.9) V46(31.5,-11.9) V47(32.2,-11.9) V48(32.9,-11.9) V49(33.6,-11.9) V50(34.3,-11.9) V51(35,-11.9) V52(35.7,-11.9) W2(0.7,-12.6) W4(2.1,-12.6) W6(3.5,-12.6) W8(4.9,-12.6) W10(6.3,-12.6) W14(9.1,-12.6) W15(9.8,-12.6) W16(10.5,-12.6) W17(11.2,-12.6) W18(11.9,-12.6) W19(12.6,-12.6) W20(13.3,-12.6) W21(14,-12.6) W22(14.7,-12.6) W23(15.4,-12.6) W24(16.1,-12.6) W25(16.8,-12.6) W26(17.5,-12.6) W27(18.2,-12.6) W28(18.9,-12.6) W29(19.6,-12.6) W30(20.3,-12.6) W31(21,-12.6) W32(21.7,-12.6) W33(22.4,-12.6) W34(23.1,-12.6) W35(23.8,-12.6) W36(24.5,-12.6) W37(25.2,-12.6) W38(25.9,-12.6) W39(26.6,-12.6) W43(29.4,-12.6) W45(30.8,-12.6) W47(32.2,-12.6) W49(33.6,-12.6) W51(35,-12.6) Y1(0,-13.3) Y2(0.7,-13.3) Y3(1.4,-13.3) Y4(2.1,-13.3) Y5(2.8,-13.3) Y6(3.5,-13.3) Y7(4.2,-13.3) Y8(4.9,-13.3) Y9(5.6,-13.3) Y10(6.3,-13.3) Y11(7,-13.3) Y14(9.1,-13.3) Y15(9.8,-13.3) Y16(10.5,-13.3) Y17(11.2,-13.3) Y18(11.9,-13.3) Y19(12.6,-13.3) Y20(13.3,-13.3) Y21(14,-13.3) Y22(14.7,-13.3) Y23(15.4,-13.3) Y24(16.1,-13.3) Y25(16.8,-13.3) Y26(17.5,-13.3) Y27(18.2,-13.3) Y28(18.9,-13.3) Y29(19.6,-13.3) Y30(20.3,-13.3) Y31(21,-13.3) Y32(21.7,-13.3) Y33(22.4,-13.3) Y34(23.1,-13.3) Y35(23.8,-13.3) Y36(24.5,-13.3) Y37(25.2,-13.3) Y38(25.9,-13.3) Y39(26.6,-13.3) Y42(28.7,-13.3) Y43(29.4,-13.3) Y44(30.1,-13.3) Y45(30.8,-13.3) Y46(31.5,-13.3) Y47(32.2,-13.3) Y48(32.9,-13.3) Y49(33.6,-13.3) Y50(34.3,-13.3) Y51(35,-13.3) Y52(35.7,-13.3)
