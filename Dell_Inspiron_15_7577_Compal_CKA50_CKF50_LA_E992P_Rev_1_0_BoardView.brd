# Allegro board Dell_Inspiron_15_7577_Compal_CKA50_CKF50_LA_E992P_Rev_1_0_BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_D47: length 61.5
  IN1 w0.076: 150.83,70.85 150.83,72.57 149.97,73.42 149.97,77.66 149.29,78.34 v2(149.12,78.34)
  IN1 w0.097: v2(123.99,36.32) 124.8,37.14 124.8,38.58 129.76,43.53 130.14,43.53 131.43,44.83 133.14,44.83 136.5,48.19 136.5,48.19 137.01,48.7 137.01,48.91 136.88,49.04 136.88,49.25 137.02,49.4 137.23,49.4 137.36,49.27 137.57,49.27 137.72,49.41 137.72,49.62 137.59,49.75 137.59,49.96 137.74,50.11 137.94,50.11 138.08,49.98 138.28,49.98 138.43,50.12 138.43,50.33 138.3,50.47 138.3,50.67 138.45,50.82 138.66,50.82 138.79,50.69 139,50.69 139.14,50.84 139.14,51.04 139.01,51.18 139.01,51.39 139.17,51.55 139.38,51.55 139.62,51.3 139.83,51.3 139.98,51.45 139.98,51.66 139.73,51.9 139.73,52.11 139.88,52.26 140.09,52.26 140.33,52.01 140.54,52.01 140.69,52.16 140.69,52.37 140.45,52.61 140.45,52.82 150.44,62.81 150.44,62.94 150.45,62.96 150.45,63.19 150.83,63.57 150.83,70.85
  BOTTOM w0.076: v2(149.12,78.34) 148.71,78.64 UH1.BC2
  BOTTOM w0.14: JDIMM1.84 123.58,35.91 v2(123.99,36.32)
DDR_A_D48: length 60.6
  IN5 w0.076: 143.95,74.24 144.12,74.41 144.12,75.1 145.4,76.38 145.4,82.78 145.56,82.93 145.56,84.93 145.68,85.05 146.04,85.05 v2(146.09,85.01)
  IN5 w0.097: v2(157.88,41.67) 158.02,41.81 158.02,45.95 144.23,59.74 144.23,59.9 144.29,59.95 144.29,60.11 144.17,60.23 144.01,60.23 143.96,60.17 143.8,60.17 143.61,60.36 143.61,60.79 143.72,60.9 143.9,60.9 144.01,61.01 144.01,61.17 143.9,61.28 143.72,61.28 143.61,61.4 143.61,64.49 143.5,64.61 143.15,64.61 143.04,64.72 143.04,64.88 143.15,64.99 143.5,64.99 143.61,65.11 143.61,65.27 143.5,65.38 143.15,65.38 143.04,65.49 143.04,65.65 143.15,65.76 143.5,65.76 143.61,65.88 143.61,66.04 143.5,66.15 143.15,66.15 143.04,66.26 143.04,66.42 143.15,66.54 143.5,66.54 143.61,66.65 143.61,67.01 143.72,67.12 143.9,67.12 144.01,67.24 144.01,67.4 143.9,67.51 143.72,67.51 143.61,67.62 143.61,67.78 143.72,67.9 143.9,67.9 144.01,68.01 144.01,68.17 143.9,68.28 143.72,68.28 143.61,68.4 143.61,68.56 143.72,68.67 143.9,68.67 144.01,68.78 144.01,68.94 143.9,69.06 143.72,69.06 143.61,69.17 143.61,69.33 143.72,69.44 143.9,69.44 144.01,69.55 144.01,69.71 143.9,69.83 143.72,69.83 143.61,69.94 143.61,70.1 143.72,70.21 143.9,70.21 144.01,70.33 144.01,70.49 143.9,70.6 143.72,70.6 143.61,70.71 143.61,70.87 143.72,70.99 143.9,70.99 144.01,71.1 144.01,71.26 143.9,71.37 143.72,71.37 143.61,71.48 143.61,71.64 143.72,71.76 143.9,71.76 144.01,71.87 144.01,72.03 143.9,72.14 143.72,72.14 143.61,72.26 143.61,72.42 143.72,72.53 143.9,72.53 144.01,72.64 144.01,72.8 143.9,72.92 143.72,72.92 143.61,73.03 143.61,73.91 143.64,73.94 143.65,73.94 143.95,74.24
  BOTTOM w0.076: UH1.BG11 145.78,84.7 v2(146.09,85.01)
  BOTTOM w0.14: v2(157.88,41.67) 157.88,41.67 158,41.67 158.33,42 JDIMM1.215
DDR_A_D49: length 60.6
  IN5 w0.076: 144.31,73.88 144.31,74.15 144.29,74.17 144.29,75.03 145.57,76.31 145.57,82.71 145.72,82.86 145.72,84.01 v2(146.09,84.37)
  IN5 w0.097: 144.31,73.88 144.31,66.77 144.2,66.65 144.02,66.65 143.91,66.54 143.91,66.38 144.02,66.27 144.2,66.27 144.31,66.15 144.31,65.99 144.2,65.88 144.02,65.88 143.91,65.77 143.91,65.61 144.02,65.49 144.2,65.49 144.31,65.38 144.31,65.22 144.2,65.11 144.02,65.11 143.91,65 143.91,64.84 144.02,64.72 144.2,64.72 144.31,64.61 144.31,64.39 144.2,64.27 144.02,64.27 143.91,64.16 143.91,64 144.02,63.89 144.2,63.89 144.31,63.77 144.31,63.61 144.2,63.5 144.02,63.5 143.91,63.39 143.91,63.23 144.02,63.11 144.2,63.11 144.31,63 144.31,62.84 144.2,62.73 144.02,62.73 143.91,62.62 143.91,62.46 144.02,62.34 144.2,62.34 144.31,62.23 144.31,62.07 144.2,61.96 144.02,61.96 143.91,61.84 143.91,61.68 144.02,61.57 144.2,61.57 144.31,61.46 144.31,60.69 144.86,60.14 144.86,59.98 144.72,59.83 144.72,59.67 144.83,59.56 144.99,59.56 145.14,59.7 145.3,59.7 145.47,59.53 145.47,59.37 145.33,59.23 145.33,59.07 145.45,58.95 145.61,58.95 145.75,59.09 145.91,59.09 146.02,58.98 146.02,58.82 145.88,58.68 145.88,58.52 145.99,58.41 146.15,58.41 146.29,58.55 146.45,58.55 146.57,58.44 146.57,58.28 146.43,58.14 146.43,57.98 146.54,57.86 146.7,57.86 146.84,58 147,58 147.11,57.89 147.11,57.73 146.97,57.59 146.97,57.43 158.32,46.08 158.32,40.71 158.02,40.4 v2(157.84,40.4)
  BOTTOM w0.089: UH1.BG10 v2(146.09,84.37)
  BOTTOM w0.14: v2(157.84,40.4) 157.48,40.4 157.33,40.55 JDIMM1.211
DDR_A_D50: length 60.9
  IN5 w0.076: 144.61,73.58 144.61,74.23 144.49,74.35 144.49,75 145.73,76.24 145.73,82.61 146.09,82.96 v2(146.09,83.07)
  IN5 w0.097: v2(157.84,37.67) 157.84,37.28 157.65,37.09 157.65,36.89 157.74,36.79 158.08,36.79 158.63,37.35 158.63,37.64 158.51,37.75 158.34,37.75 158.23,37.87 158.23,38.03 158.34,38.14 158.51,38.14 158.63,38.25 158.63,38.63 158.51,38.74 158.14,38.74 158.03,38.85 158.03,39.01 158.14,39.13 158.51,39.13 158.63,39.24 158.63,39.59 158.51,39.7 158.46,39.7 158.34,39.82 158.34,39.98 158.46,40.09 158.51,40.09 158.63,40.2 158.63,46.34 147.6,57.37 147.6,57.82 145.35,60.08 145.35,60.24 145.63,60.52 145.63,60.68 145.52,60.79 145.36,60.79 145.08,60.51 144.92,60.51 144.61,60.82 144.61,73.58
  BOTTOM w0.089: UH1.BG8 v2(146.09,83.07)
  BOTTOM w0.14: JDIMM1.212 157.57,35.66 157.39,35.84 157.39,36.49 157.84,36.94 v2(157.84,37.67)
DDR_A_D51: length 60.6
  IN5 w0.076: v2(147,83.08) 147,82.95 147.65,82.3 147.65,81.93 148.27,81.31 148.27,76.98 148.69,76.56 148.69,75.25 147.2,73.76 147.2,73.17
  IN5 w0.097: 147.2,73.17 147.2,62.8 147.21,62.79 147.21,62.53 152.07,57.67 152.07,57.51 151.44,56.88 151.44,56.72 151.55,56.6 151.71,56.6 152.34,57.23 152.5,57.23 152.62,57.12 152.62,56.96 151.98,56.33 151.98,56.17 152.1,56.06 152.26,56.06 152.89,56.69 153.05,56.69 153.16,56.58 153.16,56.42 152.53,55.79 152.53,55.63 152.64,55.51 152.8,55.51 153.43,56.14 153.59,56.14 153.71,56.03 153.71,55.87 153.08,55.24 153.08,55.08 162.25,45.9 162.25,45.53 162.14,45.42 161.72,45.42 161.61,45.31 161.61,45.15 161.72,45.04 162.14,45.04 162.25,44.92 162.25,44.76 162.14,44.65 161.72,44.65 161.61,44.54 161.61,44.38 161.72,44.26 162.14,44.26 162.25,44.15 162.25,43.47 162.45,43.27 162.45,41.36 v2(162.35,41.25)
  BOTTOM w0.089: UH1.BF8 v2(147,83.08)
  BOTTOM w0.14: v2(162.35,41.25) 162.09,41.25 161.82,41.52 JDIMM1.229
DDR_A_D52: length 60.6
  IN5 w0.076: v2(147,85.01) 147.55,84.46 147.55,82.97 147.98,82.54 147.98,82.07 148.6,81.45 148.6,77.12 149.02,76.7 149.02,74.85 147.81,73.63 147.81,73.17
  IN5 w0.097: v2(160.45,36.73) 161.78,36.73 163.06,38.01 163.06,43.51 162.85,43.72 162.85,46.62 156.61,52.86 156.61,52.86 156.05,53.42 156.05,54.53 147.99,62.59 147.81,62.78 147.81,73.17
  BOTTOM w0.089: UH1.BF11 v2(147,85.01)
  BOTTOM w0.14: v2(160.45,36.73) 160.58,36.73 160.72,36.59 160.72,35.89 160.57,35.75 JDIMM1.224
DDR_A_D53: length 60.3
  IN5 w0.076: 147.5,73.17 147.5,73.63 148.86,74.99 148.86,76.63 148.44,77.05 148.44,81.38 147.82,82 147.82,82.42 147.36,82.87 147.36,84.02 v2(147,84.37)
  IN5 w0.097: v2(162.33,39.98) 162.33,40.02 162.75,40.44 162.75,43.39 162.55,43.59 162.55,46.49 156.31,52.73 156.31,52.74 155.75,53.3 155.75,54.41 155.38,54.78 155.22,54.78 154.59,54.15 154.43,54.15 154.32,54.26 154.32,54.42 154.95,55.05 154.95,55.21 154.84,55.33 154.68,55.33 154.05,54.69 153.89,54.69 153.77,54.81 153.77,54.97 154.4,55.6 154.4,55.76 147.51,62.65 147.51,63.32 147.5,63.32 147.5,73.17
  BOTTOM w0.089: UH1.BF10 v2(147,84.37)
  BOTTOM w0.14: JDIMM1.225 160.82,41.49 v2(162.33,39.98)
DDR_A_D54: length 60
  IN5 w0.076: 144.91,73.28 144.91,73.83 147.61,76.53 147.61,79.97 146.29,81.29 146.29,82.22 v2(146.09,82.42)
  IN5 w0.097: 144.91,73.28 144.91,61.93 146.19,60.65 146.19,60.49 145.9,60.2 145.9,60.04 146.01,59.93 146.17,59.93 146.46,60.22 146.62,60.22 146.74,60.11 146.74,59.95 146.44,59.65 146.44,59.49 146.55,59.38 146.71,59.38 147.01,59.68 147.17,59.68 147.28,59.56 147.28,59.4 146.99,59.11 146.99,58.95 147.1,58.83 147.26,58.83 147.56,59.13 147.72,59.13 147.9,58.94 147.9,57.49 158.93,46.46 158.93,37.23 v2(157.83,36.12)
  BOTTOM w0.089: UH1.BG7 v2(146.09,82.42)
  BOTTOM w0.14: v2(157.83,36.12) 158.43,36.12 158.57,35.98 JDIMM1.216
DDR_A_D55: length 60.9
  IN5 w0.076: 146.89,73.17 146.89,73.69 148.53,75.32 148.53,76.49 148.11,76.91 148.11,81.25 147,82.35 v2(147,82.42)
  IN5 w0.097: 146.89,73.17 146.89,62.53 146.91,62.52 146.91,62.41 150.25,59.06 150.25,58.9 149.7,58.34 149.7,58.21 149.83,58.07 149.97,58.07 150.53,58.63 150.69,58.63 150.8,58.51 150.8,58.35 150.17,57.72 150.17,57.56 150.28,57.45 150.44,57.45 151.07,58.08 151.23,58.08 151.35,57.97 151.35,57.81 150.71,57.17 150.71,57.01 161.31,46.41 161.31,38.87 v2(160.44,38)
  BOTTOM w0.089: UH1.BF7 v2(147,82.42)
  BOTTOM w0.14: JDIMM1.228 161.57,36.79 161.27,37.1 161.27,37.56 160.82,38 v2(160.44,38)
DDR_A_D56: length 59.4
  IN5 w0.076: 152.26,73.17 152.26,73.49 152.29,73.51 152.29,73.55 151.15,74.69 151.15,82.16 150.29,83.02 150.29,84.48 v2(149.75,85.02)
  IN5 w0.097: v2(168,39.47) 168.07,39.47 168.7,40.1 168.7,42.07 169.01,42.38 169.01,44.67 169.58,45.24 169.58,45.81 168.63,46.76 168.63,47.86 152.26,64.24 152.26,73.02 152.26,73.02 152.26,73.17
  BOTTOM w0.089: UH1.BB11 v2(149.75,85.02)
  BOTTOM w0.14: v2(168,39.47) 165.82,41.64 JDIMM1.245
DDR_A_D57: length 59.4
  IN5 w0.076: v2(148.83,85.01) 148.83,84.96 148.42,84.55 148.42,84.29 148.3,84.17 148.3,82.96 148.15,82.81 148.15,82.14 148.77,81.52 148.77,77.31 149.19,76.89 149.19,74.62 148.72,74.15 148.72,73.17
  IN5 w0.097: v2(163.88,41.56) 163.79,41.66 163.79,46.72 159.53,50.98 159.53,51.14 159.93,51.53 159.93,51.69 159.81,51.81 159.65,51.81 159.26,51.41 159.1,51.41 158.98,51.52 158.98,51.68 159.38,52.08 159.38,52.24 159.27,52.35 159.11,52.35 158.71,51.96 158.55,51.96 158.44,52.07 158.44,52.23 158.83,52.63 158.83,52.79 158.72,52.9 158.56,52.9 158.16,52.5 158,52.5 157.89,52.62 157.89,52.78 158.29,53.17 158.29,53.33 158.17,53.45 158.01,53.45 157.62,53.05 157.46,53.05 157.34,53.16 157.34,53.32 157.74,53.72 157.74,53.88 157.58,54.04 157.42,54.04 157.06,53.67 156.9,53.67 156.78,53.79 156.78,53.95 157.15,54.31 157.15,54.47 148.72,62.9 148.72,73.17
  BOTTOM w0.076: UH1.BC11 148.52,84.7 v2(148.83,85.01)
  BOTTOM w0.14: JDIMM1.237 163.82,41.62 v2(163.88,41.56)
DDR_A_D58: length 59.6
  IN5 w0.076: v2(149.75,83.07) 150.82,82 150.82,74.48 151.66,73.65 151.66,73.17
  IN5 w0.097: 151.66,73.17 151.66,63.99 167.45,48.2 167.45,46.79 167.56,46.68 167.82,46.68 167.93,46.57 167.93,46.41 167.82,46.29 167.56,46.29 167.45,46.18 167.45,46.02 167.56,45.91 167.82,45.91 167.93,45.79 167.93,45.63 167.82,45.52 167.56,45.52 167.45,45.41 167.45,45.25 167.56,45.14 167.82,45.14 167.93,45.02 167.93,44.86 167.82,44.75 167.56,44.75 167.45,44.64 167.45,38.87 168.06,38.26 v2(168.06,38.2)
  BOTTOM w0.089: UH1.BB8 v2(149.75,83.07)
  BOTTOM w0.14: v2(168.06,38.2) 168.12,38.2 168.44,37.87 168.44,36.83 168.15,36.55 167.86,36.55 167.08,35.76 JDIMM1.250
DDR_A_D59: length 59.5
  IN5 w0.076: v2(148.83,83.07) 148.83,82.96 148.48,82.6 148.48,82.27 149.22,81.54 149.52,81.54 150,81.06 150,74.48 149.32,73.8 149.32,73.17
  IN5 w0.097: v2(163.88,39) 164.59,39.71 164.59,47.88 164.19,48.28 164.03,48.28 163.71,47.97 163.55,47.97 163.44,48.08 163.44,48.24 163.75,48.55 163.75,48.71 163.64,48.83 163.48,48.83 163.17,48.51 163.01,48.51 162.9,48.63 162.9,48.79 163.21,49.1 163.21,49.26 149.32,63.15 149.32,73.17
  BOTTOM w0.089: UH1.BC8 148.57,82.88 v2(148.83,83.07)
  BOTTOM w0.14: v2(163.88,39) 162.57,37.7 JDIMM1.232
DDR_A_D60: length 59.3
  IN5 w0.076: 149.02,73.17 149.02,73.81 149.83,74.62 149.83,80.99 149.45,81.37 149.15,81.37 148.31,82.21 148.31,82.7 148.47,82.85 148.47,84 v2(148.83,84.37)
  IN5 w0.097: v2(163.88,40.29) 163.88,40.33 164.28,40.73 164.28,41.35 164.28,41.36 164.28,41.78 164.09,41.97 164.09,46.99 162.05,49.03 162.05,49.19 162.37,49.51 162.37,49.67 162.26,49.78 162.1,49.78 161.78,49.46 161.62,49.46 161.5,49.57 161.5,49.73 161.83,50.06 161.83,50.22 161.71,50.33 161.55,50.33 161.23,50.01 161.07,50.01 160.96,50.12 160.96,50.28 161.28,50.6 161.28,50.76 161.17,50.88 161.01,50.88 160.68,50.55 160.52,50.55 160.41,50.67 160.41,50.83 160.73,51.15 160.73,51.31 149.02,63.02 149.02,73.17
  BOTTOM w0.089: v2(148.83,84.37) 148.57,84.18 UH1.BC10
  BOTTOM w0.14: v2(163.88,40.29) 163.53,40.29 163.26,40.56 163.26,41.5 162.82,41.94 JDIMM1.233
DDR_A_D61: length 59.4
  IN5 w0.076: v2(149.75,84.37) 150.13,83.99 150.13,82.94 150.99,82.08 150.99,74.55 151.99,73.55 151.99,73.33 151.96,73.3 151.96,73.17
  IN5 w0.097: v2(168,40.74) 168.26,40.74 168.4,40.88 168.4,42.28 168.29,42.4 167.86,42.4 167.75,42.51 167.75,42.67 167.86,42.78 168.54,42.78 168.66,42.9 168.66,43.06 168.54,43.17 167.86,43.17 167.75,43.28 167.75,43.44 167.86,43.56 168.54,43.56 168.66,43.67 168.66,43.83 168.54,43.94 167.86,43.94 167.75,44.05 167.75,44.21 167.86,44.33 168.15,44.33 168.25,44.42 168.25,45.12 168.36,45.23 168.52,45.23 168.63,45.34 168.63,45.5 168.52,45.61 168.36,45.61 168.25,45.73 168.25,47.82 151.96,64.11 151.96,73.14 151.96,73.15 151.96,73.17
  BOTTOM w0.089: UH1.BB10 v2(149.75,84.37)
  BOTTOM w0.14: v2(168,40.74) 166.83,41.91 JDIMM1.249
DDR_A_D62: length 58.9
  IN5 w0.076: v2(148.83,82.42) 148.83,82.37 149.46,81.74 149.88,81.74 150.16,81.45 150.16,74.35 149.71,73.89 149.71,73.17
  IN5 w0.097: 149.71,73.17 149.71,63.18 164.9,48 164.9,39.14 164.78,39.03 164.55,39.03 164.44,38.91 164.44,38.75 164.55,38.64 164.78,38.64 164.9,38.53 164.9,38.37 164.78,38.25 164.55,38.25 164.44,38.14 164.44,37.98 164.55,37.87 164.78,37.87 164.9,37.75 164.9,37.59 164.78,37.48 164.55,37.48 164.44,37.37 164.44,37.21 164.55,37.1 164.97,37.1 165.09,36.98 165.09,36.51 164.99,36.41 164.14,36.41 v2(163.93,36.2)
  BOTTOM w0.089: v2(148.83,82.42) 148.57,82.23 UH1.BC7
  BOTTOM w0.14: JDIMM1.236 163.57,36.06 163.72,36.2 v2(163.93,36.2)
DDR_A_D63: length 59.3
  IN5 w0.076: 151.36,73.17 151.36,73.39 151.37,73.4 151.37,73.71 150.66,74.41 150.66,81.8 150.04,82.42 v2(149.75,82.42)
  IN5 w0.097: 151.36,73.17 151.36,63.87 167.14,48.08 167.14,43.39 167.05,43.29 166.64,43.29 166.54,43.19 166.54,42.99 166.64,42.89 167.05,42.89 167.14,42.79 167.14,42.58 167.05,42.49 166.64,42.49 166.54,42.39 166.54,42.18 166.64,42.09 167.05,42.09 167.14,41.99 167.14,41.78 167.05,41.69 166.85,41.69 166.75,41.59 166.75,41.38 166.85,41.28 167.05,41.28 167.14,41.19 167.14,37.52 v2(167.68,36.99)
  BOTTOM w0.089: UH1.BB7 v2(149.75,82.42)
  BOTTOM w0.14: JDIMM1.246 166.08,35.79 167.27,36.99 v2(167.68,36.99)
DDR_A_DQS0: length 71.7
  IN1 w0.097: v2(137.96,79.47) 137.68,79.47 136.67,78.46 135.88,78.46 134.61,77.19 134.61,67.75 133.38,66.51 128.76,66.51 126.81,64.56 126.81,64.36 127.22,63.94 127.22,63.59 126.97,63.33 126.62,63.33 126.2,63.75 126,63.75 125.86,63.61 125.86,63.41 126.28,62.99 126.28,62.64 126.03,62.39 125.67,62.39 125.26,62.81 125.06,62.81 124.91,62.67 124.91,62.47 125.33,62.05 125.33,61.69 125.08,61.44 124.73,61.44 124.31,61.86 124.11,61.86 123.97,61.72 123.97,61.52 124.39,61.1 124.39,60.75 124.14,60.5 123.78,60.5 123.36,60.92 123.16,60.92 122.47,60.22 118.64,60.22 105.56,47.15 105.56,40.81 105.37,40.61 105.12,40.61 104.98,40.47 v2(104.98,40.38)
  BOTTOM w0.076: UH1.BP5 140.85,80.56 140.53,80.87 140.15,80.87 139.97,80.7 138.6,80.7 138.09,80.19 138.09,79.54 138.01,79.47 v2(137.96,79.47)
  BOTTOM w0.14: v2(104.98,40.38) 105.14,40.54 105.52,40.54 105.83,40.84 JDIMM1.13
DDR_A_DQS1: length 67.3
  IN1 w0.076: 139.01,70.99 139.01,71 139,71.01 139,71.07 138.99,71.08 138.99,73.55 138.63,73.91 138.63,74.91 139.31,75.59 139.52,75.59 139.7,75.41 v2(139.7,75.21)
  IN1 w0.097: v2(110.95,37.89) 110.76,37.71 110.61,37.71 110.51,37.8 110.51,46.1 120.43,56.03 128.8,56.03 139.01,66.23 139.01,70.99
  BOTTOM w0.076: UH1.BK3 143.46,79.49 143.39,79.41 143.39,78.73 143.77,78.35 143.77,77.89 142.68,76.8 142.68,76.72 142.66,76.7
  BOTTOM w0.14: v2(110.95,37.89) 110.97,37.89 111.6,37.26 111.6,36.32 110.96,35.69 110.96,35.56 111.07,35.45 JDIMM1.34 ; v2(139.7,75.21) 139.93,75.21 140.1,75.03 140.99,75.03 142.66,76.7
DDR_A_DQS2: length 67.9
  IN5 w0.076: 135.88,82.38 135.89,82.4 135.89,82.41 135.97,82.48 136.55,82.48 137.57,83.51 137.8,83.51 139.29,84.99 140.97,84.99 141.2,84.76 141.2,84.58 140.95,84.33 140.95,83.87 140.87,83.79 140.64,83.79 140.56,83.87 140.56,84.24 v2(140.57,84.24)
  IN5 w0.097: v2(150.56,39.79) 150.31,39.54 150.17,39.54 150.02,39.7 150.02,42.7 134.8,57.91 134.8,69.89 134.95,70.03 135.32,70.03 135.57,70.28 135.57,70.63 135.32,70.88 134.95,70.88 134.8,71.03 134.8,71.23 134.95,71.37 135.07,71.37 135.32,71.62 135.32,71.97 135.07,72.22 134.95,72.22 134.8,72.36 134.8,72.76 134.95,72.9 135.07,72.9 135.32,73.15 135.32,73.51 135.07,73.76 134.95,73.76 134.8,73.9 134.8,74.1 134.95,74.24 135.07,74.24 135.32,74.49 135.32,74.84 135.07,75.09 134.95,75.09 134.8,75.23 134.8,77.61 134.6,77.82 133.72,77.82 133.62,77.91 133.62,78.2 133.78,78.36 134.56,78.36 134.8,78.61 134.8,81.31 135.88,82.38
  BOTTOM w0.089: UH1.BR9 140.61,84.14 140.61,84.18 140.56,84.23 140.56,84.24 v2(140.57,84.24)
  BOTTOM w0.14: v2(150.56,39.79) 150.42,39.65 150.05,39.65 149.95,39.75 149.95,41.23 149.26,41.91 149.26,42.11 149.33,42.17 JDIMM1.179
DDR_A_DQS3: length 62.4
  IN5 w0.076: 141.84,76.35 141.86,76.36 141.86,76.38 142.95,77.47 142.95,77.6 142.95,77.6 142.95,82.12 143.22,82.39 143.22,82.88 143.13,82.96 143.13,83.71 143.22,83.8 143.33,83.8 143.41,83.72 v2(143.41,83.72)
  IN5 w0.097: 141.84,76.35 140.22,74.73 140.22,60.26 141.35,59.13 141.35,58.78 141.15,58.58 141.15,58.38 141.3,58.24 141.5,58.24 141.69,58.44 142.05,58.44 142.31,58.17 142.31,57.81 142.12,57.62 142.12,57.42 142.26,57.28 142.46,57.28 142.65,57.47 143.01,57.47 143.26,57.22 143.26,56.87 143.06,56.67 143.06,56.47 143.2,56.33 143.4,56.33 143.6,56.53 143.95,56.53 155.4,45.08 155.4,39.25 155.6,39.06 155.6,37.91 155.37,37.68 154.85,37.68 154.79,37.63 154.63,37.63 154.53,37.53 154.53,37.3 v2(154.62,37.22)
  BOTTOM w0.089: UH1.BJ9 143.8,83.26 143.68,83.13 143.52,83.13 143.28,83.37 143.28,83.6 143.41,83.72 v2(143.41,83.72)
  BOTTOM w0.14: JDIMM1.200 154.58,35.73 154.46,35.84 154.46,36.05 154.12,36.4 154.12,37.11 154.27,37.26 154.57,37.26 v2(154.62,37.22)
DDR_A_DQS4: length 68
  IN1 w0.076: v2(141.52,74.05) 141.56,74.05 141.67,73.95 142.05,73.56 144.29,71.32 144.29,71.01 144.28,71 144.28,70.99
  IN1 w0.097: 144.28,70.99 144.28,65.19 131.1,52.01 124.58,52.01 120.89,48.32 120.69,48.32 120.44,48.57 120.08,48.57 119.82,48.31 119.82,47.95 120.07,47.7 120.07,47.49 119.92,47.35 119.71,47.35 119.47,47.59 119.1,47.59 118.85,47.33 118.85,46.97 119.09,46.73 119.09,46.52 118.94,46.37 118.74,46.37 118.49,46.62 118.13,46.62 117.87,46.36 117.87,46 118.12,45.75 118.12,45.54 116.16,43.59 116.16,42.8 114.97,41.61 114.97,39.85 115.16,39.65 115.56,39.65 v2(115.6,39.62)
  BOTTOM w0.076: 144.77,75.43 144.78,75.45 144.78,75.53 145.88,76.62 145.88,79.41 145.95,79.49 UH1.BF3
  BOTTOM w0.14: 144.77,75.43 143,73.66 142.16,73.66 141.78,74.05 v2(141.52,74.05) ; v2(115.6,39.62) 115.83,39.85 116.14,39.85 116.45,40.15 116.45,41.1 116.21,41.33 116.21,41.76 116.33,41.87 JDIMM1.55
DDR_A_DQS5: length 62.5
  IN1 w0.076: 148.61,70.85 148.61,72.81 147.05,74.38 147.05,74.75 v2(146.78,75.02)
  IN1 w0.097: 148.61,70.85 148.61,63.56 132.76,47.71 130.02,47.71 122.87,40.56 122.87,40.18 121.82,39.14 121.82,37.86 122.08,37.61 122.56,37.61 122.63,37.53 v2(122.67,37.5)
  BOTTOM w0.076: UH1.BC3 148.47,79.49 148.39,79.41 148.39,75.65 148.45,75.6 148.45,75.52
  BOTTOM w0.14: v2(146.78,75.02) 146.94,75.02 147.31,74.65 148.09,74.65 148.45,75.01 148.45,75.52 ; v2(122.67,37.5) 122.49,37.68 122.48,37.67 121.77,37.67 121.46,37.37 121.46,35.84 121.58,35.73 JDIMM1.76
DDR_A_DQS6: length 60.6
  IN5 w0.076: 146.16,73.17 146.16,73.19 146.15,73.2 146.15,73.42 148.3,75.57 148.3,76.38 147.94,76.74 147.94,80.11 146.62,81.43 146.62,83.42 146.47,83.58 146.47,83.84 146.55,83.91 146.79,83.91 v2(146.98,83.72)
  IN5 w0.097: v2(160.49,40.11) 160.54,40.06 160.54,39.88 160.44,39.78 159.95,39.78 159.85,39.88 159.85,44.63 159.99,44.77 160.33,44.77 160.58,45.02 160.58,45.38 160.33,45.63 159.99,45.63 159.85,45.77 159.85,46.84 148.82,57.87 148.82,59.32 145.83,62.31 145.83,62.57 146.16,62.91 146.16,63.32 145.83,63.65 145.83,63.91 146.16,64.24 146.16,64.65 145.83,64.99 145.83,65.24 146.16,65.58 146.16,65.99 145.83,66.32 145.83,66.58 146.16,66.91 146.16,67.33 145.83,67.66 145.83,67.92 146.16,68.25 146.16,68.66 145.83,69 145.83,69.25 146.16,69.59 146.16,70 145.83,70.33 145.83,70.59 146.16,70.92 146.16,71.33 145.83,71.67 145.83,71.92 146.16,72.26 146.16,73.17
  BOTTOM w0.089: UH1.BF9 v2(146.98,83.72)
  BOTTOM w0.14: v2(160.49,40.11) 160.24,39.85 159.94,39.85 159.83,39.85 159.71,39.96 159.71,41.76 159.82,41.87 JDIMM1.221
DDR_A_DQS7: length 59.5
  IN5 w0.076: 150.63,73.17 150.63,73.27 150.62,73.28 150.62,74.22 150.49,74.35 150.49,81.59 150.01,82.07 149.81,82.07 149.6,82.07 149.39,82.27 149.39,83.37 v2(149.75,83.72)
  IN5 w0.097: 150.63,73.17 150.63,63.56 165.81,48.38 165.81,48.26 165.81,39.3 165.93,39.19 166.22,39.19 166.31,39.29 166.3,39.48 v2(166.25,39.53)
  BOTTOM w0.089: UH1.BB9 v2(149.75,83.72)
  BOTTOM w0.14: v2(166.25,39.53) 166.35,39.42 166.35,39.42 166.6,39.42 166.83,39.42 167.22,39.03 167.22,38.8 167.22,38.43 164.96,36.18 164.96,35.84 165.08,35.73 JDIMM1.242
DDR_A_DQS#0: length 71.6
  IN1 w0.097: v2(138.46,79.82) 138.18,79.82 138.11,79.89 137.82,79.89 137.56,79.63 137.56,79.61 136.59,78.64 135.8,78.64 134.43,77.27 134.43,67.83 133.3,66.7 128.68,66.7 126.62,64.63 126.62,64.28 127.04,63.86 127.04,63.66 126.9,63.52 126.7,63.52 126.28,63.94 125.92,63.94 125.67,63.69 125.67,63.33 126.09,62.92 126.09,62.72 125.95,62.57 125.75,62.57 125.33,62.99 124.98,62.99 124.73,62.74 124.73,62.39 125.15,61.97 125.15,61.77 125,61.63 124.81,61.63 124.39,62.05 124.03,62.05 123.78,61.8 123.78,61.44 124.2,61.03 124.2,60.83 124.06,60.68 123.86,60.68 123.44,61.1 123.09,61.1 122.39,60.41 118.56,60.41 105.38,47.22 105.38,41.03 105.28,40.94 105.07,40.94 v2(104.99,41.01)
  BOTTOM w0.076: v2(138.46,79.82) 138.28,80 138.28,80.15 138.67,80.54 140.04,80.54 140.22,80.71 140.47,80.71 140.65,80.52 140.65,80.44 140.73,80.37 140.73,80.22 140.65,80.15 140.41,80.15 140.31,80.24 UH1.BR5
  BOTTOM w0.14: v2(104.99,41.01) 105.18,40.82 105.41,40.82 105.55,40.96 105.55,41.65 105.33,41.87 JDIMM1.11
DDR_A_DQS#1: length 67.2
  IN1 w0.076: 138.82,70.99 138.82,73.48 138.46,73.84 138.46,74.98 139.24,75.76 139.59,75.76 139.8,75.55 140,75.55 140.08,75.62 v2(140.08,75.68)
  IN1 w0.097: v2(110.91,37.31) 110.91,37.4 110.79,37.52 110.53,37.52 110.32,37.73 110.32,46.18 120.36,56.21 128.73,56.21 138.82,66.31 138.82,70.99
  BOTTOM w0.076: 142.47,76.9 142.48,76.92 142.56,76.92 143.6,77.96 143.6,78.29 143.22,78.66 143.22,79.41 143.15,79.49 UH1.BL3
  BOTTOM w0.14: v2(110.91,37.31) 110.95,37.35 111.11,37.35 111.32,37.15 111.32,36.44 110.69,35.81 110.69,35.57 110.58,35.46 JDIMM1.32 ; 142.47,76.9 140.88,75.31 140.22,75.31 140.08,75.45 v2(140.08,75.68)
DDR_A_DQS#2: length 68
  IN5 w0.076: 135.73,82.49 135.76,82.53 135.78,82.53 135.9,82.65 136.48,82.65 137.5,83.67 137.73,83.67 139.22,85.16 141.03,85.16 141.36,84.83 v2(141.36,84.25)
  IN5 w0.097: v2(150.56,39.21) 150.4,39.37 150.38,39.36 150.25,39.36 150.09,39.36 149.83,39.62 149.83,42.62 134.62,57.83 134.62,69.97 134.87,70.22 135.25,70.22 135.39,70.36 135.39,70.56 135.25,70.7 134.87,70.7 134.62,70.95 134.62,71.3 134.87,71.55 134.99,71.55 135.13,71.69 135.13,71.89 134.99,72.03 134.87,72.03 134.62,72.28 134.62,72.84 134.87,73.09 134.99,73.09 135.13,73.23 135.13,73.43 134.99,73.57 134.87,73.57 134.62,73.82 134.62,74.17 134.87,74.42 134.99,74.42 135.13,74.57 135.13,74.77 134.99,74.91 134.87,74.91 134.62,75.16 134.62,77.53 134.52,77.63 133.64,77.63 133.43,77.84 133.43,78.28 133.7,78.55 134.48,78.55 134.62,78.69 134.62,81.39 135.73,82.49
  BOTTOM w0.089: UH1.BP9 141.29,84.24 141.35,84.24 v2(141.36,84.25)
  BOTTOM w0.14: v2(150.56,39.21) 150.39,39.37 149.94,39.37 149.67,39.64 149.67,41.11 148.99,41.8 148.99,41.91 148.82,42.07 JDIMM1.177
DDR_A_DQS#3: length 62.4
  IN5 w0.076: 141.71,76.48 141.73,76.5 141.74,76.5 142.78,77.54 142.78,77.67 142.78,77.67 142.78,82.19 142.99,82.4 142.99,82.87 142.97,82.89 142.97,83.81 143.2,84.06 143.2,84.08 143.41,84.32 v2(143.41,84.43)
  IN5 w0.097: v2(154.62,38.03) 154.76,37.89 155.31,37.89 155.41,37.99 155.41,38.98 155.22,39.17 155.22,45 143.88,56.34 143.68,56.34 143.48,56.14 143.13,56.14 142.88,56.4 142.88,56.75 143.07,56.95 143.07,57.15 142.93,57.29 142.73,57.29 142.53,57.09 142.18,57.09 141.93,57.34 141.93,57.69 142.13,57.89 142.13,58.09 141.97,58.25 141.77,58.25 141.57,58.05 141.22,58.05 140.97,58.3 140.97,58.66 141.17,58.85 141.17,59.05 140.04,60.18 140.04,74.81 141.71,76.48
  BOTTOM w0.089: v2(143.41,84.43) 143.4,84.31 UH1.BL9
  BOTTOM w0.14: JDIMM1.198 154.08,35.73 154.19,35.84 154.19,35.94 153.84,36.29 153.84,37.3 154.56,38.03 v2(154.62,38.03)
DDR_A_DQS#4: length 67.8
  IN1 w0.076: 144.47,70.99 144.47,71.01 144.46,71.02 144.46,71.39 141.99,73.86 141.99,73.97 142.29,74.27 142.29,74.44 142.17,74.56 141.93,74.56 v2(141.88,74.51)
  IN1 w0.097: 144.47,70.99 144.47,65.11 131.18,51.82 124.66,51.82 120.97,48.13 120.61,48.13 120.36,48.38 120.15,48.38 120.01,48.23 120.01,48.02 120.25,47.78 120.25,47.42 120,47.16 119.63,47.16 119.39,47.41 119.18,47.41 119.03,47.26 119.03,47.05 119.28,46.8 119.28,46.44 119.02,46.19 118.66,46.19 118.41,46.43 118.21,46.43 118.06,46.28 118.06,46.08 118.3,45.83 118.3,45.47 116.35,43.51 116.35,42.73 115.15,41.53 115.15,39.99 115.25,39.89 115.3,39.89 115.43,40.02 115.6,40.02 115.65,40.07 115.65,40.25 v2(115.6,40.31)
  BOTTOM w0.076: 144.57,75.63 144.59,75.65 144.67,75.65 145.71,76.69 145.71,79.41 145.64,79.49 UH1.BG3
  BOTTOM w0.14: 144.57,75.63 142.88,73.94 v3(142.56,73.94) 142.28,73.94 141.88,74.34 v2(141.88,74.51) ; JDIMM1.53 115.83,41.87 115.94,41.76 115.94,41.45 115.93,41.45 115.93,41.22 116.17,40.98 116.17,40.27 116.03,40.13 115.77,40.13 v2(115.6,40.31)
DDR_A_DQS#5: length 62.6
  IN1 w0.076: 148.8,70.85 148.8,70.86 148.79,70.87 148.79,70.92 148.78,70.93 148.78,72.88 147.22,74.45 147.22,75.32 v2(147.25,75.36)
  IN1 w0.097: v2(122.73,38.2) 122.78,38.16 122.78,38 122.69,37.9 122.5,37.9 122.4,37.79 122.16,37.79 122.01,37.94 122.01,39.06 123.06,40.1 123.06,40.49 130.09,47.52 132.84,47.52 148.8,63.48 148.8,70.85
  BOTTOM w0.076: UH1.BD3 148.15,79.49 148.23,79.41 148.23,75.51 148.17,75.45 148.17,75.43
  BOTTOM w0.14: v2(122.73,38.2) 122.62,38.2 122.36,37.95 121.65,37.95 121.19,37.48 121.19,35.84 121.07,35.73 JDIMM1.74 ; 148.17,75.43 148.17,75.12 147.97,74.93 147.43,74.93 147.25,75.1 v2(147.25,75.36)
DDR_A_DQS#6: length 60.7
  IN5 w0.076: 145.98,73.17 145.98,73.19 145.99,73.2 145.99,73.49 148.13,75.64 148.13,76.31 147.78,76.67 147.78,80.04 146.46,81.36 146.46,83.35 v2(146.09,83.72)
  IN5 w0.097: v2(160.5,39.34) 160.24,39.59 159.87,39.59 159.66,39.8 159.66,44.71 159.91,44.96 160.25,44.96 160.39,45.1 160.39,45.3 160.25,45.44 159.91,45.44 159.66,45.69 159.66,46.76 148.63,57.79 148.63,59.25 145.64,62.24 145.64,62.65 145.98,62.98 145.98,63.24 145.64,63.57 145.64,63.98 145.98,64.32 145.98,64.58 145.64,64.91 145.64,65.32 145.98,65.65 145.98,65.91 145.64,66.25 145.64,66.66 145.98,66.99 145.98,67.25 145.64,67.58 145.64,67.99 145.98,68.33 145.98,68.58 145.64,68.92 145.64,69.33 145.98,69.66 145.98,69.92 145.64,70.25 145.64,70.67 145.98,71 145.98,71.26 145.64,71.59 145.64,72 145.98,72.34 145.98,73.17
  BOTTOM w0.089: v2(146.09,83.72) 146.09,83.73 146.05,83.77 145.8,83.77 145.63,83.6 UH1.BG9
  BOTTOM w0.14: JDIMM1.219 159.33,41.87 159.44,41.76 159.44,39.84 159.71,39.57 160.06,39.57 160.27,39.57 v2(160.5,39.34)
DDR_A_DQS#7: length 59.5
  IN5 w0.076: 150.44,73.17 150.44,73.18 150.45,73.19 150.45,74.15 150.33,74.28 150.33,81.52 149.94,81.9 149.88,81.9 149.53,81.9 149.23,82.21 149.23,83.57 149.07,83.72 v2(148.83,83.72)
  IN5 w0.097: 150.44,73.17 150.44,63.49 165.63,48.3 165.63,48.18 165.63,39.23 165.85,39 166.14,39 166.14,38.99 166.19,38.99 166.28,38.9 v2(166.28,38.78)
  BOTTOM w0.089: v2(148.83,83.72) 148.57,83.53 UH1.BC9
  BOTTOM w0.14: v2(166.28,38.78) 166.28,38.96 166.47,39.14 166.71,39.14 166.94,38.92 166.94,38.55 164.69,36.29 164.69,35.84 164.57,35.73 JDIMM1.240
DDR_A_MA0: length 66.9
  IN2 w0.145: v2(156.03,75.15) 155.87,74.99 155.87,73.94 156.16,73.65 156.41,73.65 156.63,73.43 156.63,66.42 154.99,64.78 154.99,64.55 155.22,64.32 155.22,64.09 155.06,63.93 154.83,63.93 154.6,64.16 154.38,64.16 154.21,64 154.21,63.77 154.44,63.54 154.44,63.31 154.28,63.15 154.05,63.15 153.82,63.38 153.6,63.38 153.43,63.22 153.43,62.99 153.66,62.76 153.66,62.53 153.5,62.37 153.28,62.37 153.04,62.6 152.82,62.6 152.65,62.44 152.65,62.21 152.89,61.98 152.89,61.75 152.72,61.59 152.5,61.59 152.26,61.82 152.04,61.82 151.87,61.66 151.87,61.43 152.11,61.2 152.11,60.97 151.94,60.81 151.72,60.81 151.48,61.04 151.26,61.04 151.09,60.88 151.09,60.65 151.33,60.42 151.33,60.19 151.16,60.03 150.94,60.03 150.7,60.26 150.48,60.26 150.22,60.01 150.22,59.78 150.52,59.49 150.52,59.26 150.36,59.1 150.13,59.1 149.83,59.39 149.61,59.39 149.44,59.23 149.44,59 149.74,58.71 149.74,58.48 149.58,58.32 149.35,58.32 149.06,58.61 148.83,58.61 148.67,58.45 148.67,58.22 148.96,57.93 148.96,57.7 148.8,57.54 148.57,57.54 148.28,57.83 148.05,57.83 139.03,48.81 139.03,38.84 140.32,37.54 v2(140.49,37.54)
  BOTTOM w0.076: 156.16,75.81 157.52,77.17 159.7,77.17 160.02,77.49 160.02,78.99 UH1.AH3
  BOTTOM w0.213: v2(156.03,75.15) 156.03,75.68 156.16,75.81 ; JDIMM1.144 138.58,37.02 139.1,37.54 v2(140.49,37.54)
DDR_A_MA1: length 60.5
  IN2 w0.076: 155.17,73.2 155.17,73.39 155.11,73.46 155.11,76.36 155.23,76.48 155.23,77.75 155.03,77.95 v2(154.17,77.95)
  IN2 w0.145: v2(135.79,40.37) 135.57,40.58 135.57,42.44 137,43.86 137,49.55 137.99,50.54 137.99,50.54 138.35,50.9 138.77,51.32 138.77,51.32 139.13,51.68 139.55,52.1 139.55,52.1 139.91,52.46 140.69,53.24 140.69,53.24 141.11,53.66 141.47,54.01 141.47,54.02 148.95,61.5 148.95,62.96 150.01,64.02 150.24,64.02 150.74,63.52 150.97,63.52 151.13,63.68 151.13,63.91 150.63,64.41 150.63,64.64 150.79,64.8 151.02,64.8 151.52,64.3 151.75,64.3 151.91,64.46 151.91,64.69 151.41,65.19 151.41,65.42 151.57,65.58 151.8,65.58 152.3,65.08 152.53,65.08 152.69,65.24 152.69,65.47 152.19,65.97 152.19,66.2 152.35,66.36 152.58,66.36 153.08,65.86 153.31,65.86 153.47,66.02 153.47,66.25 152.97,66.75 152.97,66.98 153.13,67.14 153.36,67.14 153.86,66.64 154.09,66.64 155.17,67.73 155.17,73.2
  BOTTOM w0.076: v2(154.17,77.95) 154.24,77.89 154.7,77.89 155.04,78.22 155.04,78.8 155.19,78.95 155.19,79.84 UH1.AP4
  BOTTOM w0.213: JDIMM1.133 135.82,40.4 v2(135.79,40.37)
DDR_A_MA2: length 67.4
  IN2 w0.145: v2(135.79,36.54) 136.95,37.7 136.95,41.86 138.16,43.08 138.16,48.61 143.32,53.78 143.32,54.01 143.14,54.19 143.14,54.42 143.3,54.58 143.53,54.58 143.71,54.4 143.94,54.4 144.1,54.56 144.1,54.79 143.92,54.97 143.92,55.2 144.08,55.36 144.31,55.36 144.49,55.17 144.72,55.17 144.88,55.34 144.88,55.56 144.7,55.75 144.7,55.98 144.86,56.14 145.09,56.14 145.27,55.95 145.5,55.95 145.69,56.15 145.69,56.38 145.51,56.56 145.51,56.79 145.67,56.95 145.9,56.95 146.08,56.77 146.31,56.77 146.47,56.93 146.47,57.16 146.29,57.34 146.29,57.57 146.45,57.73 146.68,57.73 146.86,57.55 147.09,57.55 147.25,57.71 147.25,57.94 147.07,58.12 147.07,58.35 147.23,58.51 147.46,58.51 147.64,58.33 147.87,58.33 148.03,58.49 148.03,58.72 147.85,58.9 147.85,59.13 148.01,59.29 148.24,59.29 148.42,59.11 148.65,59.11 148.81,59.27 148.81,59.5 148.63,59.68 148.63,59.91 148.79,60.07 149.02,60.07 149.2,59.89 149.43,59.89 149.59,60.05 149.59,60.27 149.41,60.46 149.41,60.69 149.57,60.85 149.8,60.85 149.98,60.66 150.21,60.66 150.37,60.83 150.37,61.05 150.19,61.24 150.19,61.47 150.35,61.63 150.58,61.63 150.76,61.44 150.99,61.44 151.15,61.61 151.15,61.83 150.97,62.02 150.97,62.25 151.13,62.41 151.36,62.41 151.54,62.22 151.77,62.22 151.93,62.39 151.93,62.61 151.75,62.8 151.75,63.03 151.91,63.19 152.14,63.19 152.32,63 152.55,63 152.71,63.17 152.71,63.39 152.53,63.58 152.53,63.81 152.69,63.97 152.92,63.97 153.1,63.78 153.33,63.78 153.49,63.95 153.49,64.17 153.31,64.36 153.31,64.59 153.47,64.75 153.7,64.75 153.88,64.56 154.11,64.56 154.27,64.73 154.27,64.95 154.09,65.14 154.09,65.37 154.25,65.53 154.48,65.53 154.66,65.34 154.89,65.34 155.05,65.5 155.05,65.73 154.87,65.92 154.87,66.15 155.03,66.31 155.26,66.31 155.44,66.12 155.67,66.12 156.12,66.58 156.12,73.18 155.64,73.67 155.63,73.67 155.61,73.68 155.61,75.83 v2(156.1,76.31)
  BOTTOM w0.076: UH1.AN4 156.67,79.69 156.67,77.9 156.1,77.33 156.1,76.32 v2(156.1,76.31)
  BOTTOM w0.213: JDIMM1.132 135.58,35.69 135.79,35.91 v2(135.79,36.54)
DDR_A_MA3: length 60.5
  IN2 w0.145: v2(135.81,39.1) 135.89,39.1 136.44,39.64 136.44,42.07 137.58,43.22 137.58,49.49 138.18,50.09 138.41,50.09 138.59,49.91 138.82,49.91 138.98,50.07 138.98,50.3 138.8,50.48 138.8,50.71 138.96,50.87 139.19,50.87 139.37,50.69 139.6,50.69 139.76,50.85 139.76,51.08 139.58,51.26 139.58,51.49 139.74,51.65 139.97,51.65 140.15,51.47 140.38,51.47 140.54,51.63 140.54,51.86 140.36,52.04 140.36,52.27 140.52,52.43 140.74,52.43 140.93,52.25 141.16,52.25 141.32,52.41 141.32,52.64 141.13,52.82 141.13,53.05 141.3,53.21 141.52,53.21 141.71,53.03 141.94,53.03 142.1,53.19 142.1,53.42 141.91,53.6 141.91,53.83 150.07,61.98 150.07,62.21 149.57,62.71 149.57,62.94 149.73,63.1 149.96,63.1 150.46,62.6 150.68,62.6 155.65,67.57 155.65,73.27 155.36,73.56 155.36,76.23 155.84,76.71 v2(155.84,79.8)
  BOTTOM w0.076: v2(155.84,79.8) 155.84,79.87 155.78,79.94 155.78,80.49 UH1.AP5
  BOTTOM w0.213: JDIMM1.131 135.33,42.07 135.07,41.81 135.07,39.37 135.34,39.1 v2(135.81,39.1)
DDR_A_MA4: length 65.1
  IN2 w0.145: v2(154.68,76.51) 154.73,76.47 154.73,69.62 147.84,62.74 147.84,62.51 148.27,62.08 148.27,61.85 148.11,61.69 147.88,61.69 147.45,62.12 147.22,62.12 147.06,61.96 147.06,61.73 147.49,61.3 147.49,61.07 147.33,60.91 147.1,60.91 146.67,61.34 146.44,61.34 146.28,61.18 146.28,60.95 146.71,60.52 146.71,60.29 146.55,60.13 146.32,60.13 145.89,60.56 145.66,60.56 145.5,60.4 145.5,60.17 145.93,59.74 145.93,59.51 145.77,59.35 145.54,59.35 145.11,59.78 144.88,59.78 144.72,59.62 144.72,59.39 145.15,58.96 145.15,58.73 144.99,58.57 144.76,58.57 144.33,59 144.1,59 143.94,58.84 143.94,58.61 144.37,58.18 144.37,57.95 144.21,57.79 143.98,57.79 143.55,58.22 143.32,58.22 143.16,58.06 143.16,57.83 143.59,57.4 143.59,57.17 143.43,57.01 143.2,57.01 142.77,57.44 142.54,57.44 142.38,57.28 142.38,57.05 142.99,56.44 142.99,56.24 136.28,49.53 136.28,43.87 135.07,42.65 135.07,38.03 135.27,37.83 v2(135.79,37.83)
  BOTTOM w0.076: v2(154.68,76.51) 154.38,76.81 154.38,77.33 155.2,78.16 155.2,78.56 UH1.AP2
  BOTTOM w0.213: v2(135.79,37.83) 135.38,37.83 135.15,37.59 135.15,36.03 134.93,35.81 134.92,35.81 134.69,35.58 134.69,35.57 134.58,35.46 JDIMM1.128
DDR_A_MA5: length 63.9
  IN2 w0.145: v2(133.77,38.88) 133.77,38.89 133.78,38.88 134.22,38.88 134.48,39.15 134.48,43.12 135.36,43.99 135.36,49.24 138.21,52.09 138.21,52.32 137.61,52.92 137.61,53.15 137.78,53.31 138,53.31 138.6,52.71 138.83,52.71 138.99,52.87 138.99,53.1 138.39,53.7 138.39,53.93 138.56,54.09 138.78,54.09 139.38,53.49 139.61,53.49 139.77,53.65 139.77,53.88 139.17,54.48 139.17,54.71 139.34,54.87 139.56,54.87 140.16,54.27 140.39,54.27 140.55,54.43 140.55,54.66 139.95,55.26 139.95,55.49 140.11,55.65 140.34,55.65 140.94,55.05 141.17,55.05 141.33,55.21 141.33,55.44 140.73,56.04 140.73,56.27 140.89,56.43 141.12,56.43 141.72,55.83 141.95,55.83 142.11,55.99 142.11,56.22 141.51,56.82 141.51,57.05 154.28,69.81 154.28,73.27 154.28,73.27 154.28,73.37 154.34,73.43 154.34,75.21 154.22,75.34 154.22,76.63 v2(154.73,77.14)
  BOTTOM w0.076: UH1.AP1 155.48,78.13 155.08,77.73 155.08,77.34 154.89,77.14 v2(154.73,77.14)
  BOTTOM w0.213: JDIMM1.126 134.07,35.61 134.46,36 134.46,36.41 134.46,36.42 134.46,38.6 134.17,38.89 133.77,38.89 v2(133.77,38.88)
DDR_A_MA6: length 67.9
  IN2 w0.145: v2(133.82,41.22) 133.82,43.17 134.41,43.76 134.41,50.57 134.64,50.81 134.87,50.81 135.47,50.21 135.69,50.21 135.85,50.38 135.85,50.6 135.26,51.2 135.26,51.43 135.42,51.59 135.65,51.59 136.24,50.99 136.47,50.99 136.63,51.16 136.63,51.38 136.04,51.98 136.04,52.21 136.2,52.37 136.43,52.37 137.02,51.77 137.25,51.77 137.41,51.94 137.41,52.16 136.82,52.76 136.82,52.99 148.4,64.57 148.4,64.8 147.87,65.33 147.87,65.56 148.03,65.72 148.26,65.72 148.79,65.19 149.02,65.19 149.18,65.35 149.18,65.58 148.65,66.11 148.65,66.34 148.81,66.5 149.04,66.5 149.57,65.97 149.8,65.97 149.96,66.13 149.96,66.36 149.43,66.89 149.43,67.12 149.59,67.28 149.82,67.28 150.35,66.75 150.58,66.75 150.96,67.13 150.96,67.35 150.46,67.86 150.46,68.08 150.62,68.25 150.85,68.25 151.35,67.74 151.58,67.74 151.74,67.91 151.74,68.13 151.23,68.64 151.23,68.86 151.4,69.03 151.62,69.03 152.13,68.52 152.36,68.52 152.52,68.69 152.52,68.91 152.01,69.42 152.01,69.64 152.18,69.81 152.4,69.81 152.91,69.3 153.13,69.3 153.83,69.99 153.83,73.3 153.96,73.43 153.96,75.6 v2(153.07,76.48)
  BOTTOM w0.076: UH1.AP3 155.78,79.19 155.78,77.95 155.25,77.42 155.25,76.53 154.83,76.11 v1(154.34,76.11) 153.44,76.11 v2(153.07,76.48)
  BOTTOM w0.213: JDIMM1.127 134.33,41.72 v2(133.82,41.22)
DDR_A_MA7: length 67.3
  IN2 w0.145: v2(152.93,75.06) 152.93,75.02 153.36,74.59 153.36,73.68 152.35,72.67 152.35,71.32 140.34,59.31 140.34,59.08 140.87,58.55 140.87,58.32 140.71,58.16 140.48,58.16 139.95,58.69 139.72,58.69 139.56,58.53 139.56,58.3 140.09,57.77 140.09,57.54 139.93,57.38 139.71,57.38 139.17,57.91 138.94,57.91 138.78,57.75 138.78,57.52 139.32,56.99 139.32,56.76 139.15,56.6 138.93,56.6 138.39,57.13 138.16,57.13 138,56.97 138,56.74 138.54,56.21 138.54,55.98 138.37,55.82 138.15,55.82 137.61,56.35 137.38,56.35 137.22,56.19 137.22,55.96 137.76,55.43 137.76,55.2 137.56,55 137.33,55 136.87,55.47 136.64,55.47 136.48,55.31 136.48,55.08 136.94,54.61 136.94,54.39 136.78,54.22 136.55,54.22 136.09,54.69 135.86,54.69 135.7,54.53 135.7,54.3 136.16,53.83 136.16,53.61 132.69,50.13 132.69,43.4 132.69,43.39 132.69,40.23 132.69,40.22 132.69,38.15 132.97,37.87 133.91,37.87 134.28,37.5 134.28,36.48 133.89,36.09 v2(133.65,36.09)
  BOTTOM w0.076: v2(152.93,75.06) 153.08,74.91 v1(153.94,74.91) 154.12,74.91 155.58,76.37 155.58,77.28 156.11,77.81 156.11,78.07 UH1.AN1
  BOTTOM w0.213: v2(133.65,36.09) 133.29,36.09 133.07,35.88 JDIMM1.122
DDR_A_MA8: length 68.2
  IN2 w0.145: v2(133.82,40.05) 133.5,40.05 133.14,40.41 133.14,43.21 133.9,43.97 133.9,50.7 141.91,58.71 141.91,58.94 141.37,59.47 141.37,59.7 141.54,59.86 141.76,59.86 142.3,59.33 142.53,59.33 142.69,59.49 142.69,59.72 142.15,60.25 142.15,60.48 142.32,60.64 142.54,60.64 143.08,60.11 143.31,60.11 143.47,60.27 143.47,60.5 142.93,61.03 142.93,61.26 143.1,61.42 143.32,61.42 143.86,60.89 144.09,60.89 144.25,61.05 144.25,61.28 143.71,61.81 143.71,62.04 143.88,62.2 144.1,62.2 144.64,61.67 144.87,61.67 145.03,61.83 145.03,62.06 144.49,62.59 144.49,62.82 144.66,62.98 144.88,62.98 145.42,62.45 145.65,62.45 145.81,62.61 145.81,62.84 145.27,63.37 145.27,63.6 145.44,63.76 145.66,63.76 146.2,63.23 146.43,63.23 146.59,63.39 146.59,63.62 146.05,64.15 146.05,64.38 146.21,64.54 146.44,64.54 146.98,64.01 147.2,64.01 147.37,64.17 147.37,64.4 146.83,64.93 146.83,65.16 153.33,71.66 153.33,73.19 153.64,73.49 153.64,75.28 v2(153.07,75.85)
  BOTTOM w0.076: v2(153.07,75.85) 153.07,75.59 153.4,75.26 154.21,75.26 155.41,76.46 155.41,77.35 155.94,77.88 155.94,79.21 UH1.AN3
  BOTTOM w0.213: v2(133.82,40.05) 133.69,40.17 133.32,40.17 133.03,40.46 133.03,41.34 133.76,42.07 133.76,42.07 133.82,42.13 JDIMM1.125
DDR_A_MA9: length 64.1
  IN2 w0.145: v2(153.32,79.81) 153.72,79.42 153.72,79.32 153.72,78.68 153.72,77.76 152.25,76.29 152.25,74.64 151.45,73.85 151.45,73.39 151.45,73.39 151.45,72.83 148.23,69.6 148.23,69.37 148.5,69.09 148.5,68.87 148.34,68.7 148.11,68.7 147.84,68.98 147.61,68.98 147.45,68.82 147.45,68.59 147.72,68.31 147.72,68.09 147.56,67.92 147.33,67.92 147.06,68.2 146.83,68.2 146.67,68.04 146.67,67.81 146.94,67.53 146.94,67.31 146.78,67.14 146.55,67.14 146.28,67.42 146.05,67.42 145.89,67.26 145.89,67.03 146.16,66.75 146.16,66.53 146,66.36 145.77,66.36 145.5,66.64 145.27,66.64 145.11,66.48 145.11,66.25 145.39,65.97 145.39,65.75 145.22,65.58 145,65.58 144.72,65.86 144.49,65.86 144.33,65.7 144.33,65.47 144.61,65.19 144.61,64.97 144.44,64.81 144.22,64.81 143.94,65.08 143.71,65.08 143.55,64.92 143.55,64.69 143.83,64.42 143.83,64.19 131.08,51.44 131.08,38.18 v2(131.29,37.96)
  BOTTOM w0.076: UH1.AT4 153.65,80.14 v2(153.32,79.81)
  BOTTOM w0.213: v2(131.29,37.96) 131.29,40.07 132.82,41.6 JDIMM1.121
DDR_A_MA10: length 65.6
  IN2 w0.145: v2(140.48,36.3) 140.62,36.44 140.77,36.44 141.21,36.88 141.21,40.19 141.1,40.29 141.1,40.33 140.73,40.7 140.7,40.7 139.87,41.53 139.87,49.02 141.3,50.45 141.53,50.45 141.79,50.19 142.02,50.19 142.18,50.35 142.18,50.58 141.92,50.84 141.92,51.07 142.08,51.23 142.31,51.23 142.57,50.97 142.8,50.97 142.96,51.13 142.96,51.36 142.7,51.62 142.7,51.85 142.92,52.07 143.15,52.07 143.44,51.78 143.67,51.78 143.83,51.94 143.83,52.17 143.54,52.46 143.54,52.69 143.7,52.85 143.93,52.85 144.22,52.56 144.45,52.56 144.61,52.72 144.61,52.95 144.32,53.24 144.32,53.47 144.48,53.63 144.71,53.63 145,53.34 145.23,53.34 145.39,53.5 145.39,53.73 145.1,54.02 145.1,54.25 145.26,54.41 145.49,54.41 145.78,54.12 146.01,54.12 146.17,54.28 146.17,54.51 145.88,54.8 145.88,55.03 146.04,55.19 146.27,55.19 146.56,54.9 146.79,54.9 146.95,55.06 146.95,55.29 146.66,55.58 146.66,55.81 146.82,55.97 147.05,55.97 147.34,55.68 147.57,55.68 147.73,55.84 147.73,56.07 147.44,56.36 147.44,56.59 147.6,56.75 147.83,56.75 148.12,56.46 148.35,56.46 157.32,65.43 157.32,73.38 156.5,74.2 v2(156.29,74.2)
  BOTTOM w0.076: UH1.AH2 160.22,78.55 160.22,77.46 159.7,76.94 157.72,76.94 157.34,76.56
  BOTTOM w0.213: v2(140.48,36.3) 141.08,35.71 JDIMM1.146 ; 157.34,76.56 157.24,76.56 156.76,76.08 156.76,74.97 156.6,74.82 v1(156.6,74.7) 156.6,74.42 156.38,74.2 v2(156.29,74.2)
DDR_A_MA11: length 67.8
  IN2 w0.145: v2(133.64,37.26) 133.54,37.37 132.75,37.37 131.93,38.19 131.93,38.23 131.59,38.57 131.59,51.31 132.06,51.79 132.29,51.79 132.89,51.19 133.12,51.19 133.28,51.36 133.28,51.58 132.68,52.18 132.68,52.41 132.84,52.57 133.07,52.57 133.67,51.97 133.9,51.97 134.06,52.14 134.06,52.36 133.46,52.96 133.46,53.19 133.62,53.35 133.85,53.35 134.45,52.75 134.68,52.75 134.84,52.92 134.84,53.14 134.24,53.74 134.24,53.97 149.28,69 149.28,69.23 149,69.51 149,69.74 149.16,69.9 149.39,69.9 149.67,69.62 149.89,69.62 150.06,69.78 150.06,70.01 149.78,70.29 149.78,70.52 149.94,70.68 150.17,70.68 150.45,70.4 150.67,70.4 150.84,70.56 150.84,70.79 150.56,71.07 150.56,71.3 150.72,71.46 150.95,71.46 151.23,71.18 151.45,71.18 151.9,71.63 151.9,73.08 152.64,73.81 152.92,73.81 152.95,73.84 v2(152.97,73.84)
  BOTTOM w0.076: UH1.AN2 156.5,78.56 156.5,78.07 156.27,77.84 156.27,77.74 155.74,77.21 155.74,75.91 153.87,74.04
  BOTTOM w0.213: 153.87,74.04 v1(153.52,73.69) 153.12,73.69 v2(152.97,73.84) ; v2(133.64,37.26) 133.3,37.6 132.25,37.6 132.04,37.39 132.04,36.05 132.58,35.51 JDIMM1.120
DDR_A_MA12: length 66.4
  IN2 w0.145: v2(152.89,77.62) 151.95,76.68 151.95,75.36 151,74.41 151,73.01 142.74,64.75 142.74,64.52 143.02,64.25 143.02,64.02 142.86,63.86 142.63,63.86 142.35,64.13 142.12,64.13 141.96,63.97 141.96,63.74 142.24,63.47 142.24,63.24 142.08,63.08 141.85,63.08 141.57,63.35 141.34,63.35 141.18,63.19 141.18,62.97 141.46,62.69 141.46,62.46 141.3,62.3 141.07,62.3 140.79,62.58 140.57,62.58 140.4,62.41 140.4,62.19 140.68,61.91 140.68,61.68 140.52,61.52 140.29,61.52 140.01,61.8 139.79,61.8 139.62,61.63 139.62,61.41 139.9,61.13 139.9,60.9 139.74,60.74 139.51,60.74 139.23,61.02 139.01,61.02 138.84,60.85 138.84,60.63 139.12,60.35 139.12,60.12 138.96,59.96 138.73,59.96 138.45,60.24 138.23,60.24 138.06,60.07 138.06,59.85 138.34,59.57 138.34,59.34 138.18,59.18 137.95,59.18 137.67,59.46 137.45,59.46 137.28,59.29 137.28,59.07 137.56,58.79 137.56,58.56 137.4,58.4 137.17,58.4 136.89,58.68 136.67,58.68 136.5,58.52 136.5,58.29 136.78,58.01 136.78,57.78 130.63,51.63 130.63,39.38 129.64,38.39 v2(129.31,38.39)
  BOTTOM w0.076: v2(152.89,77.62) 152.67,77.84 152.67,79.79 152.71,79.88 UH1.AU4
  BOTTOM w0.213: JDIMM1.119 132.33,41.81 130.67,40.15 130.67,39.63 129.44,38.39 v2(129.31,38.39)
DDR_A_MA13: length 70.2
  IN2 w0.145: v2(145.01,35.97) 144.59,36.39 144.59,47.17 146.06,48.64 146.06,48.87 145.91,49.02 145.91,49.25 146.07,49.41 146.3,49.41 146.45,49.26 146.68,49.26 146.84,49.42 146.84,49.65 146.69,49.8 146.69,50.03 146.85,50.19 147.08,50.19 147.23,50.04 147.46,50.04 147.62,50.2 147.62,50.43 147.47,50.58 147.47,50.81 147.63,50.97 147.86,50.97 148.01,50.82 148.24,50.82 148.4,50.98 148.4,51.21 148.25,51.36 148.25,51.59 148.41,51.75 148.64,51.75 148.79,51.6 149.02,51.6 156.4,58.98 156.4,59.2 156.15,59.45 156.15,59.68 156.31,59.84 156.54,59.84 156.79,59.59 157.01,59.59 157.18,59.76 157.18,59.98 156.93,60.23 156.93,60.46 157.09,60.62 157.32,60.62 157.57,60.37 157.79,60.37 157.96,60.54 157.96,60.76 157.71,61.01 157.71,61.24 157.87,61.4 158.1,61.4 158.35,61.15 158.57,61.15 158.74,61.32 158.74,61.54 158.49,61.79 158.49,62.02 159.27,62.8 159.27,63.81 159.43,63.98 160.28,63.98 160.44,64.14 160.44,64.37 160.28,64.53 159.43,64.53 159.27,64.69 159.27,64.96 159.43,65.12 160.22,65.12 160.38,65.28 160.38,65.51 160.22,65.67 159.43,65.67 159.27,65.83 159.27,66.06 159.43,66.22 160.22,66.22 160.38,66.39 160.38,66.61 160.22,66.78 159.43,66.78 159.27,66.94 159.27,67.17 159.43,67.33 160.22,67.33 160.38,67.49 160.38,67.72 160.22,67.88 159.43,67.88 159.27,68.04 159.27,68.27 159.43,68.43 160.22,68.43 160.38,68.59 160.38,68.82 160.22,68.98 159.43,68.98 159.27,69.14 159.27,71.12 160.57,72.42 160.57,73.29 v2(159.84,74.01)
  BOTTOM w0.076: UH1.AE3 163.03,79.39 163.32,79.1 163.32,77.61 161.86,76.15 161.86,75.56 162.1,75.32 162.1,75.31
  BOTTOM w0.213: v2(145.01,35.97) 144.37,35.97 144.08,35.67 JDIMM1.158 ; v2(159.84,74.01) 160.87,74.01 v1(161.35,74.49) 162.1,75.25 162.1,75.31
DDR_A_ODT0: length 66.9
  IN1 w0.076: v2(163.09,76.62) 163.09,77.05 163.02,77.13 162.1,77.13 161.52,76.55 161.52,72.1 159.32,69.9 159.32,66.3
  IN1 w0.145: 159.32,66.3 159.32,57.13 158.78,56.6 158.78,56.6 158.36,56.17 158.35,56.17 158,55.82 158,55.82 157.58,55.39 157.57,55.39 157.22,55.04 157.22,55.04 156.8,54.61 156.44,54.26 156.44,54.26 156.02,53.83 155.24,53.05 154.46,52.27 150.15,47.97 150.15,47.15 149.89,46.88 149.89,46.65 150.44,46.1 150.44,45.86 150.28,45.7 150.05,45.7 149.48,46.26 149.28,46.26 149.13,46.12 149.13,45.91 150.09,44.96 150.09,44.73 149.88,44.53 149.68,44.53 148.72,45.48 148.49,45.48 148.33,45.32 148.33,45.09 149.37,44.05 149.37,43.89 149.15,43.66 148.98,43.66 147.94,44.7 147.71,44.7 147.55,44.54 147.55,44.31 148.5,43.36 148.5,43.09 148.32,42.91 148.11,42.91 146.74,44.28 146.53,44.28 146.39,44.14 146.39,43.92 147.77,42.54 147.77,42.33 147.52,42.08 147.31,42.08 146.31,43.09 146.1,43.09 145.22,42.21 145.22,41 145.38,40.85 v2(145.38,40.8)
  BOTTOM w0.076: v2(163.09,76.62) 163.41,76.62 163.49,76.7 163.49,79.21 UH1.AD3
  BOTTOM w0.213: JDIMM1.155 143.33,41.81 143.57,41.56 143.57,41.53 144.31,40.8 v2(145.38,40.8)
DDR_A_ODT1: length 67.6
  IN1 w0.076: 161.23,70.22 161.23,70.35 162.22,71.34 162.22,74.32 163.79,75.89 163.79,77.96 v2(162.58,79.16)
  IN1 w0.145: 161.23,70.22 161.23,56.76 158.19,53.72 158.19,53.49 158.85,52.83 158.85,52.6 158.69,52.44 158.46,52.44 157.8,53.1 157.57,53.1 157.41,52.94 157.41,52.71 158.07,52.05 158.07,51.82 157.91,51.66 157.68,51.66 157.02,52.32 156.79,52.32 156.63,52.16 156.63,51.93 157.29,51.27 157.29,51.04 157.13,50.88 156.9,50.88 156.24,51.54 156.01,51.54 155.85,51.38 155.85,51.15 156.51,50.49 156.51,50.26 156.35,50.1 156.12,50.1 155.46,50.76 155.23,50.76 151.68,47.21 151.68,44.61 147.05,39.98 147.05,38.42 v2(145.62,36.99)
  BOTTOM w0.076: v2(162.58,79.16) 162.58,79.61 163.03,80.05 UH1.AE4
  BOTTOM w0.213: v2(145.62,36.99) 146.72,38.09 146.72,41.11 146.05,41.79 145.17,41.79 144.82,42.13 JDIMM1.161
DDR_A_PAR: length 69
  IN1 w0.076: 157.78,66.3 157.78,70.17 160.75,73.14 160.75,78.79 v2(161.69,79.74)
  IN1 w0.145: v2(140.45,38.83) 140.57,38.83 141.83,40.1 141.83,43.65 145.17,46.99 145.4,46.99 145.78,46.62 146,46.62 146.17,46.78 146.17,47.01 145.79,47.38 145.79,47.61 145.95,47.77 146.18,47.77 146.55,47.4 146.78,47.4 146.94,47.56 146.94,47.79 146.57,48.16 146.57,48.39 146.73,48.55 146.96,48.55 147.33,48.17 147.56,48.17 147.72,48.34 147.72,48.56 147.35,48.94 147.35,49.17 147.51,49.33 147.74,49.33 148.11,48.95 148.34,48.95 148.5,49.12 148.5,49.34 148.13,49.72 148.13,49.95 148.32,50.14 148.55,50.14 148.83,49.86 149.06,49.86 149.22,50.02 149.22,50.25 148.94,50.53 148.94,50.76 149.1,50.92 149.33,50.92 149.61,50.64 149.84,50.64 150,50.8 150,51.03 149.72,51.31 149.72,51.54 149.88,51.7 150.11,51.7 150.39,51.42 150.62,51.42 150.78,51.58 150.78,51.81 150.5,52.09 150.5,52.32 150.66,52.48 150.89,52.48 151.17,52.2 151.4,52.2 151.56,52.36 151.56,52.59 151.28,52.87 151.28,53.1 151.44,53.26 151.67,53.26 151.95,52.98 152.18,52.98 152.34,53.14 152.34,53.37 152.06,53.65 152.06,53.88 152.22,54.04 152.45,54.04 152.73,53.76 152.96,53.76 153.12,53.92 153.12,54.15 152.84,54.43 152.84,54.66 153,54.82 153.23,54.82 153.51,54.54 153.74,54.54 153.9,54.7 153.9,54.93 153.62,55.21 153.62,55.44 157.78,59.6 157.78,66.3
  BOTTOM w0.076: v2(161.69,79.74) 161.5,79.74 UH1.AG3
  BOTTOM w0.213: v2(140.45,38.83) 138.73,38.83 138.33,39.24 JDIMM1.143
DDR_A_RAS#: length 65.2
  IN2 w0.145: v2(142.91,39.65) 142.76,39.65 140.37,42.04 140.37,47.72 153.92,61.26 154.15,61.26 154.87,60.54 155.1,60.54 155.26,60.7 155.26,60.93 154.54,61.65 154.54,61.88 154.7,62.04 154.93,62.04 155.65,61.32 155.88,61.32 156.04,61.48 156.04,61.71 155.32,62.43 155.32,62.79 155.61,63.08 155.84,63.08 156.47,62.45 156.7,62.45 156.86,62.62 156.86,62.84 156.23,63.47 156.23,63.7 157.77,65.24 157.77,73.39 157.51,73.65 157.43,73.65 156.98,74.1 156.98,75.53 v2(157.37,75.92)
  BOTTOM w0.076: UH1.AH4 160.51,79.97 160.79,79.69 160.79,76.73 160.44,76.38 158.5,76.38 158.42,76.3
  BOTTOM w0.213: JDIMM1.152 142.58,37.14 142.83,37.39 143.24,37.39 143.7,37.85 143.7,39.02 143.07,39.65 v2(142.91,39.65) ; v2(157.37,75.92) 157.75,76.3 v1(157.96,76.3) 158.42,76.3
DDR_A_WE#: length 69.4
  IN2 w0.145: v2(142.79,41.43) 142.79,49.49 147.13,53.84 147.36,53.84 148.02,53.18 148.25,53.18 148.41,53.34 148.41,53.57 147.75,54.23 147.75,54.46 147.91,54.62 148.14,54.62 148.8,53.96 149.03,53.96 149.19,54.12 149.19,54.35 148.53,55.01 148.53,55.24 148.69,55.4 148.92,55.4 149.58,54.74 149.81,54.74 149.97,54.9 149.97,55.13 149.31,55.79 149.31,56.02 149.47,56.18 149.7,56.18 150.36,55.52 150.59,55.52 150.75,55.68 150.75,55.91 150.09,56.57 150.09,56.8 150.25,56.96 150.48,56.96 151.14,56.3 151.37,56.3 151.53,56.46 151.53,56.69 150.87,57.35 150.87,57.58 151.09,57.8 151.32,57.8 152.04,57.08 152.27,57.08 152.43,57.24 152.43,57.47 151.71,58.19 151.71,58.42 151.87,58.58 152.1,58.58 152.82,57.86 153.05,57.86 153.21,58.02 153.21,58.25 152.49,58.97 152.49,59.2 152.65,59.36 152.88,59.36 153.6,58.64 153.83,58.64 153.99,58.8 153.99,59.03 153.27,59.75 153.27,59.98 153.43,60.14 153.66,60.14 154.38,59.41 154.61,59.41 155.29,60.09 155.29,60.09 155.71,60.51 156.07,60.87 156.07,60.87 156.49,61.29 158.28,63.08 158.28,73.18 158.03,73.43 158.03,74.05 v2(157.37,74.71)
  BOTTOM w0.076: UH1.AG4 161.25,79.92 160.96,79.63 160.96,76.42 160.47,75.92 v1(159.87,75.92) 158.52,75.92
  BOTTOM w0.213: JDIMM1.151 142.33,41.71 142.61,41.43 v2(142.79,41.43) ; 158.52,75.92 158.43,75.92 157.6,75.09 157.6,74.94 v2(157.37,74.71)
