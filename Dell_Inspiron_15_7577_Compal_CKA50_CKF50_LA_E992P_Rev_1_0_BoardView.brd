# Allegro board Dell_Inspiron_15_7577_Compal_CKA50_CKF50_LA_E992P_Rev_1_0_BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB3RP1_C: length 2.2
  BOTTOM w0.14: UI3.12 8.19,46.72 8.31,46.59 8.31,46.44 8.1,46.23 8.1,45.82 CI7.2
USB3RP1_RE: length 33.2
  TOP w0.14: v2(7.87,57.97) 8.04,58.13 11.37,58.13 11.38,58.12 11.86,58.12 11.87,58.13 19.07,58.13 20.18,59.24 20.18,60.04 19.85,60.37 19.52,60.37 19.4,60.49 DI12.7 DI12.4 17.88,60.49 17.75,60.37 17.24,60.37 17.03,60.57 17.03,61.7 16.36,62.37 16.36,64.8 15.66,65.5 14.77,65.5 14.07,64.8 13.77,64.8 13.62,64.95 JUSB3.6
  BOTTOM w0.14: v2(7.87,57.97) 8.51,57.97 8.68,57.8 8.68,57.22 8.19,56.73 UI3.19
USB3RP2: length 103.6
  TOP w0.14: v2(361.4,37.68) 361.23,37.86 361.23,38.2 361.36,38.33 DI9.2 DI9.8 361.36,40.08 361.24,40.2 361.24,40.62 361.94,41.32 361.94,42.2 365.16,45.43 365.16,46.45 365.74,47.02 365.74,50.57 366.68,51.51 367.32,51.51 368.02,52.22 368.22,52.22 368.38,52.06 JUSB1.6
  IN1 w0.104: v2(361.4,37.68) 361.23,37.51 361.23,36.92 360.44,36.13 336.66,36.13 336.15,35.61 328.96,35.61 325.62,38.95 318.5,38.95 318.03,38.48 308.21,38.48 305.73,40.97 305.73,43.79 304.25,45.26 303.93,45.26 301.34,47.85 301.34,51 297.64,54.7 293.96,54.7 293.81,54.54 293.81,54.34 v2(293.97,54.17)
  BOTTOM w0.076: 293.69,53.88 293.54,53.72 293.54,53.42 293.23,53.11 293.23,52.61 293.28,52.56 293.34,52.56 293.42,52.49 293.42,52.37 293.34,52.29 293.31,52.29 293.23,52.22 293.23,52.04 293.46,51.81 293.46,51.71 293.38,51.63 293.27,51.63 UH2.B8
  BOTTOM w0.14: v2(293.97,54.17) 293.87,54.07 293.87,54.05 293.69,53.88
USB3RP3: length 98.8
  TOP w0.14: JUSB2.6 368.38,30.69 368.11,30.96 367.91,30.96 367.2,30.25 366.29,30.25 365.96,29.92 360.57,29.92 360.44,29.8 DI7.8 DI7.2 356.92,29.8 356.72,30 v2(356.72,30.76)
  IN1 w0.104: v2(293.1,54.69) 293.1,54.72 292.57,55.24 292.13,55.24 291.82,54.93 291.82,54.05 293.64,52.23 294.97,52.23 295.17,52.43 298.72,52.43 300.71,50.44 300.71,47.19 304.39,43.51 304.39,41.45 307.98,37.86 325.27,37.86 328.16,34.97 336.35,34.97 336.91,35.53 350.78,35.53 352.41,33.91 354.7,33.91 356.78,31.82 356.78,30.83 v2(356.72,30.76)
  BOTTOM w0.076: 292.93,53.88 292.93,53.87 292.9,53.83 292.9,53.82 292.49,53.42 292.49,52.84 292.57,52.77 292.72,52.77 292.8,52.69 292.8,52.54 292.72,52.46 292.57,52.46 292.49,52.39 292.49,52.21 292.67,52.04 UH2.A9
  BOTTOM w0.14: v2(293.1,54.69) 292.93,54.52 292.93,53.88
USB3TN1: length 318.7
  IN5 w0.104: v2(290.99,54.83) 290.87,54.96 290.04,54.96 288.98,53.89 288.98,52.31 287.82,51.15 287.82,47.16 287.34,46.68 285.49,46.68 284.5,45.69 283.75,45.69 282.11,44.05 276.31,44.05 275.95,44.41 271.57,44.41 271.05,43.9 268.08,43.9 267.63,44.35 266.11,44.35 265.62,43.86 265.62,38.95 265.62,38.79 261.02,34.19 258.36,34.19 257.48,33.3 254.55,33.3 252.01,30.76 246.83,30.76 245.44,29.37 230.73,29.37 230.33,28.97 222.17,28.97 220.83,27.64 179.54,27.64 179.05,28.12 163.41,28.12 162.3,27.01 140.28,27.01 139.46,27.83 108.51,27.83 107.54,28.79 104.39,28.79 103.25,27.65 66.6,27.65 66.13,27.18 51.55,27.18 50.41,28.32 36.64,28.32 35.38,29.58 35.38,30.05 31.92,33.52 31.92,36.42 29.77,38.57 29.77,39.7 27.91,41.56 12.97,41.56 11.34,43.19 11.34,44.4 10.88,44.86 10.32,44.86 10.07,44.61 10.07,44.16 10.14,44.1 10.45,44.1 10.52,44.03 10.52,43.84 v2(10.45,43.78)
  BOTTOM w0.076: UH2.C11 292.2,51.15 291.96,51.39 291.96,51.74 291.98,51.75 291.98,53.81 291.93,53.86 291.93,53.88
  BOTTOM w0.14: CI6.1 10.29,44.18 10.29,43.94 10.4,43.84 10.4,43.84 v2(10.45,43.78) ; 291.93,53.88 291.93,54.26 291.76,54.43 291.36,54.83 v2(290.99,54.83)
USB3TN1_C: length 2.2
  BOTTOM w0.14: UI3.8 10.19,46.72 10.06,46.59 10.06,46.39 10.33,46.13 10.33,45.76 CI6.2
USB3TN1_RE: length 20.1
  TOP w0.14: v2(11.51,56.19) 11.35,56.35 10.6,56.35 10.3,56.66 10.3,57.06 10.7,57.47 v3(18.45,57.47) 19.86,57.47 19.87,57.47 20.47,57.47 20.47,57.47 20.93,57.47 21.14,57.67 21.14,58.21 CI29.1
  BOTTOM w0.14: v2(11.51,56.19) 11.51,56.28 11.44,56.35 11.34,56.35 11.27,56.42 10.75,56.42 10.19,55.85 10.19,55.75 10.19,55.74 10.19,52.36 10.19,52.35 UI3.23
USB3TN1_RE_C: length 18.1
  TOP w0.14: CI29.2 21.13,59.82 21.22,59.82 21.49,60.09 v3(21.49,60.75) 21.5,60.75 21.5,61.23 21.12,61.61 20.83,61.61 20.82,61.6 20.08,61.6 20.07,61.61 19.57,61.61 19.45,61.49 DI12.8 DI12.2 17.9,61.49 16.87,62.52 16.87,66.66 16.04,67.49 16.04,69.27 15.49,69.81 14.77,69.81 14.08,70.5 13.84,70.5 13.62,70.28 JUSB3.8
USB3TN2: length 95.2
  TOP w0.14: v2(361.81,31.33) 361.82,31.33 362.15,31 362.55,31 362.81,31.27 362.81,34.37 CI16.1
  IN1 w0.104: v2(361.81,31.33) 361.59,31.12 360.23,31.12 359.31,30.19 356.53,30.19 355.2,31.52 355.2,32.52 354.32,33.4 352.34,33.4 350.62,35.12 337.08,35.12 336.41,34.45 324.02,34.45 323.38,35.08 310.18,35.08 303.98,41.28 303.98,43.24 302.97,44.25 301.25,44.25 300.08,45.43 300.08,49.19 299.28,49.99 296.87,49.99 295.27,51.59 293.38,51.59 291.89,53.09 291.89,53.37 291.11,54.15 290.8,54.15 v2(290.57,54.37)
  BOTTOM w0.076: UH2.B12 291.58,51.59 291.81,51.82 291.81,52.27 291.8,52.28 291.8,52.77 291.56,53.01 291.56,53.64 291.45,53.75
  BOTTOM w0.14: v2(290.57,54.37) 290.75,54.19 291.01,54.19 291.45,53.75
USB3TN2_C: length 15.5
  TOP w0.14: JUSB1.8 368.38,46.77 368.06,46.45 367.83,46.45 367.39,46.89 366.5,46.89 365.61,46 365.61,45.22 363.57,43.18 363.56,43.18 362.93,42.55 362.93,42.54 362.49,42.1 v3(362.49,41.13) 362.49,40.06 362.36,39.94 DI9.7 DI9.4 362.36,38.31 362.49,38.19 362.49,37.62 362.48,37.61 362.48,37.02 362.49,37.02 362.49,36.22 CI16.2
USB3TN3: length 83.4
  TOP w0.14: v2(355.31,28.9) 355.48,28.73 356.13,28.73 CI9.1
  IN1 w0.104: v2(290.61,53.1) 290.79,52.93 291.14,52.93 292.46,51.61 292.46,49.74 292.65,49.55 293.83,49.55 294.43,48.95 296.05,48.95 299.23,45.77 299.23,43.42 299.85,42.79 301.62,42.79 310.09,34.32 323.12,34.32 323.62,33.82 336.64,33.82 337.33,34.52 350.28,34.52 352,32.8 353.92,32.8 354.5,32.22 354.5,28.92 354.69,28.73 355.15,28.73 v2(355.31,28.9)
  BOTTOM w0.076: UH2.C13 291.15,51.29 291.15,52.63 290.94,52.84 290.87,52.84 290.61,53.09 v2(290.61,53.1)
USB3TN3_C: length 13.5
  TOP w0.14: CI9.2 357.74,28.68 358.77,28.68 358.9,28.8 DI7.4 DI7.7 360.46,28.8 360.58,28.68 v3(362.28,28.68) 363.88,28.68 364.31,28.25 364.32,28.25 365.01,27.56 365.01,27.56 366.5,26.06 367.21,26.06 368.04,25.23 368.24,25.23 368.38,25.37 JUSB2.8
USB3TP1: length 318.6
  IN5 w0.104: v2(290.99,55.41) 290.73,55.15 289.96,55.15 288.79,53.97 288.79,52.39 287.63,51.23 287.63,47.24 287.26,46.87 285.41,46.87 284.42,45.88 283.67,45.88 282.03,44.24 276.39,44.24 276,44.63 271.51,44.63 270.97,44.1 268.16,44.1 267.71,44.54 266.03,44.54 265.43,43.94 265.43,38.87 260.94,34.38 258.28,34.38 257.4,33.5 254.47,33.5 251.93,30.96 246.75,30.96 245.36,29.57 230.65,29.57 230.25,29.16 222.09,29.16 220.75,27.83 179.62,27.83 179.13,28.31 163.33,28.31 162.22,27.2 140.36,27.2 139.54,28.02 108.59,28.02 107.62,28.99 104.31,28.99 103.17,27.84 66.52,27.84 66.05,27.37 51.63,27.37 50.49,28.52 36.72,28.52 35.58,29.66 35.58,30.13 32.11,33.6 32.11,36.5 29.96,38.65 29.96,39.78 27.99,41.75 13.05,41.75 11.53,43.27 11.53,44.48 10.96,45.05 10.24,45.05 9.87,44.68 v2(9.87,43.78)
  BOTTOM w0.076: UH2.B11 292.2,51.79 292.14,51.84 292.14,53.81 292.19,53.86 292.19,53.88
  BOTTOM w0.14: v2(290.99,55.41) 291.16,55.25 291.3,55.25 292.19,54.37 292.19,53.88 ; CI5.1 10.04,44.18 10.04,43.95 v2(9.87,43.78)
USB3TP1_C: length 2.2
  BOTTOM w0.14: CI5.2 10.07,45.82 10.07,46.02 9.81,46.29 9.81,46.59 9.69,46.72 UI3.9
USB3TP1_RE: length 20.1
  TOP w0.14: v2(11.51,56.77) 11.35,56.61 10.71,56.61 10.55,56.76 10.55,56.96 10.8,57.21 18.09,57.21 18.1,57.21 18.78,57.21 18.78,57.21 v3(20.21,57.21) 21.04,57.21 21.39,57.57 21.39,58.21 CI28.1
  BOTTOM w0.14: UI3.22 9.69,52.02 9.93,52.26 9.93,52.46 9.94,52.46 9.94,55.64 9.93,55.64 9.93,55.96 10.64,56.67 11.41,56.67 v2(11.51,56.77)
USB3TP1_RE_C: length 18.2
  TOP w0.14: CI28.2 21.74,60.5 21.75,60.51 21.75,61.34 21.22,61.87 v3(20.36,61.87) 19.58,61.87 19.46,61.99 DI12.9 DI12.1 17.76,61.99 17.12,62.63 17.12,66.77 16.94,66.94 16.94,66.95 16.49,67.4 16.49,67.4 16.3,67.59 16.3,69.37 15.6,70.07 14.87,70.07 14.19,70.75 13.81,70.75 13.62,70.94 JUSB3.9
USB3TP2: length 95.2
  TOP w0.14: CI20.1 363.07,31.17 362.65,30.75 v2(361.81,30.75)
  IN1 w0.104: v2(290.57,53.79) 290.74,53.95 291.03,53.95 291.69,53.29 291.69,53.01 293.3,51.4 295.19,51.4 296.79,49.8 299.2,49.8 299.88,49.11 299.88,45.35 301.17,44.06 302.89,44.06 303.79,43.16 303.79,41.2 310.1,34.89 323.3,34.89 323.94,34.25 336.49,34.25 337.16,34.93 350.54,34.93 352.26,33.21 354.24,33.21 355,32.44 355,31.44 356.45,30 359.39,30 360.31,30.92 361.63,30.92 v2(361.81,30.75)
  BOTTOM w0.076: 291.18,53.7 291.4,53.48 291.4,52.94 291.64,52.7 291.64,52.38 291.57,52.31 291.4,52.31 291.35,52.26 291.35,51.83 291.4,51.78 291.53,51.78 291.63,51.88 291.63,51.99 UH2.A12
  BOTTOM w0.14: v2(290.57,53.79) 290.73,53.94 290.9,53.94 291.15,53.7 291.16,53.71 291.17,53.71 291.18,53.7
USB3TP2_C: length 15.4
  TOP w0.14: JUSB1.9 368.38,46.04 368.22,46.19 367.73,46.19 367.28,46.64 366.6,46.64 365.86,45.9 365.86,45.11 365.38,44.63 365.38,44.62 364.7,43.94 364.69,43.94 362.74,41.99 362.74,41.37 362.75,41.37 362.75,40.8 362.74,40.8 362.74,40.06 362.86,39.93 DI9.6 DI9.5 362.86,38.33 362.74,38.2 v3(362.74,37.28) 362.74,36.25 CI20.2
USB3TP3: length 83.5
  TOP w0.14: CI10.1 356.13,28.48 355.48,28.48 v2(355.31,28.31)
  IN1 w0.104: v2(355.31,28.31) 355.09,28.54 354.61,28.54 354.3,28.84 354.3,32.14 353.84,32.6 351.92,32.6 350.2,34.32 337.41,34.32 336.72,33.63 323.54,33.63 323.04,34.13 310.01,34.13 301.54,42.6 299.77,42.6 299.03,43.34 299.03,45.69 295.97,48.76 294.35,48.76 293.75,49.36 292.57,49.36 292.26,49.66 292.26,51.53 291.12,52.67 290.77,52.67 v2(290.61,52.51)
  BOTTOM w0.076: UH2.D13 290.67,51.02 290.67,51.75 290.83,51.91 290.83,52.47 290.75,52.54 290.64,52.54 v2(290.61,52.51)
USB3TP3_C: length 13.5
  TOP w0.14: CI10.2 357.63,28.42 358.78,28.42 358.9,28.3 DI7.5 DI7.6 360.46,28.3 360.58,28.42 361.95,28.42 361.98,28.4 362.7,28.4 362.73,28.42 363.78,28.42 v3(364.36,27.85) 366.39,25.81 367.1,25.81 367.94,24.97 368.24,24.97 368.38,24.83 JUSB2.9
USB20_N1: length 306.4
  IN5 w0.104: v2(13.42,36.58) 13.39,36.54 12.53,36.54 12.23,36.24 12.23,32.9 13.79,31.33 16.1,31.33 17.04,32.27 25.86,32.27 31.11,27.01 32.67,27.01 36.48,23.21 84.43,23.21 85.42,24.2 105.17,24.2 105.37,24.4 131.59,24.4 132.98,23.01 180.01,23.01 181.22,24.22 222.25,24.22 223.59,25.56 231.74,25.56 232.14,25.96 237.45,25.96 238.68,24.73 261.86,24.73 264.87,27.75 265.75,27.75 266.41,28.4 266.41,30.32 267.63,31.54 268.65,31.54 270.61,33.5 270.61,34.7 271.51,35.6 271.9,35.6 273.86,37.56 274.64,37.56 275.34,38.26 282.19,38.26 282.88,38.95 288.16,38.95 288.35,39.14 290.82,39.14 291.01,39.33 293.2,39.33 293.27,39.27 294.1,39.27 294.3,39.47 294.3,39.7 294.35,39.75 294.36,39.75 v2(294.53,39.93)
  BOTTOM w0.076: v2(294.53,39.93) 294.87,39.59 UH2.AF5
  BOTTOM w0.14: US1.2 11.27,37.22 11.39,37.1 11.8,37.1 12.49,36.41 13.26,36.41 v2(13.42,36.58)
USB20_N2: length 75.8
  IN1 w0.104: v2(295.16,41.24) 294.95,41.03 294.95,40.78 295.06,40.67 295.38,40.67 295.5,40.8 296.71,40.8 296.75,40.84 301.17,40.84 306.55,35.45 306.55,34.76 309.78,31.54 324.66,31.54 326.33,33.2 337.03,33.2 337.75,33.92 349.96,33.92 351.51,32.36 351.51,31.55 v2(351.71,31.35)
  BOTTOM w0.089: UH2.AD5 294.92,41.08 295.09,41.24 v2(295.16,41.24)
  BOTTOM w0.14: LI2.1 357.48,38.52 357.35,38.39 357.35,36.58 353.53,32.76 352.49,32.76 351.54,31.81 351.54,31.52 v2(351.71,31.35)
USB20_N2_L: length 18.2
  BOTTOM w0.14: JUSB1.2 366.88,48.85 366.68,49.05 365.8,49.05 365.16,48.41 365.16,44.43 364.3,43.57 364.3,43.56 363.96,43.22 363.95,43.22 363.3,42.57 362.88,42.57 361.98,41.67 DI10.3 361.67,41.82 361.67,42.43 361.53,42.57 361.29,42.57 360.21,41.49 v3(357.75,41.49) 357.4,41.49 357.23,41.33 357.23,41.03 357.48,40.79 LI2.2
USB20_N3: length 71.3
  IN1 w0.104: v2(353.09,31.58) 352.89,31.78 352.55,31.78 352.4,31.63 352.4,30.59 351.4,29.59 348.24,29.59 347,30.83 336.27,30.83 335.36,31.74 326.85,31.74 325.18,30.06 309.22,30.06 305.07,34.22 305.07,34.83 301.25,38.65 298.19,38.65 297.86,38.31 295.96,38.31 295.84,38.19 295.06,38.19 293.95,39.31 293.64,39.31 293.53,39.42 292.54,39.42 292.46,39.33 292.46,39.14 292.52,39.08 292.52,38.89 292.58,38.83 292.77,38.82 v2(292.83,38.88)
  BOTTOM w0.102: v2(292.83,38.88) UH2.AG8
  BOTTOM w0.14: v2(353.09,31.58) 353.24,31.73 353.79,31.73 353.9,31.62 LI5.1
USB20_N3_L: length 15.7
  BOTTOM w0.14: LI5.2 355.81,31.62 355.94,31.75 v3(356.57,31.75) 357.47,31.75 357.64,31.58 359.21,31.58 360.02,32.39 360.21,32.39 360.33,32.27 360.33,31.89 DI8.3 360.68,31.58 360.92,31.82 360.92,32.22 361.09,32.39 361.81,32.39 362.36,31.85 362.36,31.84 362.7,31.5 362.71,31.5 366.23,27.97 366.74,27.97 366.88,27.83 JUSB2.2
USB20_N4: length 62
  IN1 w0.104: v2(297.88,40.23) 297.86,40.23 297.59,39.95 297.59,39.79 297.78,39.59 299.38,39.59 299.63,39.85 301.18,39.85 305.86,35.16 305.86,34.54 309.54,30.87 324.82,30.87 324.89,30.93 324.91,30.93 326.53,32.55 335.77,32.55 336.65,31.68 343.77,31.68 344.6,32.5 347.66,32.5 v2(347.77,32.61)
  BOTTOM w0.076: UH2.AE1 296.8,40.25 297.13,40.57 297.42,40.57 297.77,40.23 v2(297.88,40.23)
  BOTTOM w0.14: v2(347.77,32.61) 347.08,32.61 346.84,32.86 346.84,33.76 346.3,34.3 JNGFF1.5
USB20_N7: length 308.7
  IN5 w0.104: v2(15.1,34.17) 15.31,34.38 15.54,34.38 17.05,32.87 26.1,32.87 31.36,27.62 32.98,27.62 36.75,23.84 84.2,23.84 85.18,24.82 104.79,24.82 104.97,25 131.84,25 133.23,23.61 150.68,23.61 151.26,24.2 179.86,24.2 180.49,24.82 222,24.82 223.34,26.16 231.49,26.16 231.89,26.56 237.75,26.56 238.98,25.33 261.6,25.33 264.9,28.64 264.9,30.7 266.99,32.79 269.05,32.79 269.98,33.72 269.98,35.71 270.88,36.61 271.74,36.61 272.61,37.48 272.61,38.2 273.96,39.55 287.81,39.55 288.42,40.16 288.96,40.16 289.47,40.67 289.47,40.93 290.2,41.65 297.32,41.65 297.48,41.65 297.69,41.86 297.69,41.86 297.8,41.98 297.8,41.98 297.8,42.22 297.8,42.22 297.8,42.27 v2(297.96,42.43)
  BOTTOM w0.076: UH2.AB3 296.12,41.6 296.67,41.6 296.79,41.72 297.54,41.72 297.75,41.93 297.75,42.22 v2(297.96,42.43)
  BOTTOM w0.14: v2(15.1,34.17) 14.98,34.29 14.98,34.48 15.09,34.59 15.51,34.59 15.66,34.44 15.66,30.68 15.54,30.56 UR1.3
USB20_N8: length 90.8
  IN5 w0.104: v2(293.03,37.75) 293.1,37.67 293.26,37.67 293.36,37.77 293.36,38.11 293.21,38.26 289.54,38.26 289.09,37.81 282.61,37.81 281.92,37.11 276.02,37.11 274.5,35.59 273.28,35.59 272.65,34.95 272.65,34.68 267.01,29.05 267.01,24.81 265.02,22.82 262.66,22.82 261.35,24.13 238.43,24.13 237.2,25.35 232.39,25.35 231.88,24.84 227.8,24.84 227.38,24.43 227.38,24.07 227.48,23.98 227.6,23.98 v2(227.89,23.69)
  BOTTOM w0.076: UH2.AL8 293.3,37.48 v2(293.03,37.75)
  BOTTOM w0.14: v2(227.89,23.69) 227.89,30 226.78,31.11 223.77,31.11 223.65,31.23 TR5807.3 222.94,31.41 R127.1
USB20_N8_R: length 11.3
  BOTTOM w0.14: JPW.8 214.15,29.17 214.27,29.29 214.27,29.85 214.97,30.55 214.97,30.95 215.3,31.28 215.71,31.28 D5226.2 216.26,31.01 216.42,31.01 v3(216.89,31.48) 217.68,32.27 219.91,32.27 220.37,31.82 220.38,31.82 220.72,31.48 220.72,31.47 221.08,31.11 221.44,31.11 221.57,31.23 TR5807.4 222.03,31.39 R127.2
USB20_N9: length 257.1
  IN5 w0.104: v2(78.17,25.62) 78.17,25.02 78.65,24.54 84.04,24.54 84.93,25.42 104.54,25.42 104.72,25.6 132.09,25.6 133.47,24.22 150.44,24.22 151.01,24.8 179.61,24.8 180.24,25.42 221.75,25.42 223.09,26.76 231.24,26.76 231.65,27.16 238,27.16 239.23,25.94 245.49,25.94 246.76,27.21 249.4,27.21 250.67,25.94 260.45,25.94 262.71,28.2 262.71,30.49 264.88,32.65 264.88,34.22 266.92,36.27 266.92,36.27 267.16,36.51 267.16,36.51 267.51,36.86 269.66,36.86 270.66,37.86 271.25,37.86 273.55,40.16 277.55,40.16 278.06,40.67 281.47,40.67 281.94,40.19 287.6,40.19 287.82,40.41 287.82,41.37 289.41,42.95 297.53,42.95 298,43.42 v2(298,44.11)
  BOTTOM w0.076: UH2.AA1 296.81,42.46 296.81,42.78 297.09,43.06 297.34,43.06 297.51,43.23 297.51,43.62 v2(298,44.11)
  BOTTOM w0.14: RI1.1 83.15,42.1 LI1.4 81.82,41.93 80.49,40.6 80.49,39.82 80.17,39.49 v3(80.17,37.46) 80.17,32.18 80.16,32.18 80.16,31.5 80.17,31.49 80.17,29.81 78.17,27.81 v2(78.17,25.62)
USB20_N9_R: length 17.9
  BOTTOM w0.14: RI1.2 84.06,42.1 LI1.3 84.35,41.81 85.03,41.81 85.03,41.82 85.72,41.82 v3(86.46,42.56) 86.72,42.81 86.72,44.65 87.18,45.11 87.22,45.11 87.73,45.62 87.73,45.8 DI3.2 88.74,46.08 88.94,45.88 88.94,45.38 89.08,45.24 89.64,45.24 90.06,44.83 90.06,43.93 90.65,43.34 92.11,43.34 92.75,43.97 92.75,44.92 93.45,45.62 94.4,45.62 94.53,45.75 JEDP1.10
USB20_N12: length 35.5
  TOP w0.14: RV547.1 291.02,57.14 LV22.1 291.19,56.72 291.29,56.62 291.29,56.17 291.62,55.84 293.44,55.84 293.73,56.13 293.73,57.8 293.87,57.94 294.29,57.94 294.43,57.8 294.43,56.19 294.78,55.84 295.35,55.84 295.64,56.13 295.64,57.8 295.78,57.94 296.2,57.94 296.34,57.8 296.34,56.19 296.69,55.84 297.88,55.84 299.06,54.66 299.06,54.65 299.61,54.1 299.62,54.1 300.04,53.68 v3(300.04,52.52) 300.04,44.58 299.45,44 299.45,43.73 298.52,42.79 298.52,42.31 298.89,41.94 298.89,41.92 299.04,41.77 299.18,41.77 v2(299.34,41.61)
  BOTTOM w0.076: 298.86,41.43 298.86,41.42 298.8,41.36 298.8,41.35 298.77,41.32 298.77,41.1 298.43,40.76 296.77,40.76 296.59,40.57 296.09,40.57 UH2.AD3
  BOTTOM w0.14: v2(299.34,41.61) 299.27,41.68 299.07,41.68 298.86,41.47 298.86,41.43
USB20_N12_R: length 16.4
  TOP w0.14: RV547.2 291.02,58.05 LV22.2 291.19,58.59 291.31,58.71 291.31,59.45 289.6,61.16 289.6,61.62 289.45,61.78 DV12.3 288.76,63.4 289.05,63.69 289.05,63.7 289.4,64.05 289.4,65.52 289.13,65.79 v2(289.13,65.81)
  BOTTOM w0.14: v2(289.13,65.81) 289.24,65.69 289.24,65.21 289.53,64.93 290.2,64.93 291.99,63.13 292.6,63.13 293.04,62.69 293.6,62.69 JCAM1.4
USB20_P1: length 306.4
  IN5 w0.104: v2(293.89,39.91) 294.03,39.91 294.11,39.84 294.11,39.55 294.02,39.46 293.35,39.46 293.28,39.53 290.93,39.53 290.74,39.33 288.27,39.33 288.08,39.14 282.8,39.14 282.11,38.45 275.26,38.45 274.56,37.75 273.78,37.75 271.82,35.79 271.43,35.79 270.42,34.78 270.42,33.58 268.57,31.73 267.55,31.73 266.22,30.4 266.22,28.48 265.67,27.94 264.79,27.94 261.78,24.93 238.76,24.93 237.53,26.15 232.06,26.15 231.66,25.75 223.51,25.75 222.17,24.41 181.14,24.41 179.93,23.21 133.06,23.21 131.67,24.59 105.29,24.59 105.09,24.39 85.34,24.39 84.35,23.4 36.56,23.4 32.75,27.21 31.19,27.21 25.94,32.46 16.96,32.46 16.02,31.53 13.87,31.53 12.42,32.98 12.42,36.16 12.61,36.35 12.92,36.35 12.99,36.27 12.99,35.78 13.06,35.72 13.41,35.72 13.5,35.81 13.5,35.92 v2(13.42,35.99)
  BOTTOM w0.076: UH2.AG7 294.16,39.64 v2(293.89,39.91)
  BOTTOM w0.14: v2(13.42,35.99) 13.26,36.16 12.38,36.16 11.69,36.85 11.38,36.85 11.26,36.72 US1.3
USB20_P2: length 75.9
  IN1 w0.104: v2(351.12,31.35) 351.32,31.55 351.32,32.28 349.88,33.72 337.83,33.72 337.11,33.01 326.41,33.01 324.74,31.34 309.7,31.34 306.36,34.68 306.36,35.37 301.09,40.64 296.83,40.64 296.79,40.6 295.58,40.6 295.46,40.48 294.98,40.48 294.76,40.7 294.76,41.02 v2(294.54,41.24)
  BOTTOM w0.089: UH2.AD7 294.16,40.67 294.54,41.04 v2(294.54,41.24)
  BOTTOM w0.14: v2(351.12,31.35) 351.29,31.52 351.29,31.91 352.38,33.01 353.43,33.01 357.1,36.68 357.1,38.39 356.98,38.52 LI2.4
USB20_P2_L: length 18.2
  BOTTOM w0.14: LI2.3 356.98,41.43 357.3,41.75 358.1,41.75 358.1,41.75 360.1,41.75 361.67,43.32 361.67,43.45 DI10.2 362.1,43.6 362.88,42.83 363.2,42.83 v3(363.94,43.58) 364.9,44.53 364.9,48.51 365.69,49.3 366.72,49.3 366.88,49.47 JUSB1.3
USB20_P3: length 71.3
  IN1 w0.104: v2(292.09,38.91) 292.17,38.98 292.26,39.08 292.26,39.41 292.46,39.61 293.61,39.61 293.72,39.5 294.03,39.5 295.14,38.38 295.76,38.38 295.88,38.51 297.78,38.51 298.11,38.84 301.33,38.84 305.26,34.91 305.26,34.3 309.3,30.26 325.1,30.26 326.77,31.93 335.44,31.93 336.35,31.02 347.08,31.02 348.32,29.78 351.32,29.78 352.21,30.67 352.21,31.71 352.47,31.97 352.89,31.97 v2(353.09,32.17)
  BOTTOM w0.102: v2(292.09,38.91) UH2.AG10
  BOTTOM w0.14: v2(353.09,32.17) 353.26,31.99 353.78,31.99 353.91,32.12 LI5.4
USB20_P3_L: length 15.7
  BOTTOM w0.14: JUSB2.3 366.88,28.37 366.74,28.23 366.34,28.23 v3(362.71,31.85) 361.92,32.65 361.18,32.65 360.93,32.9 360.93,33.22 DI8.2 360.38,33.24 360.38,32.79 360.22,32.64 359.92,32.64 359.1,31.83 357.75,31.83 357.58,32 356.84,32 356.83,32.01 356.31,32.01 356.31,32 355.95,32 355.83,32.12 LI5.3
USB20_P4: length 62.1
  IN1 w0.104: v2(297.28,40.22) 297.35,40.15 297.35,39.75 297.7,39.4 299.46,39.4 299.71,39.65 301.1,39.65 305.67,35.08 305.67,34.46 309.46,30.68 324.9,30.68 324.97,30.74 324.99,30.74 326.61,32.36 335.69,32.36 336.57,31.48 343.85,31.48 344.68,32.31 347.3,32.31 347.51,32.1 v2(347.51,32.09)
  BOTTOM w0.076: UH2.AE2 296.45,40.18 296.71,39.92 297.27,39.92 297.37,40.02 297.37,40.12 v2(297.28,40.22)
  BOTTOM w0.14: v2(347.51,32.09) 347.51,32.16 347.31,32.36 346.98,32.36 346.58,32.75 346.58,33.65 346.2,34.04 345.89,34.04 345.64,33.8 JNGFF1.3
USB20_P7: length 308.7
  IN5 w0.104: v2(297.38,42.43) 297.39,42.43 297.61,42.2 297.61,42.14 297.61,42.14 297.61,42.06 297.4,41.85 290.12,41.85 289.28,41.01 289.28,40.75 288.88,40.35 288.34,40.35 287.73,39.75 273.88,39.75 272.41,38.28 272.41,37.56 271.66,36.81 270.8,36.81 269.79,35.79 269.79,33.8 268.97,32.99 266.91,32.99 264.7,30.78 264.7,28.72 261.52,25.53 239.06,25.53 237.83,26.75 231.81,26.75 231.41,26.35 223.26,26.35 221.92,25.01 180.41,25.01 179.78,24.39 151.18,24.39 150.6,23.81 133.31,23.81 131.92,25.19 104.89,25.19 104.71,25.01 85.1,25.01 84.12,24.03 36.83,24.03 33.06,27.81 31.44,27.81 26.18,33.06 17.13,33.06 15.62,34.57 15.23,34.57 15.08,34.72 v2(15.08,35.02)
  BOTTOM w0.076: UH2.AB2 296.23,41.84 296.09,41.98 296.09,42.08 296.23,42.22 296.43,42.22 296.77,41.88 297.47,41.88 297.59,42 297.59,42.22 v2(297.38,42.43)
  BOTTOM w0.14: v2(15.08,35.02) 15.25,34.85 15.62,34.85 15.91,34.55 15.91,30.7 16.04,30.58 UR1.4
USB20_P8: length 90.8
  IN5 w0.104: v2(227.19,23.69) 227.19,24.51 227.72,25.04 231.8,25.04 232.31,25.55 237.28,25.55 238.51,24.32 261.43,24.32 262.74,23.02 264.94,23.02 266.82,24.89 266.82,29.13 272.45,34.76 272.45,35.03 273.2,35.78 274.42,35.78 275.94,37.31 281.84,37.31 282.53,38 289.01,38 289.46,38.45 293.29,38.45 293.55,38.19 293.55,37.94 v2(293.76,37.72)
  BOTTOM w0.076: UH2.AL7 294.06,37.43 v2(293.76,37.72)
  BOTTOM w0.14: v2(227.19,23.69) 227.19,23.84 227.29,23.94 227.54,23.94 227.64,24.04 227.64,29.89 226.68,30.85 223.77,30.85 223.65,30.73 TR5807.2 222.94,30.55 R126.1
USB20_P8_R: length 11.3
  BOTTOM w0.14: JPW.7 214.65,29.17 214.53,29.29 214.53,29.74 215.23,30.44 215.23,30.85 215.41,31.03 215.61,31.03 215.75,30.89 215.75,30.53 D5226.3 216.18,30.76 216.53,30.76 216.89,31.13 216.9,31.13 217.24,31.47 217.24,31.47 217.78,32.02 219.81,32.02 v3(220.36,31.47) 220.97,30.85 221.45,30.85 221.57,30.73 TR5807.1 222.03,30.58 R126.2
USB20_P9: length 257.1
  IN5 w0.104: v2(78.75,25.62) 78.37,25.24 78.37,25.09 78.73,24.73 83.96,24.73 84.85,25.62 104.46,25.62 104.64,25.79 132.17,25.79 133.55,24.41 150.36,24.41 150.93,24.99 179.53,24.99 180.16,25.62 221.67,25.62 223.01,26.95 231.16,26.95 231.57,27.35 238.08,27.35 239.31,26.13 245.41,26.13 246.68,27.4 249.48,27.4 250.75,26.13 260.37,26.13 262.52,28.28 262.52,30.57 264.68,32.73 264.68,34.3 266.73,36.35 266.73,36.35 267.08,36.7 267.08,36.7 267.43,37.05 269.58,37.05 270.58,38.05 271.17,38.05 273.47,40.35 277.47,40.35 277.98,40.86 281.55,40.86 282.02,40.39 287.52,40.39 287.63,40.49 287.63,41.45 289.33,43.14 296.55,43.14 296.65,43.25 296.65,43.29 296.78,43.43 296.93,43.43 297.07,43.29 297.07,43.25 297.17,43.14 297.45,43.14 297.81,43.5 297.81,43.73 297.42,44.11 v2(297.42,44.11)
  BOTTOM w0.076: v2(297.42,44.11) 297.35,44.04 297.35,43.3 297.27,43.22 297.02,43.22 296.65,42.85 296.65,42.76 296.39,42.51 296.35,42.51 UH2.AA2
  BOTTOM w0.14: v2(78.75,25.62) 78.75,25.92 78.61,26.06 78.56,26.06 78.42,26.2 78.42,27.7 80.42,29.7 v3(80.42,31.85) 80.42,37.21 80.43,37.21 80.43,37.8 80.42,37.8 80.42,39.39 80.75,39.71 80.75,40.5 81.93,41.68 82.34,41.68 82.4,41.62 82.4,41.53 82.63,41.3 82.85,41.3 LI1.1 83.15,41.27 RI2.1
USB20_P9_R: length 17.9
  BOTTOM w0.14: JEDP1.9 94.56,45.25 94.44,45.37 93.56,45.37 93,44.82 93,43.86 92.22,43.08 90.55,43.08 89.8,43.83 89.8,44.72 89.54,44.99 89.04,44.99 88.88,44.82 88.88,44.29 88.74,44.15 DI3.3 87.8,44.36 87.8,44.72 87.66,44.86 87.29,44.86 86.97,44.54 86.97,42.7 86.47,42.2 86.46,42.2 85.82,41.56 v3(85.32,41.56) 84.35,41.56 LI1.2 84.06,41.27 RI2.2
USB20_P12: length 35.5
  TOP w0.14: v2(299.34,42.19) 299.27,42.12 299.07,42.12 298.77,42.42 298.77,42.68 299.71,43.62 299.71,43.89 300.29,44.47 300.29,52.21 300.3,52.22 300.3,52.85 300.29,52.86 300.29,53.79 v3(299.52,54.56) 297.99,56.09 296.79,56.09 296.59,56.29 296.59,57.91 296.3,58.19 295.67,58.19 295.38,57.91 295.38,56.23 295.24,56.09 294.89,56.09 294.69,56.29 294.69,57.91 294.4,58.19 293.77,58.19 293.48,57.91 293.48,56.23 293.34,56.09 293.06,56.09 292.96,56.19 292.96,56.33 292.82,56.47 292.54,56.47 292.4,56.33 292.4,56.19 292.3,56.09 291.76,56.09 291.54,56.31 291.54,56.56 291.69,56.7 LV22.4 291.86,57.14 RV545.1
  BOTTOM w0.076: UH2.AD2 296.37,40.84 296.33,40.88 296.33,41 296.41,41.08 296.57,41.08 296.68,40.96 296.73,40.96 296.77,40.92 298.36,40.92 298.61,41.17 298.61,41.43 298.6,41.43
  BOTTOM w0.14: 298.6,41.43 298.6,41.73 298.9,42.03 299.17,42.03 v2(299.34,42.19)
USB20_P12_R: length 16.4
  TOP w0.14: RV545.2 291.86,58.05 LV22.3 291.69,58.62 291.57,58.74 291.57,59.55 289.85,61.27 289.85,61.64 289.99,61.78 DV12.2 290.69,62.58 290.44,62.83 289.26,62.83 289.01,63.07 289.01,63.3 v3(289.4,63.68) 289.65,63.93 289.65,65.75 v2(289.71,65.81)
  BOTTOM w0.14: v2(289.71,65.81) 289.5,65.6 289.5,65.32 289.64,65.18 290.3,65.18 292.09,63.39 292.88,63.39 293.31,63.82
USB8713_TEST: length 5.4
  BOTTOM w0.14: UI3.14 7.05,48.62 6.2,47.77 6.2,46.37 RI24.1 5.39,44.69 v1(5.06,44.36)
USB_EN#: length 75.5
  TOP w0.14: v2(297.14,18.2) 297.99,17.35 297.99,16.82 298.23,16.59 UE1.13 300.03,16.59 300.58,16.03 302.17,16.03 303.14,17 307.72,17 v2(308.66,17.94) ; v2(295.99,18.83) 295.99,19.49 RE29.1
  IN4 w0.137: v2(297.14,18.2) 296.62,18.2 v2(295.99,18.83) ; v2(353.42,34.51) 351.54,32.63 349.43,32.63 347.51,30.71 336.48,30.71 332.51,26.75 314.1,26.75 313.62,26.27 309.84,26.27 309.08,25.52 309.08,23.35 307.63,21.9 307.63,20.6 308.66,19.57 v2(308.66,17.94)
  BOTTOM w0.14: v1(354.85,36.19) 353.42,34.75 v2(353.42,34.51) US2.4
USB_OC0#: length 319.8
  TOP w0.14: v2(99.33,50.08) v1(100.41,50.08)
  IN4 w0.137: v2(99.33,50.08) 99.73,49.67 127.99,49.67 130.11,47.55 170.84,47.55 173.69,44.71 181.53,44.71 182.79,43.45 239.52,43.45 240.04,43.98 240.04,46.32 246.52,52.8 246.52,58.58 248.76,60.82 266.35,60.82 269.23,57.94 269.23,51.75 270.1,50.89 270.1,47.72 271.18,46.63 271.18,46.61 273.53,44.26 v2(273.53,41.37)
  IN5 w0.097: v2(99.33,50.08) 98.64,50.08 95.26,53.46 93.66,53.46 92.86,54.26 63.16,54.26 62.95,54.05 58.79,54.05 57.66,55.18 55.6,55.18 51.17,50.75 48.38,50.75 46.52,48.9 34.48,48.9 31.74,51.64 20.73,51.64 18.07,48.99 18.07,47.97 15.34,45.24 13.88,45.24 13.25,45.88 10.2,45.88 9.88,45.56 7.85,45.56 6.39,44.1 6.39,41.18 8.1,39.46 v2(8.1,39.21)
  BOTTOM w0.076: 274.29,41.81 274.95,41.81 275.37,41.39 275.85,41.39 276.01,41.23 276.01,41.04 276.1,40.94 UH2.AD43
  BOTTOM w0.14: RP16.1 272.97,41.93 v2(273.53,41.37) 273.98,41.81 274.29,41.81 ; US1.13 8.53,38.91 8.29,39.14 8.17,39.14 v2(8.1,39.21)
USB_OC1#: length 107.8
  TOP w0.14: v1(348.27,34.79) 348.13,34.65 v2(348.13,33.23)
  IN3 w0.124: v2(276.7,41.19) 277.26,41.75 280.89,41.75 282.5,40.14 288.92,40.14 289.24,40.47 290.42,40.47 290.6,40.29 292.13,40.29 293.5,41.66 295.33,41.66 296.33,40.67 298.63,40.67 299.48,39.82 301.14,39.82 301.71,39.25 303.63,39.25 304.09,39.7 304.72,39.7 309.56,34.86 309.56,33.84 308.82,33.1 308.82,32.03 310.95,29.89 310.95,28.28 315.6,23.64 317.91,23.64 318.45,24.18 330.04,24.18 330.84,24.98 330.84,28.73 335.77,33.66 347.7,33.66 v2(348.13,33.23)
  BOTTOM w0.076: UH2.AD42 276.58,41.07 v2(276.7,41.19) 276.31,41.58 276.31,41.85 276.12,42.04 274.3,42.04 274.23,42.1
  BOTTOM w0.14: RP16.2 272.13,41.43 271.96,41.6 271.96,42.15 272.1,42.29 274.04,42.29 274.23,42.1 ; US2.3 353.42,35.64 352.9,35.12 350.83,35.12 350.46,35.49 349.01,35.49 348.13,34.61 v2(348.13,33.23)
USB_OC2#: length 8
  TOP w0.14: v2(278.2,40.17) v1(278.8,40.17)
  IN4 w0.137: v2(274.14,41.34) 274.14,41.58 274.33,41.77 275.3,41.77 276.91,40.17 v2(278.2,40.17)
  BOTTOM w0.089: UH2.AD39 278.06,40.19 v2(278.2,40.17)
  BOTTOM w0.14: v2(274.14,41.34) 273.73,40.93 RP16.3
USB_OC3#: length 4.5
  TOP w0.14: v2(274.45,40.77) v1(275.39,40.77)
  BOTTOM w0.076: v2(274.45,40.77) 275.16,40.77 275.52,41.13 UH2.AC44
  BOTTOM w0.14: v2(274.45,40.77) 274.11,40.43 RP16.4
USB_OC4#: length 4.1
  BOTTOM w0.076: 274.97,43.02 275.33,43.02 275.44,43.13 275.86,43.13 UH2.Y43
  BOTTOM w0.114: 274.97,43.02 274.86,42.91 274.23,42.91
  BOTTOM w0.14: 274.23,42.91 273.77,42.91 272.89,43.78 RP8.3
USB_OC5#: length 7.6
  TOP w0.14: v2(277.99,43.62) 277.57,43.2 275.69,43.2 v1(275.51,43.02) 272.81,43.02 v2(272.52,42.73)
  BOTTOM w0.089: v2(277.99,43.62) 277.32,42.95 UH2.Y41
  BOTTOM w0.14: v2(272.52,42.73) RP8.4
USB_OC6#: length 3.7
  BOTTOM w0.076: 274.38,43.26 274.86,43.26 274.89,43.23 275.31,43.23 275.49,43.41 UH2.W44
  BOTTOM w0.14: 274.38,43.26 273.99,43.26 272.97,44.28 RP8.2
USB_OC7#: length 5.3
  TOP w0.14: v2(274.18,43.96) v1(273.41,43.96)
  BOTTOM w0.076: UH2.W43 276.03,43.63 275.4,43.63 275.04,43.99 274.89,43.99 274.71,44.16 274.38,44.16
  BOTTOM w0.14: RP8.1 273.09,44.78 273.91,43.96 v2(274.18,43.96) 274.38,44.16
USB_POWERSHARE_VBUS_EN: length 328.2
  TOP w0.14: v2(23.53,35.63) v1(22.94,35.63) ; UE1.71 v2(313.36,11.39)
  IN1 w0.097: v2(23.53,35.63) 24.93,34.23 26.72,34.23 28.15,32.79 31.22,32.79 33.12,30.89 33.12,28.22 35.32,26.02 61.55,26.02 61.91,26.38 79.44,26.38 79.71,26.11 79.74,26.11 80.68,25.17 89.14,25.17 91.36,27.4 103.86,27.4 104.5,28.03 105.56,28.03 106.79,26.8 121.89,26.8 122.5,27.41 132.17,27.41 134.85,24.73 135.8,24.73 136.77,25.7 236.81,25.7 239.78,22.74 255.9,22.74 264.52,14.11 268.58,14.11 272.04,10.66 277,10.66 278.74,8.92 286.02,8.92 286.75,8.19 294.61,8.19 295.43,7.36 311.16,7.36 311.54,7.74 311.54,10.54 312.38,11.39 v2(313.36,11.39)
  IN3 w0.124: v2(23.53,35.63) 22.97,36.19 15.56,36.19 13.84,34.47 v2(10.33,34.47)
  BOTTOM w0.14: RI51.2 v2(10.33,34.47) 10.03,34.77 US1.5
USB_PWR_SHR_EN_L#: length 328.5
  TOP w0.14: v1(304.56,25.31) 304.72,25.31 305.12,24.92 v2(305.16,24.92) 304.7,24.46 304.7,24.01 304.8,23.91 UE1.118
  IN3 w0.124: v2(305.16,24.92) 304.73,24.49 304.73,22.89 304.92,22.7 304.92,21.12 305.55,20.48 305.55,17.75 303.72,15.92 302.43,15.92 300.59,14.08 300.23,14.08 299.33,13.17 287.55,13.17 287.23,12.86 286.79,12.86 286.04,12.1 274.4,12.1 272.52,13.98 271.3,13.98 269.68,15.6 264.11,15.6 254.96,24.75 239.25,24.75 237.53,26.47 224.79,26.47 223.75,25.43 209.47,25.43 208.86,26.04 162.12,26.04 161.8,25.72 136.64,25.72 136.55,25.64 135.64,26.55 117.99,26.55 117.07,25.63 86.68,25.63 84.77,23.72 36.04,23.72 29.31,30.45 29.31,33.11 30.09,33.89 30.09,34.63 29.77,34.95 25.83,34.95 24.37,36.41 15.41,36.41 13.95,34.95 9.98,34.95 v2(9.53,34.5)
  BOTTOM w0.14: RI10.2 9.53,33.98 v2(9.53,34.5) US1.6
USB_R_CTL: length 4.7
  BOTTOM w0.127: v1(6.64,33.63) 6.9,33.89 RI9.2
  BOTTOM w0.14: 8.68,34.7 8.68,34.01 RI9.2 ; 8.68,34.7 8.53,34.85 US1.8 ; 8.68,34.7 8.9,34.7 9.03,34.83 US1.7
USBP1_D+: length 34.3
  BOTTOM w0.14: RI66.1 17.4,57.48 LI8.4 17.57,54.11 17.97,53.71 18.55,53.71 19.54,52.73 19.54,52.41 18.9,51.77 18.9,49.79 18,48.89 17.99,48.89 17.32,48.22 17.32,48.21 16.49,47.38 16.49,44.58 12.82,40.92 6.07,40.92 4.87,39.72 v3(4.87,38.67) 4.87,37.81 5.95,36.72 US1.10
USBP1_D+_R: length 16.2
  BOTTOM w0.14: RI66.2 17.4,58.4 LI8.3 17.57,59.07 17.71,59.21 17.71,59.41 18.31,60.01 18.61,60.01 19.71,61.1 19.71,61.34 19.62,61.43 19.15,61.43 18.89,61.7 DI11.2 19.64,61.71 19.74,61.81 19.74,62.37 18.9,63.21 17.31,63.21 16.49,64.04 16.49,67.03 15.74,67.78 15.41,67.78 15.12,67.49 JUSB3.3
USBP1_D-: length 34.3
  BOTTOM w0.14: US1.11 7.19,37.22 7.11,37.15 7.11,37.07 7.02,36.98 6.06,36.98 5.12,37.92 5.12,38.24 5.13,38.25 5.13,39.1 5.12,39.11 5.12,39.61 6.18,40.67 12.93,40.67 16.74,44.48 16.74,47.27 v3(17.72,48.25) 19.15,49.68 19.15,51.67 19.79,52.31 19.79,52.83 18.66,53.97 18.07,53.97 17.82,54.22 17.82,54.86 17.92,54.96 17.92,55.43 17.82,55.53 17.82,55.79 17.93,55.9 17.93,56.35 17.82,56.46 17.82,56.73 18.07,56.97 LI8.1 18.24,57.48 RI65.1
USBP1_D-_R: length 16.2
  BOTTOM w0.14: RI65.2 18.24,58.4 LI8.2 18.07,59.07 17.97,59.17 17.97,59.3 18.42,59.75 18.72,59.75 19.96,60.99 19.96,61.35 20.04,61.43 20.54,61.43 DI11.3 20.06,61.71 20,61.78 20,62.47 19,63.46 17.42,63.46 16.74,64.14 16.74,67.14 15.84,68.04 15.22,68.04 15.12,68.14 JUSB3.2
VBST1: length 1.6
  TOP w0.14: v1(79.02,40.22) 80.01,39.23 80.01,39.22 PR308.1
VBST2: length 1.8
  TOP w0.14: PR307.2 79.77,46.46 v1(79.21,47.02)
VBST_1V: length 1
  TOP w0.14: PR101.1 v1(252.96,43.32)
VBST_+1.35V: length 1.5
  TOP w0.14: PR801.1 241.53,57.99 v1(241.33,58.19)
VCIN0_PH: length 239.3
  TOP w0.14: HT1.1 CTH2.1 160.5,88.98 v1(159.87,88.36) 159.68,88.17 v2(159.68,87.79) 159.68,87.39 160.05,87.02 RTH1.2
  IN2 w0.097: v2(231.05,68.86) 232.06,69.87 237.36,69.87 238.22,70.74 244.59,70.74 245.45,69.87 262.17,69.87 264.07,67.97 275.27,67.97 275.59,68.29 277.27,68.29 277.27,68.29 281.69,68.29 284.73,65.25 288.75,65.25 291.41,62.59 291.41,62.45 292.5,61.36 294.49,61.36 298.48,57.38 302.29,57.38 303.8,55.87 306.75,55.87 310.74,51.87 310.74,47.57 307.72,44.55 307.72,40.18 311.44,36.47 311.44,30.17 313.6,28.01 313.6,22.05 314.27,21.38 314.27,18.7 313.45,17.87 v2(312.21,17.87)
  IN4 w0.137: v2(231.05,68.86) 229.34,67.15 229.34,63.91 225.97,60.55 225.97,60.14 222.07,56.24 219.66,56.24 218.29,54.87 203.57,54.87 202.15,56.28 199.4,56.28 198.11,57.57 195.44,57.57 192.74,60.27 192.74,64.02 191.81,64.95 191.81,69.24 192.08,69.52 192.08,73.41 191.98,73.51 191.98,74.18 190.13,76.03 184.13,76.03 181.78,78.39 181.78,80.99 180.38,82.39 180.38,86.13 179.93,86.58 177.69,86.58 177.53,86.42 176.53,86.42 176.37,86.58 174.09,86.58 173.2,85.69 167.13,85.69 166.07,86.75 165.46,86.75 164.22,87.99 162.11,87.99 161.55,88.55 160.06,88.55 159.68,88.17 v2(159.68,87.79)
  BOTTOM w0.14: RE73.1 312.41,17.67 v2(312.21,17.87)
VCLK: length 4.2
  TOP w0.14: PR306.1 83.74,38.06 v1(83.85,38.06)
  TOP w0.203: PU300.19 81.68,40.81 82.14,40.35 PR306.1
VCREF0: length 6.3
  TOP w0.14: v2(301.44,11.37) 301.44,11.4 301.03,11.8 300.49,11.8 300.47,11.79 UE1.25
  BOTTOM w0.14: v2(301.44,11.37) 301.56,11.37 RE35.1 CE91.1 RE34.2 v1(300.94,13.74)
VDRV_GPU_PH1: length 5.7
  TOP w0.14: PC6101.1 178.11,128.87 v4(178.89,128.08)
  TOP w0.254: PC6101.1 177.27,129.12 PR6106.2 176.19,129.12 175.36,128.3 v2(174.8,128.3)
  BOTTOM w0.254: PU6100.24 v2(174.8,128.3)
VDRV_GPU_PH2: length 4.3
  TOP w0.14: v2(174.09,137.25) 173.6,137.25 v1(173.2,137.65)
  TOP w0.254: v2(174.09,137.25) 174.6,137.76 PR6113.2 PC6116.1
  BOTTOM w0.254: PU6101.24 174.35,137.5 v2(174.09,137.25)
VDRV_GPU_PH3: length 3.2
  BOTTOM w0.14: PR6120.2 175.67,113.17 173.69,113.17 v1(173.58,113.27)
VGA_CLK_REQ#: length 120.6
  TOP w0.14: v2(281.53,27.27) 281.47,27.21 281.47,26 281.72,25.75 RP3.6
  IN2 w0.097: v2(281.53,27.27) 281.53,27.45 281.42,27.56 281.42,28.88 281.66,29.12 281.66,31.38 280.73,32.31 280.73,32.91 281.01,33.19 281.01,35.04 v2(281.43,35.46)
  IN3 w0.124: v2(203.69,74.89) 204.11,74.48 207.41,74.48 207.61,74.67 209.59,74.67 209.75,74.51 210.49,74.51 213.45,71.55 217.38,71.55 220.96,67.97 221.9,67.97 223.27,66.6 228.09,66.6 230.15,64.54 235.44,64.54 235.84,64.14 265.32,64.14 270.13,59.33 270.13,52.85 270.95,52.03 270.95,45.44 271.28,45.11 271.28,41.14 270.95,40.81 270.95,38.25 272.2,37 272.2,36.16 272.96,35.4 274.04,35.4 274.23,35.59 274.76,35.59 276.05,34.29 277.62,34.29 277.85,34.06 278.42,34.06 279.59,35.23 281.2,35.23 v2(281.43,35.46)
  BOTTOM w0.102: UH2.AR31 281.89,35.46 v2(281.43,35.46)
  BOTTOM w0.14: v2(203.69,74.89) 203.74,74.84 203.74,73.88 QG510.1
VGA_SMB_CK2: length 24.9
  IN4 w0.089: 202.91,78.19 202.82,78.29 202.82,79.56 202.91,79.65 202.91,81.6 202.84,81.67 202.84,82.28 202.35,82.77 202.35,83.72 201.85,84.22 v2(201.85,84.25)
  IN4 w0.137: 202.91,78.19 203.32,77.79 203.32,76.61 204.75,75.18 204.75,74.64 204.55,74.44 203.64,74.44 202.25,73.05 200.57,73.05 200.19,72.67 197.91,72.67 197.59,72.35 197.59,71.4 198.22,70.77 198.62,70.77 199.18,71.33 199.45,71.33 199.45,71.34 v2(199.46,71.34)
  BOTTOM w0.114: UG9.BJ8 v2(201.85,84.25)
  BOTTOM w0.14: RG17.1 200.33,70.56 200.31,70.58 QG6.4 199.9,70.89 v2(199.46,71.34)
VGA_SMB_DA2: length 22.4
  TOP w0.089: v2(202.55,84.25) 202.55,84.44 v1(202.12,84.86)
  IN4 w0.089: v2(202.55,84.25) 202.55,83.71 202.86,83.4 203.11,83.4 203.62,82.9 203.62,82.01 203.09,81.48 203.09,79.57 203,79.48 203,78.57 203.37,78.19
  IN4 w0.137: 203.37,78.19 204.36,77.21 204.36,76.05 205.01,75.4 205.01,74.53 204.66,74.18 203.75,74.18 202.36,72.79 200.68,72.79 200.3,72.41 198.85,72.41 198.55,72.11 v2(198.55,71.83)
  BOTTOM w0.114: UG9.BH8 v2(202.55,84.25)
  BOTTOM w0.14: v2(198.55,71.83) 198.65,71.93 198.65,72.43 QG6.1 198.6,72.53 198.46,72.67 197.45,72.67 RG18.1
VL: length 2.1
  BOTTOM w0.14: v2(78.64,43.03) v1(76.55,43.03)
VR_CAP: length 8.7
  TOP w0.14: UE1.18 298.06,14.59 297.66,14.19 293.56,14.19 T4931.1 292.86,15.84 CE103.1
VR_ON: length 314
  TOP w0.14: UC16.2 184.25,79.15 186.29,81.18 v2(188,81.18) ; v2(295.29,29.9) 295.29,29.28 v1(295.82,28.75) 296.17,28.4 296.17,27.61 297.23,26.55 RZ71.1 297.92,26.79 297.92,27.5 298.07,27.65 UZ21.4
  IN1 w0.097: v2(189.14,104.21) 189.14,103.35 184.29,98.5 184.29,96.96 187.46,93.79 187.46,81.74 188,81.21 v2(188,81.18) 188,79.56 185.44,77 185.44,71.33 187.95,68.82 191.11,68.82 191.77,68.17 191.77,65.54 195.95,61.36 209.12,61.36 209.64,60.84 211.94,60.84 212.49,61.4 213.72,61.4 214.38,62.06 217.86,62.06 219.73,63.93 224.59,63.93 225.33,64.67 227.56,64.67 228.19,64.04 263.59,64.04 266.07,61.56 275.76,61.56 277.29,60.03 277.29,54.56 278.5,53.34 278.5,52.08 279.96,50.63 279.96,46.81 279.6,46.46 279.6,44.3 281.47,42.43 281.47,40.96 281.86,40.57 281.86,37.04 283.36,35.54 284.1,35.54 284.72,34.93 285.38,34.93 285.76,34.55 286.63,34.55 286.96,34.88 288.01,34.88 288.84,34.05 288.84,33.16 289.01,32.98 290.58,32.98 291.69,31.87 292.07,31.87 292.86,31.09 294.23,31.09 295.29,30.03 v2(295.29,29.9)
  IN2 w0.097: v2(124.75,109.88) 125.26,109.38 126.07,109.38 126.55,109.86 126.55,117.1 127.05,117.6 131.06,121.62 131.06,123.75 132.66,125.35 134.6,125.35 135.03,125.78 135.03,134.69 135.45,135.11 135.45,138.98 134,140.43 132.45,140.43 130.14,142.74 130.14,144.54 130.82,145.23 132.94,145.23 v2(133.26,144.91)
  IN3 w0.124: v2(189.14,104.21) 189.14,104.61 186.74,107.01 186.74,108.1 184.58,110.26 181.75,110.26 180.9,111.1 176.58,111.1 175.73,111.95 167.75,111.95 167.52,111.72 158.83,111.72 158.38,111.26 136.87,111.26 134.27,108.67 125.35,108.67 124.75,109.26 v2(124.75,109.88)
  BOTTOM w0.14: v2(133.26,144.91) 133.26,144.23 PR5023.1
VR_SVID_ALERT#: length 72.7
  TOP w0.14: v2(132.61,144.81) 132.61,144.87 133.38,145.63 138.2,145.63 v1(138.33,145.51) 138.51,145.33 138.51,143.91 138.16,143.56 PR5008.2 ; v2(129.45,94.69) 129.53,94.61 131.47,94.61 131.69,94.83 136.22,94.83 136.75,95.37 136.78,95.37 136.99,95.58 RH152.2 137.84,95.58 RH153.1
  IN1 w0.097: v2(132.61,144.81) 131.58,143.78 131.29,143.78 130.29,142.78 130.29,139.28 128.9,137.9 128.9,124.15 130.6,122.45 130.6,121.63 128.27,119.31 128.27,110.79 127.25,109.77 127.25,102.34 129.77,99.82 129.77,95.74 129.41,95.38 129.41,94.73 v2(129.45,94.69)
VR_SVID_ALERT#_R: length 9.3
  TOP w0.14: v2(145.02,99.91) 144.21,99.1 144.21,97.97 v1(143.7,97.46) 143.3,97.06 141.11,97.06 140.87,97.3 140.35,97.3 138.93,95.88 RH153.2
  BOTTOM w0.102: UH1.BH31 144.67,100.26 v2(145.02,99.91)
VR_SVID_CLK: length 77.9
  TOP w0.14: v2(144.23,101.23) 144.46,101 144.46,100.23 143.74,99.51 140.92,99.51 139.42,98.01 139.42,97.17 138.53,96.28 137.52,96.28 137.34,96.1 136.75,96.1 136.01,95.35 v1(130.65,95.35) 130.27,95.35 130.07,95.16 v2(129.85,95.16) ; v2(135.2,145.18) 134.75,144.73 134.75,143.74 135.03,143.46 PR5006.2
  IN1 w0.097: v2(135.2,145.18) 134.32,144.29 132.67,144.29 131.75,143.38 131.45,143.38 130.69,142.61 130.69,139.12 129.3,137.74 129.3,124.31 131,122.62 131,121.47 130.79,121.25 130.79,121.24 128.67,119.13 128.67,110.63 127.65,109.61 127.65,102.51 130.17,99.99 130.17,95.49 v2(129.85,95.16)
  BOTTOM w0.114: UH1.BH32 144.55,100.91 v2(144.23,101.23)
VR_SVID_DATA: length 85.2
  TOP w0.14: v2(145.17,97.96) 144.96,97.96 143.54,96.54 141.02,96.54 140.83,96.35 140.13,96.35 139.54,95.75 139.54,95.49 138.93,94.89 RH151.2 138.93,94.15 138.98,94.09 138.98,93.51 138.57,93.09 v1(136.5,93.09) 130.28,93.09 129.45,93.92 v2(129.45,94.07)
  IN1 w0.097: v2(129.45,94.07) 130.57,95.19 130.57,100.86 128.06,103.38 128.06,109.44 129.08,110.46 129.08,118.96 131.4,121.29 131.4,122.79 129.71,124.48 129.71,137.57 131.09,138.95 131.09,142.44 131.62,142.98 131.92,142.98 132.83,143.89 139.1,143.89 140.33,145.11 v2(140.88,145.11)
  BOTTOM w0.114: UH1.BH29 145.17,98.49 v2(145.17,97.96)
  BOTTOM w0.14: PR5011.2 141.62,144.38 v2(140.88,145.11)
VREF: length 2.7
  TOP w0.203: PU6000.2 161.68,136.74 161.88,136.54 PR6064.1 PC6016.2
VREF_CPU: length 5
  TOP w0.203: v2(316.51,21.91) 316.51,21.5 v1(316.39,21.38) 315.99,20.99 UE1.95
  BOTTOM w0.254: v2(316.51,21.91) 316.51,21.49 315.91,20.89 CE77.1 RE116.2
VTTREF_1.2V: length 3.1
  TOP w0.14: PC212.1 110.48,64.17 v4(110.28,63.97)
  TOP w0.203: PC212.1 111.78,64.71 111.99,64.93 PU200.4
WLAN_CLK_REQ#: length 88.4
  TOP w0.14: RP3.7 282.62,26.25 282.74,26.37 282.74,26.89 283.05,27.2 284.14,27.2 284.71,27.77 284.71,28.92 v2(285.09,29.3)
  IN4 w0.137: v2(348.97,36.73) 345.93,36.73 343.86,34.66 329.06,34.66 328.22,33.82 317.02,33.82 316.57,34.28 308.35,34.28 305.63,31.55 305.36,31.55 304.93,31.12 299.95,31.12 298.38,29.56 296.56,29.56 296.45,29.44 293.89,29.44 293.86,29.41 291.57,29.41 289.55,27.38 286.28,27.38 285.92,27.75 285.92,28.73 285.51,29.14 285.26,29.14 v2(285.09,29.3)
  BOTTOM w0.076: 285.17,30.29 285.17,30.69 UH2.BD25
  BOTTOM w0.114: 285.17,30.29 285.17,29.39 v2(285.09,29.3)
  BOTTOM w0.14: JNGFF1.45 345.68,46.3 346.72,45.25 346.72,40.01 v1(348.35,38.38) 348.97,37.76 v2(348.97,36.73)
WLAN_WIGIG60GHZ_DIS#: length 82.8
  TOP w0.14: v2(345.81,39.14) 346.61,39.14 348.02,40.55 v1(348.02,41.62) 348.02,43.72 346.44,45.29 DN1.1
  IN4 w0.137: v2(279.64,36.64) 279.78,36.64 280.51,37.37 280.91,37.37 281.55,38 292.3,38 292.6,37.71 292.6,37.16 292.77,36.99 297.85,36.99 298.06,36.78 298.06,36.49 298.04,36.47 298.04,35.74 298.55,35.22 299,35.22 299.83,34.38 301.07,34.38 302.34,35.65 305.14,35.65 308.27,38.79 319.09,38.79 319.82,38.05 320.41,38.05 320.7,38.33 326.24,38.33 328.12,40.21 328.84,40.21 329.06,40 343.23,40 344.08,39.14 v2(345.81,39.14)
  BOTTOM w0.102: v2(279.64,36.64) UH2.AL35
WLAN_WIGIG60GHZ_DIS#_R: length 7.2
  TOP w0.14: DN1.2 343.51,45.16 342.36,45.16 v2(341.94,45.58)
  BOTTOM w0.14: v2(341.94,45.58) 341.94,45.63 340.53,47.05 JNGFF1.48
XDP_BPM#0: length 132
  TOP w0.14: v1(207.21,57.62) 206.55,58.28 v2(206.55,58.83)
  IN3 w0.124: v2(138.47,96.87) 136.77,98.56 136.77,106.23 139.51,108.97 158.48,108.97 159.54,110.03 168.22,110.03 168.45,110.26 175.03,110.26 175.88,109.41 180.18,109.41 182.86,106.73 183.32,106.73 186.41,103.65 186.41,101.33 189.28,98.47 189.28,78.99 198.76,69.5 200.98,69.5 201.17,69.69 v2(201.17,69.95)
  IN4 w0.137: v2(201.17,69.95) 201.17,70.03 201.94,70.81 205.2,70.81 205.72,70.28 205.72,69.73 206.98,68.47 206.98,65.96 208.7,64.25 208.7,62.09 207.01,60.4 207.01,59.27 206.57,58.83 v2(206.55,58.83)
  BOTTOM w0.076: UH1.BR27 140.3,97.24 139.93,96.87 v2(138.47,96.87)
  BOTTOM w0.14: v2(206.55,58.83) 206.35,58.83 206.03,59.15 206.03,59.72 206.03,59.72 206.03,59.97 205.92,60.09 205.92,60.35 205.87,60.4 JXDP1.21
XDP_BPM#1: length 126.9
  IN3 w0.124: v2(138.85,97.31) 137.05,99.11 137.05,106.12 139.62,108.69 158.59,108.69 159.34,109.44 161.02,109.44 161.32,109.13 167.71,109.13 168.57,109.98 174.91,109.98 175.76,109.13 180.07,109.13 182.75,106.45 183.22,106.45 186.13,103.53 186.13,101.22 189,98.35 189,78.87 198.65,69.23 201.74,69.23 v2(202.41,69.9)
  IN4 w0.137: v2(205.6,59.4) 208.41,62.21 208.41,64.13 206.69,65.84 206.69,68.35 205.43,69.61 205.43,70.16 205.08,70.52 203.02,70.52 v2(202.41,69.9)
  BOTTOM w0.076: v2(138.85,97.31) 139.17,97.31 139.24,97.24 UH1.BT27
  BOTTOM w0.14: JXDP1.23 205.37,60.25 205.6,60.02 v2(205.6,59.4)
XDP_DBRESET#: length 124.6
  TOP w0.14: RH531.2 v1(99.15,72.16) v2(99.71,72.16) ; v2(199.3,66.21) 200.13,66.21 200.46,65.88 RH532.1 CH207.1
  BOTTOM w0.14: v2(99.71,72.16) 100.25,71.62 101.6,71.62 102.73,70.49 102.73,64.91 102.99,64.66 102.99,59.07 106.19,55.87 167.17,55.87 169.44,58.14 185.34,58.14 188.53,61.33 188.53,64.06 189.33,64.86 197.65,64.86 197.97,65.19 198.5,65.19 199.3,65.99 v2(199.3,66.21) 199.37,66.28 JXDP1.48
XDP_PLTRST#: length 21.1
  TOP w0.14: v1(192.57,66.83) v2(192.57,66.22) RH523.2 RH522.2 RH520.2
  IN2 w0.097: v2(192.57,66.22) 191.22,66.22 189.94,67.5 189.94,68.21 191.35,69.62 192.89,69.62 193.51,69 194.14,69 194.94,68.2 196.74,68.2 197.8,69.27 199.52,69.27 200,69.75 v2(200,69.94)
  BOTTOM w0.102: JXDP1.46 199.87,67.91
  BOTTOM w0.14: v2(200,69.94) 200,69.75 199.87,69.62 199.87,67.91
XDP_PRDY#: length 247
  TOP w0.14: v2(141.31,97.6) 141.09,97.83 v1(140.65,97.83)
  IN2 w0.097: v2(295.1,34.41) 295.1,34.43 294.88,34.65 294.88,36.6 295.93,37.65 295.93,39.25 295.31,39.87 295.31,40.21 295.87,40.77 295.87,41.57 295.31,42.13 295.31,43.35 296.65,44.69 296.65,46.46 296.45,46.66 296.45,47.16 295.49,48.13 294.85,48.13 293.63,49.35 291.34,49.35 290.31,50.38 289.21,50.38 286.6,52.98 286.6,53.77 286.44,53.94 286.44,54.85 284.16,57.13 283.6,57.13 282.44,58.29 277.56,58.29 276.89,58.29 274.11,61.07 261.87,61.07 259.57,63.38 235.42,63.38 232.15,60.1 231.11,60.1 230.42,59.41 227.63,59.41 227.12,58.89 221.6,58.89 221.11,59.38 218.46,59.38 218.11,59.04 215.89,59.04 v2(215.81,59.12)
  IN3 w0.124: v2(213.75,63.34) 213.75,63.86 214.2,64.3 214.2,65.91 211.23,68.88 210.29,68.88 209.58,69.59 209.58,70.25 208.94,70.9 205.08,70.9 204.88,70.7 203.8,70.7 202.05,68.95 198.53,68.95 188.72,78.76 188.72,98.24 185.86,101.1 185.86,103.38 183.07,106.17 182.64,106.17 179.95,108.85 161.21,108.85 160.9,109.16 159.45,109.16 158.71,108.42 139.74,108.42 137.33,106 137.33,100.49 139.42,98.39 139.42,97.44 139.73,97.13 140.26,97.13 140.73,97.6 v2(141.31,97.6)
  BOTTOM w0.076: UH1.BP27 140.98,97.24 141.31,97.57 v2(141.31,97.6) ; UH2.AT4 295.39,34.8 295.1,34.51 v2(295.1,34.41)
  BOTTOM w0.14: v2(215.81,59.12) 215.08,58.38 211.45,58.38 209.87,59.97 JXDP1.5 209.87,63.1 210.92,64.15 212.93,64.15 213.74,63.34 v2(213.75,63.34)
XDP_PREQ#: length 265.7
  IN2 w0.097: v2(215.22,59.13) 215.61,59.53 216.26,59.53 216.32,59.46 216.49,59.29 218.01,59.29 218.35,59.63 221.22,59.63 221.71,59.14 227.01,59.14 227.53,59.66 230.32,59.66 231.01,60.35 232.04,60.35 235.32,63.62 259.67,63.62 261.98,61.32 274.21,61.32 276.99,58.54 277.45,58.54 283.93,58.54 286.11,56.36 286.11,55.54 286.69,54.96 286.69,54.04 286.85,53.88 286.85,53.09 289.31,50.63 290.42,50.63 291.45,49.6 293.73,49.6 294.96,48.37 295.59,48.37 296.7,47.26 296.7,46.77 296.9,46.57 296.9,43.9 296.2,43.2 296.2,37.56 295.13,36.49 295.13,35.03 296.58,33.59 v2(297.17,33.59)
  IN3 w0.124: v2(132.75,97.95) 132.86,98.05 133.63,98.05 134.28,98.71 134.28,104.17 139.47,109.36 158.48,109.36 159.42,110.3 168.1,110.3 168.34,110.54 175.14,110.54 175.99,109.69 180.3,109.69 181.14,108.84 183.99,108.84 185.33,107.51 185.33,106.4 187.73,104 187.73,103.62 190.64,100.71 190.64,79.91 194.92,75.63 195.22,75.63 197.02,73.84 197.02,71.89 198.33,70.58 198.52,70.39 202.62,70.39 203.26,71.03 204.82,71.03 204.96,71.18 209.05,71.18 209.86,70.37 209.86,69.7 210.41,69.16 212.38,69.16 212.99,68.55 213.88,68.55 215.97,66.47 215.97,63.58 v2(216.21,63.34)
  BOTTOM w0.076: 137.31,98.45 137.55,98.45 138.41,99.32 142.75,99.32 UH1.BL30
  BOTTOM w0.089: v2(297.17,33.59) 296.49,34.27 295.95,34.27 UH2.AT3
  BOTTOM w0.14: v2(216.21,63.34) 215.7,62.83 213.61,62.83 212.58,63.86 211.04,63.86 210.37,63.19 JXDP1.3 210.37,59.88 211.53,58.72 214.81,58.72 v2(215.22,59.13) ; v2(132.75,97.95) 132.75,97.44 133.2,96.99 134.09,96.99 134.39,97.29 134.5,97.29 RH156.2 135.53,98.33 136.22,98.33 136.35,98.45 137.31,98.45
XDP_PRESENT#: length 4.6
  TOP w0.14: v2(195.87,66.77) v1(196.51,66.77) 196.69,66.59 RH519.1 RH540.2
  BOTTOM w0.14: v2(195.87,66.77) 196.06,66.58 196.27,66.58 196.37,66.68 JXDP1.60
XDP_PWRGOOD: length 5.4
  TOP w0.14: v2(201.74,59) 201.74,58.31 RH541.2 RH542.2
  BOTTOM w0.14: JXDP1.39 201.37,60.36 201.77,59.96 201.77,59.02 v2(201.74,59)
XDP_TDI: length 274.6
  TOP w0.14: v2(133.39,100.87) 133.74,101.22 v1(135.47,101.22) RH534.1
  IN2 w0.097: v2(305.08,30.65) 305.08,30.65 307.32,32.89 307.32,38.62 306.57,39.37 306.57,44.25 307.17,44.85 307.46,44.85 309.67,47.06 309.67,52.56 306.56,55.67 303.72,55.67 302.21,57.18 298.4,57.18 294.41,61.16 292.42,61.16 291.21,62.37 291.21,62.51 288.67,65.05 284.65,65.05 281.61,68.09 277.19,68.09 277.19,68.09 275.67,68.09 275.35,67.77 263.99,67.77 262.09,69.67 245.37,69.67 244.51,70.54 238.31,70.54 237.44,69.67 233.45,69.67 232.08,68.3 230.28,68.3 229.16,69.42 212.05,69.42 211.5,68.86 197.97,68.86 196.91,67.8 194.77,67.8 193.97,68.6 192.71,68.6 192.34,68.97 v2(192.25,68.97)
  IN3 w0.127: v2(195.24,76.93) 194.25,76.93 190.96,80.22 190.96,100.78 188.01,103.73 188.01,104.11 185.6,106.52 185.6,107.62 184.11,109.12 181.27,109.12 180.43,109.96 176.11,109.96 175.26,110.82 168.22,110.82 167.99,110.58 159.31,110.58 158.36,109.64 139.31,109.64 133.9,104.23 133.9,101.37 v2(133.39,100.87)
  BOTTOM w0.14: v2(305.08,30.65) 305.08,30.56 304.04,29.52 302.32,29.52 RH537.1 ; v2(192.25,68.97) 192.34,68.97 192.4,68.91 194.53,68.91 195.21,68.23 195.21,66.49 195.6,66.09 196.85,66.09 197.37,66.61 JXDP1.56 197.37,69.41 196.85,69.93 196.14,69.93 194.98,71.08 194.98,72.21 194.28,72.91 194.28,75.14 195.05,75.91 195.05,76.74 v2(195.24,76.93)
XDP_TDO: length 277.9
  TOP w0.14: RH533.1 136.02,98.55 v2(135.77,98.8)
  IN2 w0.097: v2(304.47,30.69) 304.5,30.69 307.13,33.32 307.13,38.54 306.37,39.29 306.37,44.33 307.09,45.05 307.38,45.05 309.47,47.14 309.47,52.48 306.48,55.47 303.64,55.47 302.13,56.98 298.32,56.98 294.33,60.97 292.34,60.97 291.01,62.29 291.01,62.42 288.59,64.85 284.57,64.85 281.53,67.89 277.11,67.89 277.11,67.89 275.75,67.89 275.43,67.57 263.91,67.57 262.01,69.47 245.29,69.47 244.42,70.34 238.39,70.34 237.52,69.47 233.53,69.47 232.16,68.1 230.2,68.1 229.08,69.22 212.14,69.22 211.58,68.67 198.05,68.67 196.99,67.6 194.69,67.6 193.89,68.4 192.94,68.4 191.78,67.25 v2(190.96,67.25)
  IN3 w0.124: v2(190.96,67.25) 190.96,66.03 184.34,59.41 182.87,59.41 v2(182.86,59.41)
  IN4 w0.137: v2(135.77,98.8) 133.77,96.8 133.77,92.98 125.48,84.69 125.48,66.99 132.05,60.42 182.67,60.42 182.86,60.22 v2(182.86,59.41)
  BOTTOM w0.14: JXDP1.52 198.37,66.66 197.32,65.61 195.4,65.61 194.72,66.29 194.72,68.03 194.33,68.42 192.65,68.42 191.47,67.25 v2(190.96,67.25) ; v2(304.47,30.69) v1(304.02,30.24) 303.75,29.97 RH539.1
