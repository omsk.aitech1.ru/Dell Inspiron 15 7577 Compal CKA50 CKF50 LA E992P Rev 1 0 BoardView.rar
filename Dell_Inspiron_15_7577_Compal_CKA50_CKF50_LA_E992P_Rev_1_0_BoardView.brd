# Allegro board Dell_Inspiron_15_7577_Compal_CKA50_CKF50_LA_E992P_Rev_1_0_BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MDO2-: length 29.3
  IN1 w0.089: JLAN.5 13.59,89.49 13.71,89.37 15.74,89.37 17.14,87.97 17.14,77.75 19.26,75.63 26.23,75.63 26.65,76.04 26.65,76.43 v2(26.84,76.62)
  BOTTOM w0.112: v2(26.84,76.62) 26.84,75.4 26.98,75.26 TL2.20
MDO3+: length 31.2
  IN5 w0.089: v2(29.11,76.16) 29.31,75.96 29.31,75.59 28.49,74.78 19.59,74.78 16.9,77.47 16.9,86.98 15.96,87.92 15.07,87.92 14.6,87.45 JLAN.7
  BOTTOM w0.112: TL2.22 28.96,74.62 29.25,74.92 29.25,76.02 v2(29.11,76.16)
MDO3-: length 31.3
  IN5 w0.089: v2(29.69,76.16) 29.57,76.04 29.57,75.49 28.6,74.52 19.48,74.52 16.64,77.36 16.64,86.87 15.85,87.66 15.18,87.66 14.71,87.19 14.1,87.19 13.95,87.04 JLAN.8
  BOTTOM w0.112: v2(29.69,76.16) 29.54,76.01 29.54,74.92 29.95,74.52 TL2.23
ME_FWP: length 30.1
  TOP w0.14: v1(316.62,15.87) 316.82,16.06 317.37,16.06 RE21.1 317.09,15.34 v2(316.9,15.34) 316.49,14.93 315.81,14.93 315.75,14.99 UE1.80
  IN5 w0.097: v2(299.01,24.56) 299,24.56 299,22.05 302.52,18.52 302.52,17.04 304.88,14.68 316.24,14.68 v2(316.9,15.34)
  BOTTOM w0.14: RH18.1 299.26,24.56 v2(299.01,24.56)
ME_SUS_PWR_ACK: length 4.1
  TOP w0.14: RH67.1 288.25,27.45 288.25,28.81 v2(287.7,29.37)
  BOTTOM w0.076: UH2.BD19 287.77,30.69 287.77,30.38 287.7,30.31 v2(287.7,29.37)
MEC_XTAL1: length 2.9
  TOP w0.14: Y1.1 302.4,27.33 CE102.1 302.41,26.46 RE66.2
MEC_XTAL1_R: length 4.7
  TOP w0.14: UE1.123 302.8,24.06 302.87,24.13 302.87,24.86 303.33,25.31 RE66.1 303.79,25.56 304.69,26.46 v1(304.69,26.65)
MEC_XTAL2: length 5.7
  TOP w0.14: Y1.2 301.41,27.35 CE101.1 301.36,26.42 RE106.1 302,24.91 v1(302,24.62) 302,23.01 UE1.125
MEM_VDD_CTL: length 66.1
  TOP w0.14: v1(231.52,51.34) v2(232.12,51.34) PR810.1
  IN5 w0.254: v2(202.55,81.45) 203.44,81.45 203.71,81.72 204.48,81.72 204.83,81.37 204.83,79.28 205.72,78.39 206.54,78.39 206.76,78.16 207.72,78.16 208.38,77.5 211.47,77.5 212.1,76.86 213.46,76.86 214.33,77.73 233.81,77.73 v2(234.67,76.86)
  BOTTOM w0.254: UG9.BH4 v2(202.55,81.45) ; v2(232.12,51.34) 232.12,52.15 230.96,53.3 230.96,56.13 233.22,58.39 233.22,62.2 235.59,64.56 235.59,75.95 v2(234.67,76.86)
MEM_VREF: length 199.4
  TOP w0.089: v2(205.98,81.37) 205.75,81.6 RG24.1
  IN2 w0.381: v2(257.79,126.58) 257.79,135.92 250.3,143.41 217.05,143.41 216.16,142.51 v2(215.11,142.51)
  IN3 w0.508: v2(244.35,73.37) 244.36,73.36 244.68,73.36 246.4,71.65 266.77,71.65 267.36,72.24 267.36,74.53 v2(265.85,76.04)
  IN5 w0.508: v2(244.35,73.37) 241.54,76.18 236.98,76.18 234.61,78.55 214.87,78.55 213.26,80.16 212.54,80.16 212.41,80.04 207.75,80.04 206.42,81.37 v2(205.98,81.37)
  BOTTOM w0.305: UG9.BD3 205.66,81.05 v2(205.98,81.37)
  BOTTOM w0.381: 263.76,89.62 263.95,89.62 264.64,88.93 264.64,77.04 265.65,76.04 v2(265.85,76.04) ; 263.76,89.62 261.48,89.62 260.51,90.59 QG4.2 ; 263.76,89.62 264.27,90.13 264.27,94.51 266.89,97.13 266.89,125.63 v1(266.53,125.99) 265.75,126.77 261.18,126.77 QG3.2 259.2,125.17 v2(257.79,126.58) ; QG2.2 215.36,137.99 215.36,138.77 215.11,139.02 v2(215.11,142.51)
MIC2_VREFO: length 10.1
  TOP w0.203: HDA1.29 348.02,19.46 348.54,18.94 v2(348.72,18.94)
  IN2 w0.305: v2(348.72,18.94) 348.72,16.41 v2(345.48,13.17)
  BOTTOM w0.305: v2(345.48,13.17) RA42.1 RA43.1
MODEL_ID: length 6.4
  TOP w0.14: v2(308.13,21.78) 308.4,22.05 UE1.109
  BOTTOM w0.14: v1(306.62,24.46) 305.74,23.59 RE125.2 305.75,23.38 CE104.1 RE124.2 307.43,21.78 v2(308.13,21.78)
MSATA_DEVSLP: length 40.2
  TOP w0.14: v2(276.75,38.99) v1(276.08,38.99)
  IN1 w0.097: v2(275.74,15.26) 278.89,15.26 279.43,14.72 280.06,14.72 280.84,15.5 283.62,15.5 v2(284.62,14.5)
  IN2 w0.097: v2(276.75,38.99) 275.63,37.86 275.63,34.56 277.23,32.96 277.23,32.61 276.5,31.89 276.15,31.89 275.65,31.4 275.65,31.25 274.46,30.06 274.46,28.84 276.42,26.89 276.42,17.99 276.99,17.42 276.99,15.8 276.44,15.26 v2(275.74,15.26)
  BOTTOM w0.089: UH2.AG42 276.75,39.01 v2(276.75,38.99)
  BOTTOM w0.14: RD59.2 284.88,15.07 284.62,14.81 v2(284.62,14.5)
MSCLK: length 4.8
  BOTTOM w0.14: JDEG1.6 322.75,7.97 v1(322.33,8.4) 321.98,8.74 RE63.2
MSDATA: length 5
  BOTTOM w0.14: RE65.2 v1(321.03,10.24) 321.03,8.69 322.25,7.47 JDEG1.7
NB_MUTE#: length 3.4
  TOP w0.14: UE1.119 304.4,21.66 v2(304.35,21.62)
  BOTTOM w0.14: RE58.2 304.2,21.48 304.34,21.62 v2(304.35,21.62) 304.79,22.05 v1(304.79,22.69)
NC_B4: length 3.3
  BOTTOM w0.076: RT86.2 RT45.1 358.94,61.01 358.94,59.91 358.71,59.68 358.71,59.01 UT1.B4
NC_B5: length 3
  BOTTOM w0.089: 357.8,59.65 357.81,59.64 357.81,59.02 UT1.B5
  BOTTOM w0.127: RT46.1 356.59,60.86 v1(357.09,60.37) 357.8,59.65
NC_G2: length 5.1
  BOTTOM w0.076: UT1.G2 359.46,56.49 359.7,56.25 360.06,56.25 360.87,55.44 360.87,54.44 361.23,54.08
  BOTTOM w0.14: RT47.1 362.5,54.07 362.31,53.88 361.43,53.88 361.23,54.08
NRB_BIT: length 4.3
  BOTTOM w0.076: 283.67,29.49 283.67,29.76 283.95,30.04 283.95,30.57 283.81,30.71 283.41,30.71 UH2.BD28
  BOTTOM w0.14: 283.67,29.49 v1(283.67,28.27) 283.67,27.78 RH92.2
NTC_LA: length 3.3
  TOP w0.14: v1(147.36,144.77) 147.84,145.25 PH6000.1
  TOP w0.254: PH6000.1 PR6008.1 148.6,143.42 PR6007.2
NTC_LB: length 16.4
  TOP w0.127: v1(157.32,145.19) 156.88,144.76 v2(156.88,144.49)
  TOP w0.254: v2(156.88,144.49) 156.88,143.84 PR6020.1 ; PC6009.1 150.42,144.25 PR6011.2 150.42,143.4 PC6007.2 149.53,144.3 PR6008.2 PH6000.2 149.85,145.58 151.13,145.58 v2(151.46,145.25) 151.47,145.27 PR6009.2 152.13,145.25 PR6012.2 PR6010.2
  BOTTOM w0.254: v2(151.46,145.25) 151.7,145.25 151.72,145.27 152.74,145.27 154.28,143.73 156.12,143.73 v2(156.88,144.49)
NVVDD1_EN: length 226.1
  TOP w0.14: PQ6000.2 165.71,132.48 166,132.18 v1(167.77,132.18) ; v2(222.73,58.15) 222.73,58.27 223.38,58.92 224.77,58.92 RG549.2 225.31,60.59 225.5,60.78 225.63,60.65 DG7.1 226.13,60.53 226.46,60.86 CG442.1
  TOP w0.254: PR6040.2 161.08,132.27 v2(161.4,131.95) 161.74,131.95 162.03,131.66 162.98,131.66 164.01,132.69 164.01,133.31 164.25,133.56 165.41,133.56 165.71,133.25 PQ6000.2
  IN1 w0.097: v2(222.73,58.15) 220.07,58.15 219.01,57.08 214.54,57.08 213.81,57.81 212.21,57.81 211.48,57.08 207.19,57.08 206.65,57.62 194.41,57.62 192.98,56.19 v2(192.98,55.91)
  IN2 w0.254: v2(124.32,94.44) 124.32,94.67 123.03,95.96 123.03,102.06 127.65,106.68 127.95,106.68 128.24,106.96 128.24,107.27 128.25,107.28 128.25,117.26 130.71,119.73 130.71,119.73 132.15,121.17 132.15,123.29 133.11,124.26 135.13,124.26 139.4,128.53 140.3,128.53 141.73,129.96 146.95,129.96 148.2,128.71 149.17,128.71 150.24,129.78 155.2,129.78 156.01,128.97 157.56,128.97 159.81,131.22 160.99,131.22 161.4,131.63 v2(161.4,131.95)
  IN5 w0.254: v2(124.32,94.44) 126.85,91.91 126.85,85.8 123.64,82.59 123.64,59.61 128.86,54.38 v2(130.47,54.38)
  BOTTOM w0.254: v2(130.47,54.38) 192.49,54.38 192.98,54.87 v2(192.98,55.91)
NVVDD1_ENP: length 10.8
  TOP w0.14: v1(163.63,131.64) 163.91,131.92 v2(164.06,131.92)
  TOP w0.203: PR6036.1 158.41,134.09 v2(158.54,134.23) PU6000.36
  TOP w0.254: v2(164.06,131.92) 164.47,131.92 165.06,132.51 PQ6000.3
  IN1 w0.254: v2(164.06,131.92) 163.85,131.92 162.08,133.68 159.09,133.68 v2(158.54,134.23)
NVVDD1_PGOOD: length 149.5
  TOP w0.14: v2(224.09,63.33) 224.09,63.81 224.05,63.84 224.05,63.94 DG4.1
  TOP w0.203: PU6000.38 159.34,134.92 v2(159.58,134.69) 159.78,134.48 159.78,133.99 PR6061.2
  IN2 w0.254: v2(203.8,73.04) 203.72,73.04 203.72,73.02 198.77,73.02 197.11,74.68 197.11,77.11 196.4,77.82 191.49,77.82 191.22,77.55 189.81,77.55 188.92,76.65 187.36,76.65 185.57,78.43 185.57,83.65 187.94,86.01 187.94,100.3 183.28,104.96 182.21,104.96 181.52,105.64 181.52,106.71 180.43,107.81 180.43,108.1 180.43,115.37 179.56,116.23 173.58,116.23 173.08,116.74 173.08,118.47 172.11,119.43 172.11,121.76 171.67,122.2 167.83,122.2 167.08,122.95 166.68,122.95 164.89,124.74 164.89,127.45 163.82,128.51 163.82,129.22 162.09,130.95 162.09,132.17 v2(159.58,134.69)
  IN4 w0.137: v2(203.8,73.04) 203.72,73.04 203.72,72.96 202.79,72.04 201.74,72.04 200.47,70.77 199.8,70.77 199.34,70.31 199.34,68.36 199.95,67.75 199.95,66.11 199.63,65.79 199.63,61.54 200.59,60.59 200.59,59.43 201.49,58.53 203.09,58.53 203.94,57.68 207.24,57.68 208.24,56.68 216.97,56.68 219.66,59.37 219.66,60.57 221.99,62.89 223.66,62.89 224.09,63.32 v2(224.09,63.33)
  BOTTOM w0.14: v2(203.8,73.04) 203.8,73.01 203.94,72.86 203.94,71.15 203.75,70.96 UG29.2
NVVDD_B+: length 21
  TOP w0.508: PR6006.1 152.31,137.65 PC6000.2 152.1,137.43 v2(151.56,137.43)
  IN3 w0.508: v2(151.56,137.43) 154.23,137.43 155.65,136.01 163.07,136.01 163.46,135.61 165.24,135.61 166.22,136.59 168.53,136.59 168.56,136.62
  BOTTOM w0.508: v2(178.28,143.69) 177.72,144.25 PC6125.1
  vias: v2(165.76,142.67) v2(166.44,142.67) v2(167.1,142.67) v2(167.11,142.04) v2(171.29,144.39) v2(171.29,143.72) v2(173.57,142.4) v2(173.57,141.59) v2(173.71,134.95) v2(174.03,133.59) v2(174.03,132.78) v2(174.25,142.4) v2(174.25,141.59) v2(174.35,134.95) v2(174.35,122.52) v2(174.64,124.25) v2(174.7,133.59) v2(174.7,132.78) v2(174.66,123.66) v2(174.66,123.03) v2(175.17,126.2) v2(175.56,121.08) v2(175.56,120.26) v2(175.81,126.2) v2(176.23,121.08) v2(176.23,120.26) v4(174.66,120.82)
NVVDD_ISUMN1: length 41.8
  TOP w0.14: v2(181.78,129.95) 181.89,130.06 v4(182.61,130.06)
  TOP w0.254: PR6009.1 152.12,144.17 v2(152.57,143.73)
  IN1 w0.254: v2(181.78,129.95) 181.59,129.76 176.25,129.76 176.06,129.57 173.71,129.57 172.48,130.8 172.48,133.34 170.43,135.39 169.98,135.39 167.1,138.27 163.55,138.27 158.77,143.04 154.31,143.04 153.37,143.98 152.82,143.98 v2(152.57,143.73)
  BOTTOM w0.254: PL6101.3 183.17,130.2 182.79,129.82 181.9,129.82 v2(181.78,129.95)
NVVDD_ISUMN2: length 35.8
  TOP w0.14: v2(182.35,139.86) v1(181.6,139.86)
  TOP w0.254: v2(154.53,144.36) PR6010.1
  IN1 w0.254: v2(182.35,139.86) 182.47,139.98 182.47,141.63 181.9,142.2 178.36,142.2 176.8,143.77 173.36,143.77 171.93,145.19 156.82,145.19 155.74,144.11 154.98,144.11 154.73,144.36 v2(154.53,144.36)
  BOTTOM w0.254: PL6102.3 182.92,138.78 182.35,139.35 v2(182.35,139.86)
NVVDD_ISUMN3: length 62.4
  TOP w0.14: v1(183.52,118.8) 183.52,118.28 183.06,117.82 v2(182.79,117.82)
  TOP w0.254: v2(154.53,145.44) 154.34,145.25 PR6012.1
  IN1 w0.254: v2(182.79,117.82) 181.78,117.82 180.57,116.61 175.24,116.61 174.35,117.5 174.35,121.18 175.15,121.98 175.15,124.71 174.16,125.7 174.16,126.35 172.75,127.75 171.85,127.75 170.94,128.66 170.94,130.88 168.34,133.48 168.34,135.45 168.31,135.47 168.31,135.5 167.99,135.82 165.66,135.82 165.23,135.38 164.02,135.38 161.51,137.89 161.51,138.79 158.36,141.95 152.95,141.95 151.55,143.35 151.55,144.3 152.57,145.32 154.41,145.32 v2(154.53,145.44)
  BOTTOM w0.254: PL6103.3 185.01,117.44 184.51,117.95 182.92,117.95 v2(182.79,117.82)
NVVDD_ISUMP1: length 41.3
  TOP w0.14: v2(181.78,129.31) v4(181.78,128.37)
  TOP w0.254: PR6002.1 v2(153.14,143.49)
  IN1 w0.254: v2(181.78,129.31) 181.71,129.38 176.38,129.38 176.19,129.19 173.52,129.19 172.12,130.58 172.12,133.2 170.29,135.03 169.83,135.03 166.95,137.91 163.4,137.91 158.63,142.69 153.94,142.69 v2(153.14,143.49)
  BOTTOM w0.254: PL6101.2 183.17,128.93 182.67,129.44 181.9,129.44 v2(181.78,129.31)
NVVDD_ISUMP2: length 35.6
  TOP w0.14: v2(182.98,139.86) v1(182.98,140.68)
  TOP w0.254: PR6003.1 154.85,143.93 155.17,144.25 v2(155.17,144.62)
  IN1 w0.254: v2(155.17,144.62) 155.68,144.62 156.63,145.57 172.06,145.57 173.51,144.12 176.95,144.12 178.49,142.59 182.03,142.59 182.86,141.76 182.86,139.98 v2(182.98,139.86)
  BOTTOM w0.254: v2(182.98,139.86) 182.92,139.92 PL6102.2
NVVDD_ISUMP3: length 61.9
  TOP w0.254: v2(155.11,145.32) 155.36,145.32 155.74,144.94 v1(155.74,144.63) PR6004.1
  IN1 w0.254: v2(182.79,118.46) 181.78,118.46 180.35,117.03 175.46,117.03 174.73,117.76 174.73,121.06 175.5,121.83 175.5,124.86 174.6,125.76 174.6,126.41 172.9,128.11 172,128.11 171.3,128.81 171.3,131.03 168.7,133.63 168.7,135.6 168.67,135.63 168.67,135.64 168.14,136.17 165.51,136.17 165.08,135.74 164.16,135.74 161.87,138.04 161.87,138.94 158.48,142.33 153.07,142.33 151.93,143.47 151.93,144.11 152.76,144.94 154.73,144.94 v2(155.11,145.32)
  BOTTOM w0.254: PL6103.2 185.01,118.77 184.57,118.33 182.92,118.33 v2(182.79,118.46)
NVVDD_PSI: length 99.4
  TOP w0.14: v1(195.62,89.14) 195.87,89.14 v2(196.28,89.55)
  TOP w0.254: PR6051.1 159.3,131.92 v2(159.17,131.79)
  IN2 w0.254: v2(207.68,75.66) 207.68,76.14 209.53,77.98 209.53,87.06 209.14,87.44 207.93,87.44 207.69,87.21 198.62,87.21 v2(196.28,89.55)
  IN4 w0.254: v2(196.28,89.55) 196.28,89.8 195.38,90.7 195.38,95.62 188.44,102.56 188.44,103.87 187.88,104.43 187.88,104.44 186.44,105.89 186.44,107.3 183.78,109.96 181.09,109.96 180.77,110.28 180.77,115.97 179.85,116.89 174.23,116.89 174.04,116.7 173.52,116.7 173.27,116.96 173.27,119.6 172.37,120.5 172.37,125.48 170.92,126.93 163.21,126.93 161.9,128.23 159.42,128.23 158.71,128.95 158.71,130.2 159.4,130.89 159.4,131.56 v2(159.17,131.79)
  BOTTOM w0.14: RG566.2 207.07,75.49 RG162.1 207.54,75.46 207.68,75.6 v2(207.68,75.66)
NVVDD_VCC_SENSE: length 8.6
  TOP w0.14: PR6021.2 196.56,109.36 196.51,109.31 v1(196.51,108.74)
  TOP w0.254: PR6021.2 196.41,109.81 195.81,110.4 v2(195.7,110.4)
  BOTTOM w0.102: UG9.BM45 200.37,110.77 201.14,110.77 201.45,110.47 UG9.BK45
  BOTTOM w0.254: UG9.BM45 198.7,110.45 198.24,110.91 196.21,110.91 v2(195.7,110.4)
NVVDD_VID: length 78.5
  TOP w0.254: v2(162.73,132.17) 162.33,132.17 161.96,132.54 PR6069.1
  IN2 w0.254: v2(205.95,82.85) 205.4,83.4 202.86,83.4 202.41,82.96 201.08,82.96 200.38,83.66 200.38,84.39 197.25,87.53 194.53,87.53 191.54,90.52 191.54,97.2 180.79,107.95 180.79,115.51 179.71,116.59 175.46,116.59 172.47,119.58 172.47,122.65 170.09,125.02 170.09,125.76 170.03,125.82 170.03,128.43 168.45,130.01 166.88,130.01 164.4,132.49 163.78,132.49 163.46,132.17 v2(162.73,132.17)
  BOTTOM w0.114: UG9.BD6 205.95,82.85 v2(205.95,82.85)
NVVDD_VSS_SENSE: length 3.7
  BOTTOM w0.254: UG9.BL45 UG9.BM44 198.46,109.75 197.94,110.26 PR6026.2
NVVDDB_B+: length 0.9
  TOP w0.14: v2(167.25,135.3) v4(167.25,136.2)
  vias: v2(114.21,115.85) v2(114.21,115.22) v2(114.21,114.58) v2(114.21,111.41) v2(114.85,115.85) v2(114.85,115.22) v2(114.85,114.58) v2(114.85,111.41) v2(115.48,115.85) v2(115.48,115.22) v2(115.48,114.58) v2(115.48,111.41) v2(116.12,115.85) v2(116.12,115.22) v2(116.12,114.58) v2(116.12,111.41) v2(164.82,134.08) v2(165.43,134.08) v2(166.08,135.3) v2(166.08,134.66) v2(166.08,134.08) v2(166.66,135.3) v2(166.66,134.66) v2(166.66,134.08) v2(167.25,134.66) v2(167.25,134.08) v2(167.83,135.3) v2(167.83,134.66) v2(167.83,134.08)
OVERT#: length 7
  TOP w0.089: RG576.1 206.73,80.04 v2(206.48,79.78) 206.4,79.78 v1(206.07,80.11) ; RG168.1 203.65,82.55 v2(203.25,82.15)
  IN1 w0.097: v2(203.25,82.15) 203.85,81.55 204.96,81.55 205.33,81.18 205.33,80.93 v2(206.48,79.78)
  BOTTOM w0.114: UG9.BG5 v2(203.25,82.15)
P1: length 65.2
  TOP w0.254: v2(36.5,45.47) 36.5,44.65 PR710.1 ; PR700.2 52.3,24.59 PQ700.3 53.43,24.59 54.61,23.41 v1(54.93,23.41) 55.93,23.41 PC702.1 56.88,24.36 v2(56.88,25.26)
  IN2 w0.508: 55.16,48.67 54.66,48.17 37.97,48.17 36.5,46.7 v2(36.5,45.47)
  IN4 w0.508: v2(36.5,45.47) 36.62,45.35 36.62,44.65 37.59,43.68 37.59,41.36 38.71,40.23 38.71,37.21 39.13,36.79 39.13,33.63 40.78,31.98 46.67,31.98 49.44,29.21 49.44,26.89 50.13,26.2 51.14,26.2 52.87,24.48 56.39,24.48 56.88,24.97 v2(56.88,25.26)
  vias: v2(56.43,50.51) v2(56.43,49.88) v2(56.43,49.24) v2(56.43,48.61) v2(56.43,47.97) v2(56.43,47.34) v2(56.43,46.7) v2(56.43,46.07) v2(56.48,53.75) v2(56.48,53.11) v2(56.48,52.42) v2(56.48,51.78) v2(56.48,51.15) v2(57.06,53.75) v2(57.06,53.11) v2(57.06,52.42) v2(57.06,51.78) v2(57.06,51.15) v2(57.06,50.45) v2(57.06,49.81) v2(57.06,49.11) v2(57.06,48.48) v2(57.06,47.84) v2(57.06,47.21) v2(57.06,46.57) v2(57.06,45.99)
P2:
  vias: v1(52.22,41.84)
P_SYS: length 204.8
  TOP w0.14: v2(99.8,53.56) v1(99.8,54.46)
  TOP w0.203: PR728.2 v2(31.1,39.13) 31.63,39.13 31.78,39.27 PU700.9
  TOP w0.254: PR5028.1 v2(129.33,143.71)
  IN1 w0.254: v2(99.8,53.56) 90.91,53.56 88.69,51.34 85.07,51.34 82.53,53.88 59.04,53.88 57.68,55.24 55.63,55.24 51.14,50.75 45.09,50.75 43.6,49.27 36.3,49.27 34.98,47.95 34.98,40.33 33.69,39.04 31.18,39.04 v2(31.1,39.13)
  IN4 w0.254: v2(99.8,53.56) 120.15,53.56 122.29,55.71 122.29,89.21 122.93,89.84 122.93,95.39 123.72,96.18 123.72,103.26 124.5,104.03 124.5,105.51 124.02,105.99 124.02,108.61 124.44,109.03 125.81,109.03 126.05,109.27 126.05,113.69 122.45,117.29 122.45,135.34 128.3,141.19 128.3,141.81 129.33,142.84 v2(129.33,143.71)
PA_USB2_RBIAS: length 4.4
  TOP w0.14: v1(350.58,57.01) 350.58,56.23 350.91,55.9 351.31,55.9 v2(351.9,56.48) 352.31,56.9 352.31,57.66 RT43.1
  BOTTOM w0.102: v2(351.9,56.48) 351.9,56.48 UT1.H19
PANEL_BKEN_EC: length 278.8
  TOP w0.14: v2(305.15,24.26) 305.2,24.21 UE1.117 ; RV566.1 92.67,50.14 92.5,50.32 v1(90.23,50.32) v2(89.64,50.32)
  IN3 w0.124: v2(305.15,24.26) 305.15,21.21 305.78,20.58 305.78,17.66 301.56,13.44 300.19,13.44 298.85,12.09 291.91,12.09 291.46,11.65 289.04,11.65 287.81,10.41 286.89,10.41 285.43,11.88 273.62,11.88 272.77,12.72 271.78,12.72 269.93,14.57 264.73,14.57 254.78,24.52 239.16,24.52 237.46,26.22 224.86,26.22 223.8,25.16 209.41,25.16 208.76,25.81 162.21,25.81 161.89,25.49 136.73,25.49 136.55,25.32 135.54,26.33 118.08,26.33 117.16,25.41 87.84,25.41 v2(85.57,23.14)
  IN4 w0.137: v2(85.57,23.14) 87.16,24.73 87.16,29.56 84.3,32.42 84.3,33.36 84.8,33.86 87.44,33.86 88.32,34.73 88.32,37.82 86.49,39.65 86.49,47.29 89.53,50.32 v2(89.64,50.32)
PB_USB2_RBIAS: length 3.2
  TOP w0.14: v2(351.88,57.12) 351.69,57.31 351.69,58.04 RT44.1 350.72,59.25 v1(350.68,59.25)
  BOTTOM w0.076: v2(351.88,57.12) 351.88,57.11 UT1.F19
PBAT_CHG_SMBCLK: length 311.5
  TOP w0.14: PD3.2 60.95,31.34 v1(60.83,31.45) ; UE1.9 300.08,18.19 300.18,18.09 301.09,18.09 v2(301.53,17.65)
  TOP w0.254: v2(62.26,28.84) 60.98,30.12 PD3.2 60.94,30.13 PR8.2 ; v2(28.64,36.79) 28.64,36.83 29.6,37.79 PR731.1
  IN3 w0.124: v2(28.64,36.79) 28.75,36.68 29.87,36.68 30.32,36.24 30.32,33.8 29.54,33.02 29.54,30.54 36.13,23.95 67.15,23.95 ; 67.15,23.95 84.67,23.95 86.59,25.86 116.97,25.86 117.89,26.78 135.73,26.78 136.56,25.95 161.7,25.95 162.02,26.26 208.95,26.26 209.52,25.69 223.7,25.69 224.74,26.74 237.58,26.74 239.35,24.97 255.09,24.97 264.24,15.83 269.8,15.83 271.42,14.21 272.62,14.21 274.5,12.33 285.94,12.33 286.7,13.08 287.14,13.08 287.46,13.41 299.24,13.41 300.14,14.3 300.43,14.3 301.83,15.7 301.83,17.35 v2(301.53,17.65) ; 67.15,23.95 v2(62.26,28.84)
  BOTTOM w0.14: v2(301.53,17.65) 301.1,18.08 RE44.1
PBAT_CHG_SMBDAT: length 334.9
  TOP w0.127: v2(26.58,38.79) v1(26.58,39.65)
  TOP w0.14: v2(300.69,18.52) 300.62,18.59 UE1.8
  TOP w0.254: PR730.1 29.44,38.85 28.13,38.85 27.7,38.42 27.08,38.42 26.71,38.79 v2(26.58,38.79) ; PR10.2 60.05,29.12 PD3.3 61.3,29.12 v2(61.61,28.81)
  IN1 w0.097: v2(300.69,18.52) 299.88,17.71 294.08,17.71 292.85,18.94 288.82,18.94 287.44,17.56 285.53,17.56 284.93,16.96 280.75,16.96 280.19,17.52 277.14,17.52 276.4,18.26 273.05,18.26 272.12,19.19 270.89,19.19 267.58,22.5 263.33,22.5 257,28.83 254.55,28.83 253.69,29.7 243.83,29.7 242.21,31.32 225.77,31.32 225.43,31.66 172.43,31.66 171.83,32.26 142.73,32.26 142.48,32.51 125.86,32.51 124.63,33.75 102.27,33.75 100.17,35.85 v2(98.23,35.85)
  IN1 w0.254: v2(61.61,28.81) 60.16,27.36 51.56,27.36 50.62,28.29 49.39,28.29 48.37,27.27 37.42,27.27 31.49,33.19 29.49,33.19 26.94,35.74 26.94,38.53 26.71,38.76 26.61,38.76 v2(26.58,38.79)
  IN2 w0.254: v2(98.23,35.85) 97.46,35.08 93.49,35.08 92.38,33.98 88.64,33.98 87.68,33.01 85.3,33.01 84.93,32.63 84.93,29.45 85.38,29 94.77,29 95.92,27.84 95.92,23.46 95.35,22.89 91.16,22.89 90.15,23.9 85,23.9 84.05,22.95 67.46,22.95 v2(61.61,28.81)
  BOTTOM w0.14: RE43.1 300.17,19.03 v2(300.69,18.52)
PBAT_PRES#: length 291.4
  TOP w0.14: UE1.29 298.18,10.19 298.06,10.06 296.14,10.06 CE76.1 295.2,11 v2(295.2,12.75) 294.74,12.75 v1(294.16,13.34)
  TOP w0.254: PD4.2 60.07,28.09 PR12.2 ; PD4.2 61.31,28.09 v2(61.61,27.79) ; PD4.2 60.95,27.84 60.17,27.07 PR13.1 ; v2(63.46,28.83) 63.46,29.11 63.88,29.53 PC12.1 ; PR723.1 32,33.03 32.36,32.67 32.36,31.44 33.57,30.23 v2(33.57,30.23)
  IN1 w0.097: v2(295.2,12.75) 293.74,12.75 292.75,11.77 291.59,11.77 290.35,10.52 290.35,10.17 289.91,9.73 289.04,9.73 289.04,9.73 279.14,9.73 276.48,12.39 271.5,12.39 268.26,15.63 264.15,15.63 256.25,23.53 253.11,23.53 252.09,24.55 239.83,24.55 237.89,26.5 139.82,26.5 138.91,27.4 133.49,27.4 132.89,28 122.25,28 121.65,27.4 107.15,27.4 105.75,28.79 104.31,28.79 103.67,28.16 90.7,28.16 90.48,27.94 82.9,27.94 82.42,28.41 64.91,28.41 64.49,28.83 v2(63.46,28.83)
  IN1 w0.254: v2(33.57,30.23) 33.62,30.23 36.94,26.91 48.52,26.91 49.54,27.94 50.48,27.94 51.42,26.99 60.81,26.99 v2(61.61,27.79) 62.56,27.79 63.46,28.69 v2(63.46,28.83)
PCH_BATLOW#: length 6.8
  BOTTOM w0.076: UH2.BD13 291.02,30.71 291.02,29.39 290.42,28.79 290.42,28.48
  BOTTOM w0.14: RH81.1 288.65,25.67 289.99,27.02 v1(289.99,27.78) 290.42,28.21 290.42,28.48
PCH_CPU_BCLK_N: length 171.3
  IN2 w0.104: v2(181.22,101.27) 180.95,101.12 180.93,101.02 180.93,100.86 181.05,100.74 183.07,100.74 184,99.8 184,85.86 181.08,82.94 181.08,79.49 184.45,76.12 184.45,71.27 187.87,67.85 187.87,66.07 190.41,63.53 197.13,63.53 198.95,61.71 209.08,61.71 209.62,62.25 221.35,62.25 221.73,61.88 223.7,61.88 223.88,62.07 229.81,62.07 230.17,62.43 231.25,62.43 234.48,65.66 260.51,65.66 262.35,63.82 274.59,63.82 277.84,60.57 286.1,60.57 290.66,56.01 291.24,56.01 292.02,55.23 292.02,54.16 293.53,52.66 298.69,52.66 299.63,51.71 299.63,49.62 299.06,49.05 298.68,49.05 298.59,48.96 298.58,48.96 298.42,48.8 v2(298.42,48.78)
  BOTTOM w0.076: 298.11,49.08 298.1,49.08 297.92,49.08 297.76,48.92 297.27,48.92 297.07,48.72 296.48,48.72 UH2.H2
  BOTTOM w0.14: UH1.A32 180.52,100.84 181.17,100.84 181.31,100.98 181.31,101.18 v2(181.22,101.27) ; 298.11,49.08 298.4,48.78 v2(298.42,48.78)
PCH_CPU_BCLK_P: length 171
  IN2 w0.104: v2(180.61,101.43) 180.76,101.16 180.73,101.04 180.73,100.78 180.97,100.55 182.99,100.55 183.81,99.72 183.81,85.94 180.88,83.02 180.88,79.41 184.25,76.04 184.25,71.19 187.68,67.77 187.68,65.99 190.33,63.34 197.05,63.34 198.87,61.52 209.16,61.52 209.7,62.06 221.27,62.06 221.65,61.69 223.78,61.69 223.96,61.87 229.89,61.87 230.25,62.24 231.33,62.24 234.56,65.46 260.43,65.46 262.27,63.62 274.51,63.62 277.76,60.38 286.02,60.38 290.58,55.82 291.16,55.82 291.83,55.15 291.83,54.08 293.45,52.46 298.61,52.46 299.44,51.63 299.44,49.7 298.98,49.24 298.57,49.24 298.42,49.39 v2(298.42,49.37)
  BOTTOM w0.076: UH2.G2 296.39,49.17 296.67,48.89 297.01,48.89 297.21,49.09 297.69,49.09 297.97,49.37 298.11,49.37
  BOTTOM w0.14: v2(180.61,101.43) 180.24,101.43 180.23,101.42 180.15,101.42 180,101.27 180,101.26 179.94,101.2 179.94,101.12 179.65,100.83 UH1.B31 ; 298.11,49.37 v2(298.42,49.37)
PCH_CPU_PCIBCLK_N: length 177
  IN2 w0.104: v2(178.96,102.85) 179.16,102.85 179.26,102.95 179.26,103.2 179.13,103.33 178.93,103.33 178.82,103.43 178.82,103.58 178.96,103.72 181.82,103.72 185.9,99.64 185.9,94.14 184.57,92.8 184.57,85.58 182.52,83.53 182.52,78.89 185.01,76.4 185.01,71.45 188.38,68.08 188.38,66.31 190.08,64.61 196.75,64.61 199.06,62.29 208.89,62.29 209.34,62.74 225.56,62.74 225.7,62.88 226.88,62.88 226.95,62.8 229.63,62.8 229.74,62.92 231.03,62.92 234.26,66.14 260.72,66.14 262.55,64.3 275.19,64.3 278.43,61.06 286.3,61.06 290.86,56.5 291.44,56.5 292.67,55.27 294.31,55.27 296.39,53.19 298.85,53.19 300.3,51.73 300.3,48.34 300.14,48.18 298.79,48.18 298.71,48.26 298.29,48.26 298.2,48.18 298.05,48.18 v2(297.88,48.35)
  BOTTOM w0.076: v2(297.88,48.35) 297.66,48.14 297.12,48.14 296.86,48.39 296.63,48.39 296.56,48.31 296.56,48.19 296.69,48.07 UH2.J1
  BOTTOM w0.14: UH1.C36 178.91,102.89 v2(178.96,102.85)
PCH_CPU_PCIBCLK_P: length 177.1
  IN2 w0.104: v2(178.25,103.28) 178.88,103.91 181.9,103.91 186.1,99.72 186.1,94.06 184.76,92.72 184.76,85.5 182.72,83.45 182.72,78.97 185.21,76.48 185.21,71.53 188.57,68.16 188.57,66.39 190.16,64.8 196.83,64.8 199.14,62.49 208.81,62.49 209.26,62.93 225.48,62.93 225.62,63.07 226.96,63.07 227.03,62.99 229.55,62.99 229.66,63.11 230.95,63.11 234.18,66.34 260.8,66.34 262.63,64.5 275.27,64.5 278.51,61.25 286.38,61.25 290.94,56.69 291.52,56.69 292.75,55.47 294.39,55.47 296.47,53.38 298.93,53.38 300.5,51.81 300.5,48.26 300.22,47.98 298.71,47.98 298.63,48.07 298.37,48.07 298.28,47.98 298.1,47.98 v2(297.88,47.77)
  BOTTOM w0.076: UH2.J2 296.37,48.14 296.7,47.82 296.99,47.82 297.14,47.97 297.68,47.97 v2(297.88,47.77)
  BOTTOM w0.14: v2(178.25,103.28) 178.44,103.09 UH1.D35
PCH_DPWROK: length 4.2
  TOP w0.14: v4(294.9,31.79) 294.9,31.85 293.43,33.31 RH9.2 293.09,33.8 v2(293.09,34.06)
  BOTTOM w0.076: v2(293.09,34.06) 293.03,34.13 292.35,34.13 UH2.AV11
PCH_ESPI_CLK: length 5.9
  BOTTOM w0.076: 288.33,28.48 288.33,28.92 288.81,29.4 288.81,30.41 289.15,30.75 289.15,31.06 UH2.BC17
  BOTTOM w0.14: 288.33,28.48 288.33,27.77 288.2,27.64 RH168.1 288.52,26.7 v1(289.18,26.7)
PCH_ESPI_IO0: length 8.6
  TOP w0.14: v2(287.26,34.46) 287.26,34.25 287.69,33.82 287.69,33.35 287.41,33.07 287.41,32.02 287.52,31.92 287.52,31.16 v1(287.21,30.85) 286.96,30.6 286.96,27.21 RH574.1
  BOTTOM w0.089: UH2.AT22 287.17,34.58 287.26,34.49 v2(287.26,34.46)
PCH_ESPI_IO1: length 7.8
  TOP w0.14: v2(287.26,33.61) 287.11,33.45 287.11,32.13 286.59,31.61 286.59,29.91 285.9,29.23 285.9,28.24 v1(285.99,28.15) 285.99,27.29 RH575.1
  BOTTOM w0.089: UH2.AV22 287.06,33.81 v2(287.26,33.61)
PCH_ESPI_IO2: length 10.1
  TOP w0.14: RH576.1 285.64,27.51 285.64,29.35 286.32,30.04 286.32,31.82 v1(286.66,32.15) 286.84,32.33 286.84,34.98 v2(287.24,35.38)
  BOTTOM w0.089: v2(287.24,35.38) 287.24,35.37 287.76,34.84 UH2.AT19
PCH_ESPI_IO3: length 4.2
  TOP w0.14: RH577.1 288.84,27.47 288.77,27.54 288.77,28.43 v2(288.72,28.48)
  BOTTOM w0.076: UH2.BD16 289.49,30.78 288.98,30.27 288.98,29.28 288.72,29.03 v2(288.72,28.48)
PCH_ITP_PMODE: length 153.2
  TOP w0.14: v2(193.52,65.5) 193.52,64.28 193.22,63.97 192.03,63.97 v1(191.82,63.77) 191.66,63.77 191.53,63.9 191.53,64.57 RH522.1
  IN3 w0.124: v2(193.52,65.5) 195.79,67.77 205.67,67.77 206.59,68.68 206.59,70.06 206.88,70.35 208.71,70.35 209.03,70.02 209.03,69.36 210.06,68.33 211,68.33 212.7,66.62 212.7,64.29 213,64 213,62.97 213.97,61.99 219.55,61.99 220.66,60.89 223.48,60.89 223.8,60.57 225.57,60.57 225.67,60.67 230.73,60.67 231.07,61.01 233.45,61.01 233.57,60.88 233.58,60.88 234.15,60.31 235.67,60.31 237.96,62.6 264.22,62.6 268.59,58.22 268.59,52.15 269.41,51.33 269.41,47.91 268.5,47 268.5,37.48 269.69,36.29 269.69,35.29 271.68,33.3 272.39,33.3 273.54,32.16 274.01,32.16 274.6,31.57 275.8,31.57 276.16,31.93 276.56,31.93 277.68,33.05 280.13,33.05 281.92,34.84 281.92,35.08 282.3,35.46 283.69,35.46 284.2,34.95 285.28,34.95 286.3,35.97 289.85,35.97 290.3,35.52 290.81,35.52 291.69,34.64 293.85,34.64 294.11,34.89 297.54,34.89 298.32,34.1 298.32,33.7 v2(298.12,33.5)
  BOTTOM w0.076: 298.16,34.04 297.59,34.6 296.68,34.6 296.58,34.5 UH2.AT2
  BOTTOM w0.14: v2(298.12,33.5) 298.32,33.7 298.32,33.9 298.18,34.04 298.16,34.04
PCH_JTAG_TCK: length 156
  TOP w0.14: RH95.2 193.67,57.15 v2(193.67,55.88) ; v2(228.55,56.7) 228.86,56.7 229.08,56.47 230.44,56.47 231.43,57.46 v4(231.43,58.88) 231.43,65.75 v2(228.88,68.3)
  IN1 w0.097: v2(193.67,55.88) 194.83,57.04 206.44,57.04 206.96,56.53 219.53,56.53 219.79,56.78 228.36,56.78 228.45,56.7 v2(228.55,56.7)
  IN3 w0.124: v2(228.88,68.3) 231.1,66.08 236.08,66.08 236.48,65.68 265.96,65.68 272,59.64 272,53.16 272.49,52.67 272.49,46.47 272.82,46.15 272.82,43.84 273.52,43.14 273.52,41.95 273.12,41.54 273.12,41.15 274.74,39.53 275.12,39.53 276.32,38.33 278.75,38.33 279.29,37.79 279.29,37.69 279.69,37.29 281.91,37.29 282.31,37.69 288.64,37.69 289.43,36.9 290.99,36.9 291.83,36.06 295.99,36.06 296.39,35.66 297.23,35.66 v2(297.41,35.47)
  BOTTOM w0.076: UH2.AN3 296.13,36.2 296.46,35.86 297.07,35.86 297.4,35.53 297.4,35.49 v2(297.41,35.47)
  BOTTOM w0.14: v2(193.67,55.88) 196.16,58.37 196.16,59.41 197.37,60.63 JXDP1.55
PCH_JTAG_TDI: length 11
  TOP w0.14: v4(300.83,31.08) 301.16,31.08 v2(301.63,31.55) 301.63,31.83 301.22,32.24 RH100.2
  BOTTOM w0.076: UH2.AP2 296.44,35.63 297.12,34.95 298.03,34.95 298.11,34.88
  BOTTOM w0.14: RH537.2 301.73,31.03 301.73,31.45 v2(301.63,31.55) 301.61,31.55 301.42,31.74 299.92,31.74 299.42,32.25 299.42,33.19 298.91,33.7 298.91,34.08 298.11,34.88
PCH_JTAG_TDO: length 13
  TOP w0.14: v2(303.41,30.7) 302.73,30.7 v4(302.7,30.73) 302.11,31.32 RH97.2
  BOTTOM w0.076: 298.2,35.12 297.21,35.12 296.8,35.52 UH2.AP1
  BOTTOM w0.14: v2(303.41,30.7) 303.41,30.73 303.38,30.73 303.38,30.7 303.19,30.89 RH539.2 302.63,30.89 302.34,31.17 302.34,31.23 302.23,31.34 302.19,31.34 302.16,31.37 302.16,31.91 302.03,32.03 300.05,32.03 299.67,32.41 299.67,33.26 299.14,33.79 299.14,34.18 298.2,35.12
PCH_JTAG_TMS: length 9.5
  TOP w0.14: v4(298.91,33.96) v2(298.91,33.15) 299.19,32.87 RH98.2
  BOTTOM w0.076: UH2.AR2 296.61,34.79 297.68,34.79 297.98,34.48 298.11,34.48
  BOTTOM w0.14: 298.91,33.11 298.68,33.34 298.68,33.95 298.15,34.48 298.11,34.48 ; 298.91,33.11 v2(298.91,33.15) ; 298.91,33.11 298.91,33.04 298.91,32.13 299.54,31.5 300.57,31.5 RH538.2
PCH_JTAGX: length 261.1
  TOP w0.14: v2(135.81,96.62) 135.83,96.64 v1(136.48,96.64)
  IN2 w0.097: v2(217.4,59.85) 217.74,60.19 221.5,60.19 221.99,59.7 226.71,59.7 227.23,60.21 230.05,60.21 230.73,60.9 231.81,60.9 235.09,64.18 259.9,64.18 262.21,61.87 274.44,61.87 277.22,59.09 284.16,59.09 288.93,54.32 288.93,52.21 289.95,51.18 290.66,51.18 291.43,50.41 292.37,50.41 293,51.04 295.69,51.04 296.08,50.66 296.08,49.87 297.33,48.62 297.33,46.92 297.9,46.35 298.36,46.35 299.04,45.67 299.04,43.97 298.54,43.47 297.26,43.47 296.86,43.08 296.86,36.49 v2(295.87,35.5)
  IN3 w0.124: v2(217.4,59.85) 217.4,59.8 215.77,58.17 215.04,58.17 208.17,51.3 203.03,51.3 202.52,50.79 197.42,50.79 197.15,50.52 191.77,50.52 189.56,48.31 132.47,48.31 120.83,59.95 120.83,65.8 118.77,67.86 118.77,76.99 121.67,79.9 121.67,85.02 129.72,93.07 129.94,93.07 132.11,95.24 133.16,95.24 134.53,96.62 v2(135.81,96.62)
  BOTTOM w0.076: v2(295.87,35.5) 295.88,35.49 UH2.AR3
  BOTTOM w0.14: RH38.1 136.46,96.62 v2(135.81,96.62)
PCH_PCIE_WAKE#: length 12.8
  BOTTOM w0.076: 290.95,28.48 290.95,28.69 291.19,28.93 291.19,30.53 291.38,30.72 291.38,31.02 291.14,31.25 UH2.BC13
  BOTTOM w0.14: 290.95,28.48 290.95,28.01 290.56,27.63 290.56,26.81 290.4,26.65 v1(290.4,26.24) 290.13,25.97 289.73,25.97 289.32,25.57 289.32,25.03 RH17.1 290.01,24.35 290.01,22.6 290.27,22.33 291.31,22.33 RH114.1
PCH_PLTRST#: length 23
  TOP w0.14: CH208.1 284.56,31.16 v2(284.82,31.42) ; v2(282.91,18.69) 283.41,18.19 RH1.1 284.41,17.7 v1(284.91,17.7) UH7.1 286.47,17.28 286.65,17.1 286.98,17.1 287.12,17.24 UH7.2
  IN2 w0.097: v2(284.82,31.42) 284.82,30.14 285.62,29.34 285.62,25.53 284.77,24.68 283.13,24.68 282.21,23.75 282.21,20.43 282.91,19.73 282.91,18.69 v2(282.91,18.69)
  BOTTOM w0.076: v2(284.82,31.42) 284.42,31.82 UH2.BB27
PCH_PLTRST#_EC: length 559.5
  TOP w0.14: RT1.1 160.38,87.94 v2(160.38,87.75) ; v2(282.7,16.31) 283.67,17.27 RH1.2 284,17.27 284.89,16.39 v1(286.75,16.39) 287.99,16.39 288.33,16.73 v2(288.33,17.57) 288.33,18.51 287.77,19.06 UH7.4 290.37,19.6 290.97,20.2 v2(290.97,20.58)
  IN1 w0.097: v2(282.7,16.31) 277.5,16.31 276.15,17.66 271.57,17.66 267.33,21.91 263.08,21.91 256.75,28.23 250.79,28.23 249.93,29.1 243.58,29.1 241.96,30.72 225.52,30.72 225.18,31.06 206.28,31.06 205.68,30.47 204.41,30.47 203.62,31.26 172.26,31.26 171.66,31.86 142.57,31.86 142.32,32.11 118.23,32.11 117.78,32.57 108.97,32.57 108.67,32.86 106.86,32.86 106.43,33.29 v2(100.33,33.29) ; v2(290.97,20.58) 291.58,19.96 295.81,19.96 296.81,20.96 298.06,20.96 298.98,20.05 301.89,20.05 302.35,19.59 305.16,19.59 305.61,19.13 307.77,19.13 308.14,19.49 310.66,19.49 311.91,20.75 313.62,20.75 313.92,21.05 313.92,22.61 318.45,27.14 323.44,27.14 v2(324.46,28.16)
  IN2 w0.097: v2(100.33,33.29) 100.62,33.58 100.62,40.9 117.17,57.45 117.17,64.02 119.41,66.26 134.47,66.26 142.34,74.13 145.01,74.13 147.23,76.36 147.23,77.5 149.01,79.28 149.58,79.28 150.83,80.52 150.83,81.52 151.57,82.26 152.57,82.26 153.11,81.72 159.84,81.72 160.25,82.13 160.25,86.32 160.25,87.63 v2(160.38,87.75) ; v2(294.65,9.93) 294.04,9.32 289.42,9.32 288.33,10.42 v2(288.33,17.57)
  IN3 w0.124: v2(324.46,28.16) 323.06,28.16 322.76,28.46 322.76,38.52 324.21,39.97 v2(324.21,39.97)
  IN4 w0.137: v2(201.29,74.11) 200.76,73.57 200.36,73.57 199.98,73.19 197.69,73.19 197.07,72.57 197.07,71.19 197.71,70.55 197.71,65.95 197.07,65.32 197.07,63.38 v2(195.89,62.19)
  IN5 w0.097: v2(100.33,33.29) 99.3,34.32 86.49,34.32 82.03,29.86 70.03,29.86 67.18,32.71 38.49,32.71 37.82,33.38 36.54,33.38 35.79,34.13 35.79,35.45 35.05,36.19 35.05,38.59 34.11,39.53 34.11,42.67 33.8,42.99 33.8,46.43 33,47.23 29.62,47.23 28.45,46.07 28.45,43.87 v2(26.93,42.35) ; v2(160.38,87.75) 163.47,84.66 163.47,83.55 164.44,82.58 164.44,82.26 165.22,81.48 170.5,81.48 171.07,80.91 174.94,80.91 175.24,80.61 175.24,79.53 176.32,78.45 181.1,78.45 182.92,76.63 182.92,70.07 183.13,69.86 183.13,69.85 186.54,66.44 186.54,64.79 188.82,62.51 192.06,62.51 192.38,62.19 v2(195.89,62.19)
  BOTTOM w0.14: v2(26.93,42.35) UL1.19 ; v2(324.21,39.97) 324.21,40.1 323.97,40.35 323.97,42.62 323.57,43.02 323.57,44.76 325.29,46.47 336.2,46.47 336.62,46.05 JNGFF1.44 ; UG10.2 201.4,74.2 201.33,74.13 201.32,74.13 v2(201.29,74.11) ; JNGFF2.50 282.22,13.53 282.54,13.85 282.54,16.15 v2(282.7,16.31) ; RH77.1 286.86,17.87 287.28,17.45 288.21,17.45 v2(288.33,17.57) 288.6,17.57 288.93,17.23 UTPM1.17 ; RE145.2 295.82,9.38 295.21,9.38 v2(294.65,9.93)
PCH_PWROK: length 23.8
  TOP w0.14: UH14.4 308.72,28.48 v2(308.43,28.77) 308.43,28.92 RH94.1 306.97,30.38 v4(306.74,30.38)
  IN1 w0.097: v2(308.43,28.77) 307.65,29.56 307.65,30.34 305,32.98 300.69,32.98 299.16,34.51 295.89,34.51 294.95,33.58 292.75,33.58 v2(292.58,33.75)
  BOTTOM w0.076: v2(292.58,33.75) 292.58,33.6 UH2.AW11
PCH_RSMRST#: length 163.5
  TOP w0.14: RH541.1 202.1,56.35 202.67,55.78 v1(203,55.78) 204.44,55.78 v2(204.45,55.79) ; CH212.1 295.75,34.1 295.59,33.95 RH13.2 ; v2(298.55,24.16) 298.06,24.65 RH503.1 ; v2(295.73,32.62) 295.73,33.43 RH13.2 ; RH13.2 294.46,33.56 RH9.1 ; v2(300.85,11.38) 300.46,10.99 UE1.27
  IN1 w0.097: v2(204.45,55.79) 205.1,55.13 219.21,55.13 v2(219.62,55.53)
  IN2 w0.097: v2(300.85,11.38) 301.79,12.32 301.79,12.79 301.28,13.3 300.91,13.3 298.1,16.12 298.1,18.24 296.26,20.08 296.26,20.88 298.55,23.17 v2(298.55,24.16) 298.6,24.21 298.6,25.83 299.04,26.27 299.04,27.82 298.16,28.7 298.16,32.05 297.58,32.62 v2(295.73,32.62) 295.63,32.52 295.63,32.17 295.39,31.93 294.72,31.93 293.52,33.12 293.52,36.76 294.21,37.44 294.21,39.13 293.92,39.42 293.66,39.42 293.16,39.93 293.16,40.4 291.72,41.84 291.72,42.54 293.35,44.17 294.92,44.17 295.9,45.15 295.9,46.01 293.66,48.25 291.86,48.25 291.57,47.96 289.04,47.96 287.57,49.43 287.57,49.85 286.49,50.93 286.49,52.07 285.88,52.68 285.88,53.47 285.71,53.64 285.71,54.55 284.87,55.4 283.82,55.4 283.5,55.08 282.9,55.08 282.55,55.43 282.55,56.67 281.73,57.49 275.48,57.49 275.47,57.5 275.31,57.5 274.99,57.81 274.99,58.37 272.77,60.59 261.68,60.59 259.37,62.9 240.54,62.9 239.71,62.07 239.71,60.59 239.02,59.9 234.49,59.9 231.46,56.87 229.21,56.87 228.96,57.13 227.63,57.13 227.37,56.87 220.96,56.87 v2(219.62,55.53)
PCH_RSMRST#_R: length 11.1
  TOP w0.14: v2(296.01,24.67) RH503.2
  IN2 w0.097: v2(296.01,24.67) 296.01,25.82 293.71,28.13 293.71,29.27 293.45,29.53 293.44,29.53 293.21,29.76 293.21,29.77 293.14,29.84 293.14,32.06 293.03,32.17 293.03,32.18 292.74,32.48 v2(292.67,32.48)
  BOTTOM w0.089: v2(292.67,32.48) 292.66,32.49 292.21,32.49 292.06,32.34 UH2.BA11
PCH_RTCRST#: length 32
  TOP w0.14: v2(293.98,10.54) 293.97,10.56 293.36,10.56 292.79,9.99 QH6.1 ; RH84.2 CH53.1 292.01,27.9 v2(292.01,28.53) 291.72,28.53 v4(291.05,27.85)
  IN2 w0.097: v2(292.01,28.53) 292.41,28.53 295.12,25.81 295.12,25.31 295.36,25.07 v2(295.36,24.68) 295.36,23.98 295,23.61 295,19.76 295.59,19.17 295.59,16.14 294.37,14.92 294.37,11.24 293.98,10.84 v2(293.98,10.54)
  BOTTOM w0.076: v2(292.01,28.53) 292.01,29.34 292.25,29.58 292.25,30.62 292.19,30.68 292.19,31.17 UH2.BC10
  BOTTOM w0.14: CLRP1.1 294.91,22.93 294.91,23.47 295.36,23.93 v2(295.36,24.68)
PCH_RTCX1: length 7.6
  BOTTOM w0.076: UH2.BC9 292.67,31.27 292.67,30.65 292.58,30.55 292.58,29.42 292.52,29.37 292.52,29.06 293.1,28.48
  BOTTOM w0.14: YH1.1 293.53,25.59 CH45.1 293.53,27.29 RH70.1 293.55,28.03 293.1,28.48
PCH_RTCX2: length 6.5
  BOTTOM w0.076: UH2.BD10 292.41,30.79 292.41,29.51 292.33,29.43 292.33,28.95 292.56,28.72 292.56,28.48
  BOTTOM w0.14: 292.56,28.48 292.56,27.38 RH70.2 292.67,27.28 CH46.1 292.67,25.65 YH1.2
PCH_SATA_LED#: length 66.5
  TOP w0.254: QE21.2 225.26,56.05 224.91,55.69 224.91,55.21 225.21,54.9 225.67,54.9 v1(225.87,55.1) 226.34,55.1 226.62,54.82 226.95,54.82 RH502.1 226.96,55.2 v2(227.19,55.43)
  IN1 w0.254: v2(241.59,45.49) 241.59,46.11 232.87,54.84 229.58,54.84 229.01,55.41 227.2,55.41 v2(227.19,55.43)
  IN4 w0.254: v2(272.17,39.86) 271.67,39.36 266.96,39.36 264.03,36.43 260.56,36.43 260.49,36.5 256.05,36.5 253.86,38.69 250.88,38.69 249.21,40.35 248.2,40.35 246.04,42.51 246.04,46.15 245.4,46.79 242.89,46.79 v2(241.59,45.49)
  BOTTOM w0.076: UH2.AD44 275.39,40.62 274.55,39.78 274.23,39.78
  BOTTOM w0.254: 274.23,39.78 273.75,39.78 273.18,39.21 RH80.1 272.76,39.21 272.17,39.8 v2(272.17,39.86)
PCH_SMBCLK: length 277.3
  TOP w0.14: v2(272.4,26.14) 272,26.14 271.72,26.42 271.72,28.63 271.31,29.04 QH4.1 269.94,28.52 269.94,27.38 269.54,26.99 v2(268.87,26.99) ; v2(313.74,32.59) 313.22,33.11 312.63,33.11 311.44,34.3 311.44,35.78 314.25,38.59 317.09,38.59 317.76,37.91 UVGA1.30 ; v2(264.63,12.63) 263.41,12.63 263.03,12.26 263.03,9.05 263.41,8.66 265.39,8.66 265.67,8.39 U5603.1
  IN1 w0.097: v2(245.63,39.19) 245.19,38.75 245.07,38.75 244.74,38.42 244.74,36.1 244.1,35.46 239.5,35.46 238.16,34.13 238.16,32.48 238.05,32.36 174.08,32.36 173.55,32.89 173.55,35.7 172.78,36.48 172.08,36.48 v2(172.06,36.46)
  IN2 w0.097: v2(272.4,26.14) 272.4,24.95 273.48,23.87 273.48,13.67 272.63,12.82 270.28,12.82 269.48,13.62 265.61,13.62 v2(264.63,12.63)
  IN3 w0.124: v2(172.06,36.46) 172.17,36.46 173.65,37.94 v2(173.65,42)
  IN4 w0.137: v2(313.74,32.59) 311.97,30.82 308.82,30.82 308.52,31.12 307.77,31.12 307.51,30.86 307.51,30.18 304.06,26.73 299.91,26.73 298.91,27.73 298.38,27.73 298.16,27.73 297.63,28.26 297.14,28.26 297.13,28.25 297.09,28.25 296.99,28.14 294.43,28.14 292.87,26.58 290.59,26.58 290.08,26.08 289.87,26.08 285.74,26.08 284.83,26.99 283.8,26.99 281.55,24.75 280.17,24.75 279.59,24.17 274.37,24.17 v2(272.4,26.14) 270.79,26.14 269.94,26.99 v2(268.87,26.99) 268.69,26.8 265.67,26.8 265.27,27.2 262.88,27.2 260.79,29.29 260.79,30.42 260.94,30.57 261.34,30.97 261.34,32.45 259.55,34.24 250.49,34.24 248.96,35.78 245,35.78 244.7,36.07 244.7,38.54 244.7,38.76 244.93,38.99 245.43,38.99 v2(245.63,39.19)
  BOTTOM w0.14: v2(245.63,39.19) 245.54,39.09 244.87,39.09 244.48,39.48 244.48,40.99 244.33,41.14 JDIMM2.253 ; v2(172.06,36.46) 171.97,36.36 171.22,36.36 168.75,38.84 168.75,41.21 167.83,42.13 JDIMM1.253 ; JXDP1.53 197.87,60.59 196.8,59.53 196.8,58.03 195.19,56.42 195.19,53.14 189.72,47.67 179,47.67 176.18,44.84 176.18,42.87 175.51,42.2 174.87,42.2 174.71,42.36 174.36,42.36 174,42 v2(173.65,42)
PCH_SMBDATA: length 277.5
  TOP w0.14: v2(313.06,32.66) 312.71,32.66 311.18,34.19 311.18,35.67 311.18,35.89 314.14,38.85 317.2,38.85 317.74,38.31 UVGA1.29 ; QH4.4 268.35,30.34 268.1,30.09 RH26.2 267.37,29.75 266.85,29.23 266.65,29.23 265.79,28.36 v2(265.79,27.29) 265.26,26.76 v1(264.69,26.76) 263.31,26.76 258.78,22.23 258.78,16.32 259.13,15.97 260.16,15.97 262.74,13.39 262.74,6.87 263.11,6.51 265.48,6.51 U5603.4
  IN1 w0.097: v2(245.68,38.52) 245.68,38.53 245.16,38.53 244.96,38.33 244.96,36.19 244.96,36 244.19,35.24 239.59,35.24 238.42,34.07 238.42,32.41 238.15,32.14 173.98,32.14 173.33,32.79 173.33,33.1 173.23,33.2 171.7,33.2 171.6,33.3 171.6,33.57 171.7,33.67 173.23,33.67 173.33,33.76 173.33,34.02 173.23,34.12 171.73,34.12 171.63,34.21 171.63,34.51 171.73,34.61 173.16,34.61 173.29,34.74 173.29,34.98 173.18,35.09 171.83,35.09 171.67,35.25 171.67,35.5 171.81,35.64 172.49,35.64 172.61,35.76 v2(172.61,36.08)
  IN3 w0.124: v2(174.54,41.94) 174.54,38.19 172.63,36.29 172.63,36.1 v2(172.61,36.08)
  IN4 w0.137: v2(313.06,32.66) 311.49,31.09 308.93,31.09 308.63,31.39 307.88,31.39 307.88,31.39 307.66,31.39 307.24,30.97 307.24,30.29 303.95,27 300.02,27 299.02,27.99 298.27,27.99 297.74,28.52 296.99,28.52 296.88,28.41 294.32,28.41 292.76,26.85 290.48,26.85 289.98,26.35 285.85,26.35 284.94,27.26 283.69,27.26 281.44,25.01 280.06,25.01 279.52,24.48 275.25,24.48 272.45,27.27 271.57,27.27 271.37,27.08 270.8,27.08 269.03,28.86 268.74,28.86 267.17,27.29 v2(265.79,27.29) 265.61,27.47 262.99,27.47 261.05,29.4 261.05,30.31 261.61,30.87 261.61,32.59 259.68,34.51 250.6,34.51 249.07,36.04 245.11,36.04 244.97,36.18 244.97,38.59 245.11,38.73 245.48,38.73 v2(245.68,38.52)
  BOTTOM w0.14: v2(245.68,38.52) 244.97,38.52 244.68,38.23 244.68,35.75 244.58,35.65 JDIMM2.254 ; JDIMM1.254 168.08,35.6 168.25,35.77 168.54,35.77 168.86,36.1 171.68,36.1 171.74,36.03 172.57,36.03 v2(172.61,36.08) ; JXDP1.51 198.37,60.58 198.02,60.23 197.94,60.23 197.08,59.37 197.08,57.93 195.45,56.31 195.45,53.03 189.83,47.4 179.11,47.4 176.57,44.86 176.57,42.89 175.62,41.94 v2(174.54,41.94)
PCH_SPI1_CLK_R: length 2.6
  BOTTOM w0.14: UTPM1.19 289.93,17.59 v1(289.64,17.88) RTPM5.2
PCH_SPI_CLK: length 8.4
  BOTTOM w0.076: 281.81,30.25 281.9,30.25 282.28,30.63 282.28,31.11 UH2.BC31
  BOTTOM w0.14: 281.81,30.25 281.33,29.78 281.33,28.39 282.07,27.65 282.07,27.28 283.82,25.53 v1(283.82,25.45) 283.82,25.12 283.6,24.91 RH582.2
PCH_SPI_CLK_R: length 23.2
  BOTTOM w0.14: RE126.2 303.44,36.57 303.44,38.51 301.13,40.82 300.83,40.82 300.48,41.17 300.48,42.65 299.51,43.62 299.51,45.37 299.38,45.49 298.76,45.49 298.58,45.32 v2(298.58,44.22) 298.58,43.56 299.92,42.23 299.92,41.27 302.17,39.02 302.17,37.15 302.34,36.99 302.6,36.99 302.74,37.12 UH8.6
PCH_SPI_CLK_R1: length 90.6
  IN5 w0.097: v2(285.05,23.68) 285.23,23.85 287.62,23.85 288.8,22.67 298.09,22.67 302.32,18.44 302.32,16.96 304.8,14.48 316.2,14.48 v2(316.52,14.16)
  BOTTOM w0.14: RTPM5.1 288.25,20.18 288.25,21.02 288.1,21.17 287.81,21.17 287.69,21.29 287.69,22.27 287.56,22.41 287.26,22.41 287.12,22.27 287.12,21.29 287.01,21.17 286.72,21.17 286.61,21.28 286.61,22.29 286.47,22.43 286.19,22.43 286.05,22.29 286.05,20.53 285.93,20.41 285.65,20.41 285.57,20.49 285.57,21.26 285.47,21.36 285.16,21.36 285.04,21.25 285.04,20.37 284.94,20.27 284.61,20.27 284.5,20.38 284.5,20.84 284.36,20.98 284.08,20.98 283.94,20.84 283.94,20.42 283.8,20.28 283.45,20.28 283.31,20.42 283.31,21.27 283.45,21.41 284.49,21.41 284.71,21.63 284.71,22.18 285.01,22.48 285.01,22.62 284.8,22.83 284.63,22.83 284.27,22.47 283.92,22.47 CH215.1 283.6,22.78 RH582.1 284.1,24.15 284.34,24.15 284.42,24.22 284.42,24.86 284.57,25.01 284.82,25.01 284.95,24.88 284.95,24.22 285.01,24.16 285.37,24.16 285.61,24.4 285.78,24.4 285.92,24.26 285.92,24.04 285.55,23.68 v2(285.05,23.68) ; v2(316.52,14.16) 316.11,14.16 315.03,15.24 315.03,17.64 313.63,19.03 313.63,20.29 313.08,20.84 313.08,22.5 313.49,22.9 313.49,25.28 312.66,26.1 312.66,26.96 312.12,27.51 310.35,27.51 v1(304.48,33.38) 304.01,33.85 304.01,35.08 RE126.1
PCH_SPI_CS2#: length 26.6
  TOP w0.14: v2(282.41,34.34) v1(283.03,34.34)
  IN2 w0.097: v2(282.41,34.34) 283.41,33.34 283.41,32.53 282.74,31.85 282.74,29.11 283.07,28.78 283.07,27.31 280.24,24.48 v2(280.24,23.14)
  IN5 w0.097: v2(290.35,20.55) 289.88,21.02 288.59,21.02 288.56,20.98 282.41,20.98 v2(280.24,23.14)
  BOTTOM w0.076: v2(282.41,34.34) 282.08,34.68 UH2.AT31
  BOTTOM w0.14: v2(290.35,20.55) 290.62,20.28 RTPM6.1
PCH_SPI_CS2#_R: length 9.1
  IN1 w0.097: v2(290.06,18.14) 290.03,18.14 288.47,16.58 286.16,16.58 v2(285.79,16.94)
  BOTTOM w0.14: RTPM8.1 RTPM6.2 290.62,18.7 v2(290.06,18.14) 290.06,18 290.43,17.63 UTPM1.20 ; v2(285.79,16.94) RTPM13.1
PCH_SPI_CS#: length 84.4
  TOP w0.14: v1(299.16,40.98) 299.33,40.81 RH74.2 RH101.1 300.88,41.86 v2(300.9,41.84)
  IN5 w0.097: v2(280.01,29.87) 279.57,30.32 279.57,30.61 279.74,30.78 279.88,30.78 280.24,30.43 280.37,30.43 280.51,30.56 280.51,30.7 280.15,31.06 280.15,31.19 280.28,31.32 280.41,31.32 281.82,29.91 281.96,29.91 282.09,30.05 282.09,30.25 280.72,31.63 280.72,31.76 280.86,31.9 280.99,31.9 283.06,29.83 283.2,29.83 283.34,29.96 283.34,30.1 281.26,32.17 281.26,32.31 281.4,32.44 281.54,32.44 284.31,29.67 284.45,29.67 284.65,29.87 284.65,30.01 284.21,30.45 284.21,30.58 284.42,30.79 284.42,30.93 284.28,31.06 284.14,31.06 283.94,30.86 283.8,30.86 283.66,30.99 283.66,31.13 283.87,31.34 283.87,31.47 283.74,31.61 283.6,31.61 283.39,31.4 283.25,31.4 281.87,32.78 281.87,32.92 282.06,33.1 282.93,33.1 283.02,33 283.02,32.54 283.12,32.44 283.31,32.44 283.41,32.54 283.41,33 283.5,33.1 283.7,33.1 283.79,33 283.79,32.54 283.89,32.44 284.08,32.44 284.18,32.54 284.18,33 284.28,33.1 284.91,33.1 285.5,33.69 286.55,33.69 287.31,32.92 290.93,32.92 293.47,30.38 295.5,30.38 295.7,30.57 295.7,31.14 293.66,33.18 292.18,33.18 292.05,33.3 292.05,34.17 292.81,34.92 292.94,34.92 293.82,34.04 293.96,34.04 294.1,34.18 294.1,34.32 293.15,35.26 293.15,35.4 293.53,35.77 293.53,36 294.8,37.27 294.81,37.27 295.03,37.49 295.03,37.5 295.9,38.37 298.68,38.37 299.76,39.45 299.76,40.04 299.86,40.14 301.44,40.14 301.54,40.24 301.54,40.43 301.44,40.53 299.86,40.53 299.76,40.62 299.76,40.82 299.86,40.91 300.5,40.91 300.6,41.01 300.6,41.2 300.5,41.3 299.86,41.3 299.76,41.39 299.76,42.57 299.25,43.08 299.25,44.29 299.57,44.61 300.71,44.61 300.9,44.41 300.9,43.4 301.41,42.89 302.55,42.89 302.8,42.64 302.8,41.94 302.71,41.84 v2(300.9,41.84)
  BOTTOM w0.076: v2(280.01,29.87) 280.2,29.87 280.85,30.52 281.19,30.52 281.36,30.69 281.9,30.69 UH2.BD31
PCH_SPI_CS#_R: length 2.4
  TOP w0.14: RH101.2 300.36,42.93 v2(300.36,43.75)
  BOTTOM w0.14: v2(300.36,43.75) 300.2,43.91 UH8.1
PCH_SPI_HOLD#: length 83.8
  IN3 w0.124: v2(303.32,34.51) 302.99,34.19 302.99,34.01 303.2,33.8 303.38,33.8 303.96,34.39 304.14,34.39 304.31,34.21 304.31,34.03 303.73,33.45 303.73,33.28 303.91,33.1 304.08,33.1 305.27,34.29 305.45,34.29 305.63,34.11 305.63,33.93 304.59,32.9 304.59,32.72 304.77,32.55 304.94,32.55 305.98,33.58 306.15,33.58 306.49,33.24 306.49,32.1 307.13,31.46 307.13,31.21 307,31.09 306.17,31.09 306.05,30.96 306.05,30.71 306.17,30.59 307,30.59 307.13,30.46 307.13,29.87 307.1,29.84 305.63,29.84 305.54,29.94 305.54,31.33 304.27,32.6 303.7,32.6 302.55,33.76 302.37,33.76 302.19,33.58 302.19,33.4 303.09,32.5 303.09,32.33 302.92,32.15 302.74,32.15 301.84,33.05 301.67,33.05 301.49,32.88 301.49,32.7 301.87,32.32 301.87,32.14 301.69,31.97 301.52,31.97 301.14,32.35 300.96,32.35 300.69,32.08 300.69,31.89 302.38,30.2 302.38,30.03 302.21,29.86 301.93,29.86 300.3,31.49 300.1,31.49 299.93,31.31 299.93,31.09 300.79,30.23 300.79,30.06 300.61,29.88 300.37,29.88 299.52,30.73 299.35,30.73 299.22,30.61 299.22,30.43 299.65,30.01 299.65,29.83 299.47,29.66 299.29,29.66 298.87,30.08 298.7,30.08 298.69,30.07 298.14,30.07 297.42,29.35 297.24,29.35 297.11,29.23 297.11,28.35 296.99,28.22 296.74,28.22 296.61,28.35 296.61,29.23 296.49,29.35 296.24,29.35 296.12,29.23 296.12,28.35 295.99,28.22 295.74,28.22 295.62,28.35 295.62,29.23 295.49,29.35 295.24,29.35 295.12,29.23 295.12,27.58 295.02,27.48 294.75,27.48 294.62,27.61 294.62,29.23 294.5,29.35 294.25,29.35 294.11,29.49 294.11,30.25 293.68,30.69 291.4,30.69 291.28,30.56 291.28,29.95 291.15,29.83 290.91,29.83 290.78,29.95 290.78,30.56 290.66,30.69 290.41,30.69 290.28,30.56 290.28,30.18 290.16,30.06 289.91,30.06 289.79,30.18 289.79,30.56 289.66,30.69 289.16,30.69 289.03,30.56 289.03,29.03 288.91,28.9 288.66,28.9 288.54,29.03 288.54,30.56 288.41,30.69 287.71,30.69 287.59,30.56 287.59,29.87 287.46,29.75 287.21,29.75 287.09,29.87 287.09,30.56 286.97,30.69 286.72,30.69 286.59,30.56 286.59,29.87 286.47,29.75 286.22,29.75 286.09,29.87 286.09,30.56 285.97,30.69 285.32,30.69 285.19,30.56 285.19,30.03 285.07,29.91 284.82,29.91 284.7,30.03 284.7,30.56 284.57,30.69 284.26,30.69 284.14,30.56 284.14,29.87 283.72,29.46 283.72,28.95 282.63,27.86 v2(282.63,27.44)
  BOTTOM w0.076: 281.67,29.57 282.42,30.32 282.42,30.52 282.67,30.76 UH2.BD30
  BOTTOM w0.14: v2(282.63,27.44) 282.63,27.59 v1(281.9,28.33) 281.67,28.55 281.67,29.57 ; RE71.1 302.83,34.99 v2(303.32,34.51)
PCH_SPI_HOLD#_R: length 2.3
  BOTTOM w0.14: RE71.2 302.59,36.46 302.59,36.48 302.39,36.68 302.27,36.68 302.09,36.86 301.89,36.86 301.47,37.28 UH8.7
PCH_SPI_MISO: length 3
  BOTTOM w0.14: RTPM2.2 v1(293.47,17.85) 293.47,16.99 293.22,16.74 UTPM1.24
PCH_SPI_MOSI: length 2.3
  BOTTOM w0.14: UTPM1.21 290.93,17.59 v1(291.22,17.88) 291.57,18.23 RTPM4.2
PCH_SPI_SI: length 186.4
  TOP w0.14: RH525.1 v2(197.33,55.89)
  IN1 w0.097: v2(197.33,55.89) 199.45,53.76 228.17,53.76 229.1,52.83 231.2,52.83 239.71,44.33 239.71,44.31 240.99,43.02 242.04,43.02 244.95,40.12 v2(244.95,39.68)
  IN3 w0.124: v2(304.66,34.6) 304.66,34.69 304.4,34.95 303.02,34.95 299.65,31.58 298.81,31.58 298.27,31.04 297.28,31.04 297.06,30.83 296.45,30.83 296.14,31.14 296.14,31.97 296.01,32.1 295.76,32.1 295.64,31.97 295.64,31.38 295.52,31.26 294.73,31.26 294.41,30.94 294.05,30.94 293.93,31.06 293.93,31.27 293.81,31.4 293.56,31.4 293.43,31.27 293.43,31.06 293.31,30.94 293.06,30.94 292.93,31.06 292.93,31.27 292.81,31.4 292.56,31.4 292.44,31.27 292.44,31.06 292.31,30.94 291.43,30.94 291.24,31.13 291.24,31.65 291.11,31.78 290.86,31.78 290.74,31.65 290.74,31.13 290.62,31 289.53,31 289.53,31 289.2,31 289.2,31 283.14,31 282.95,30.81 282.95,30.26 282.82,30.14 282.5,30.14 282.38,30.26 282.38,30.81 282.25,30.94 281.95,30.94 281.82,30.81 281.82,30.26 281.7,30.14 281.45,30.14 281.33,30.26 281.33,30.81 281.2,30.94 280.95,30.94 280.83,30.81 280.83,30.58 280.7,30.46 280.52,30.46 280.39,30.58 280.39,31.84 280.27,31.97 280,31.97 279.88,31.84 279.88,30.5 279.75,30.38 279.5,30.38 279.38,30.5 279.38,31.84 279.25,31.97 278.98,31.97 278.86,31.84 278.86,30.26 278.73,30.13 278.48,30.13 278.36,30.25 278.36,31.84 278.23,31.97 278.05,31.97 277.85,31.77 277.85,29.62 278.23,29.24 280.96,29.24 281.08,29.11 281.08,28.28 281.21,28.16 281.46,28.16 281.58,28.28 281.58,29.11 281.71,29.24 281.88,29.24 v2(282.1,29.02)
  IN4 w0.137: v2(244.95,39.68) 244.95,39.67 244.99,39.67 244.99,39.66 245,39.66 245,39.65 246.03,39.65 246.23,39.46 246.23,38.06 246.42,37.87 247.69,37.87 248.26,38.45 248.83,38.45 250.36,36.92 250.36,35.67 250.83,35.2 259.95,35.2 261.85,33.3 261.85,33.26 262.61,32.49 262.61,28.79 263.29,28.11 267.08,28.11 268.48,29.5 270.54,29.5 272.07,27.97 273.6,27.97 276.44,25.12 279.25,25.12 279.79,25.66 281.18,25.66 281.98,26.46 281.98,28.91 v2(282.1,29.02)
  IN5 w0.097: v2(282.1,29.02) 281.94,28.87 281.94,28.25 281.84,28.16 281.44,28.16 281.34,28.06 281.34,27.87 281.44,27.77 281.84,27.77 281.94,27.67 281.94,26.87 281.84,26.77 281.57,26.77 281.47,26.67 281.47,26.48 281.57,26.38 281.84,26.38 281.94,26.29 281.94,26.09 281.84,26 281.57,26 281.47,25.9 281.47,25.71 281.57,25.61 281.84,25.61 281.94,25.51 281.94,25.32 281.84,25.23 281.57,25.23 281.47,25.13 281.47,24.94 281.57,24.84 281.84,24.84 281.94,24.74 281.94,24.55 281.84,24.45 281.57,24.45 281.47,24.36 281.47,24.16 281.57,24.07 281.84,24.07 281.94,23.97 281.94,23.75 281.84,23.65 281.57,23.65 281.47,23.55 281.47,23.36 281.57,23.26 281.84,23.26 281.94,23.17 281.94,22.67 282.55,22.07 282.74,22.07 283.6,21.2 288.47,21.2 288.51,21.24 291.47,21.24 291.57,21.15 v2(291.57,20.56)
  BOTTOM w0.076: UH2.BB29 283.2,31.66 282.9,31.35 282.9,30.29 282.69,30.08 282.69,29.36 282.35,29.02 v2(282.1,29.02)
  BOTTOM w0.14: v2(304.66,34.6) 304.69,34.62 RE128.1 ; v2(291.57,20.56) RTPM4.1
