# Allegro board Dell_Inspiron_15_7577_Compal_CKA50_CKF50_LA_E992P_Rev_1_0_BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
ESPI_CS#: length 63.4
  TOP w0.14: v2(313.22,5.62) 312.5,5.62 312.2,5.32 311.3,5.32 310.7,5.91 310.7,6.33 310.8,6.43 UE1.58 ; v1(289.89,26.55) 289.89,27.87 v2(289.31,28.45)
  IN2 w0.097: v2(289.31,28.45) 288.77,27.92 288.77,22.7 287.71,21.63 287.71,19.65 287.31,19.26 287.31,13.48 286.8,12.97 286.8,11.27 289.7,8.37 293.78,8.37 294.95,9.55 295.82,9.55 296.6,10.33 296.6,10.66 296.89,10.95 297.27,10.95 v2(297.69,10.53)
  BOTTOM w0.076: 289.28,28.48 289.23,28.53 289.23,28.74 289.14,28.83 289.14,30.07 UH2.BE16
  BOTTOM w0.14: v2(313.22,5.62) 311.85,4.24 302.19,4.24 301.32,5.11 297.47,5.11 296.76,5.82 JESPI1.7 296.76,7.51 297.92,8.66 297.92,10.3 v2(297.69,10.53) ; 289.28,28.48 v2(289.31,28.45)
ESPI_IO0: length 49.8
  TOP w0.14: RH574.2 286.49,25.67 286.49,24.29 287.18,23.59 v2(287.18,22.84) 287.2,22.84 287.86,22.18 v1(287.86,21.44) ; v2(311.2,6.12) UE1.59
  IN2 w0.097: v2(287.18,22.84) 286.45,22.11 286.45,18.49 286.64,18.29 286.64,13.76 286.13,13.25 286.13,10.99 289.44,7.68 293.1,7.68 293.45,7.33 296.26,7.33 297.84,8.91 298.6,8.91 298.93,8.58 v2(298.93,8.03)
  BOTTOM w0.14: v2(298.93,8.03) 298.76,7.85 JESPI1.3 298.76,6.41 299,6.18 301.77,6.18 302.63,5.31 310.39,5.31 v2(311.2,6.12)
ESPI_IO1: length 50.1
  TOP w0.14: v2(311.69,5.8) 311.62,5.86 311.62,6.24 311.6,6.27 UE1.60 ; v1(286.61,22) 286.6,22.01 v2(286.6,22.84) 286.6,23.55 285.56,24.59 285.56,25.63 RH575.2
  IN2 w0.097: v2(298.43,8.47) 297.72,8.47 296.35,7.1 293.36,7.1 293,7.46 289.29,7.46 285.91,10.84 285.91,13.34 286.42,13.85 286.42,18.2 286.23,18.39 286.23,22.47 v2(286.6,22.84)
  BOTTOM w0.14: v2(298.43,8.47) 298.36,8.41 298.36,7.71 298.26,7.61 JESPI1.4 298.26,6.27 298.62,5.91 301.66,5.91 302.52,5.04 310.93,5.04 v2(311.69,5.8)
ESPI_IO2: length 50.4
  TOP w0.14: v2(312.25,5.96) 312.25,6 312,6.25 UE1.61 ; v2(286.02,22.85) 286.02,23.52 v1(285.5,24.04) 285.13,24.41 285.13,24.73 284.53,25.33 284.53,25.83 284.91,26.22 RH576.2
  IN2 w0.097: v2(286.02,22.85) 286.01,22.85 286.01,17.83 285.28,17.11 285.28,14.13 285.68,13.72 285.68,10.75 289.2,7.23 292.91,7.23 293.28,6.87 296.82,6.87 v2(297.92,7.97)
  BOTTOM w0.14: v2(297.92,7.97) 297.9,7.97 297.76,7.83 JESPI1.5 297.76,6.18 298.3,5.64 301.54,5.64 302.41,4.78 311.3,4.78 312.25,5.72 v2(312.25,5.96)
ESPI_IO3: length 70.1
  TOP w0.14: RH577.2 288.84,25.31 288.2,24.68 v1(288.2,23.29) 288.2,23.25 v2(287.79,22.84) ; UE1.62 312.4,6.56 312.71,6.25 312.71,6.16 v2(312.83,6.05)
  IN2 w0.097: v2(287.79,22.84) 287.79,22.84 287.26,22.3 287.26,19.84 286.87,19.44 286.87,13.67 286.36,13.16 286.36,11.08 289.53,7.91 293.19,7.91 293.48,7.61 296.23,7.61 297.75,9.13 298.8,9.13 299.34,8.59 299.34,7.35 298.93,6.95 298.93,4.35 299.06,4.22 311.25,4.22 312.83,5.79 v2(312.83,6.05)
  BOTTOM w0.14: JESPI1.6 297.26,6.03 297.92,5.37 301.43,5.37 302.3,4.51 311.48,4.51 312.83,5.86 v2(312.83,6.05)
ESPI_RESET#: length 51.6
  TOP w0.14: UE1.53 308.8,8.85 v2(308.71,8.94) ; v2(287.83,27.89) 287.52,27.89 v1(287.31,28.1)
  IN1 w0.097: v2(308.71,8.94) 307.9,8.12 303.78,8.12 303.19,8.72 303.19,9.43 302.93,9.68 297.92,9.68 v2(297.09,10.51)
  IN2 w0.097: v2(287.83,27.89) 288.48,27.24 288.48,22.72 287.48,21.72 287.48,19.74 287.09,19.35 287.09,13.58 286.58,13.06 286.58,11.18 289.61,8.14 292.52,8.14 292.53,8.15 293.9,8.15 294.93,9.18 295.76,9.18 v2(297.09,10.51)
  BOTTOM w0.076: UH2.BC18 288.58,31.27 288.58,30.87 288.48,30.77 288.48,29.63 287.71,28.86 287.43,28.86 287.26,28.69 287.26,28.48
  BOTTOM w0.14: RE144.2 297.22,10.38 v2(297.09,10.51) ; v2(287.83,27.89) 287.52,27.89 287.26,28.15 287.26,28.48
FAN1_PWM: length 290.6
  TOP w0.14: UE1.47 306.4,8.3 306.24,8.46 v2(306.24,8.97)
  IN1 w0.097: v2(306.24,8.97) 305.51,8.97 304.86,9.62 304.67,9.62 304.03,10.26 299.05,10.26 298.36,10.95 296.9,10.95 296.56,10.61 296.56,10.1 295.79,9.33 278.98,9.33 277.14,11.17 272.16,11.17 268.8,14.53 264.69,14.53 256.09,23.13 252.95,23.13 251.95,24.13 239.21,24.13 237.24,26.1 136.54,26.1 135.68,25.24 134.98,25.24 132.41,27.8 122.33,27.8 121.73,27.2 107.03,27.2 105.69,28.54 104.37,28.54 103.73,27.9 90.98,27.9 88.9,25.82 v2(81.13,25.82)
  IN4 w0.137: v2(81.13,25.82) 82.16,25.82 83.18,26.84 83.18,32.4 82.51,33.08 82.51,37.34 82.42,37.42 82.42,40.88 83.1,41.56 83.1,46.13 82.27,46.95 82.27,63.08 83.54,64.35 88.56,64.35 v2(89.62,65.42)
  BOTTOM w0.127: v2(89.62,65.42) 89.64,65.42 v1(90.23,64.82)
  BOTTOM w0.14: v2(89.62,65.42) RE121.2 87.99,64.4 Q12.3
FAN1_PWM_OUT: length 21.9
  TOP w0.14: v4(99.12,59.05) 99.12,61.52 98.2,62.45 JFAN1.3 95.99,62.45 95.86,62.32 88.05,62.32 87.42,62.96 86.07,62.96 v2(84.79,61.67)
  BOTTOM w0.14: Q12.1 85.04,62.65 RE100.2 85.05,61.94 v2(84.79,61.67)
FAN1_TACH: length 248.9
  TOP w0.14: RE81.2 CE99.1 102.34,61.55 102.1,61.31 DE7.2 101.45,61.31 v1(101.45,57.33) 101.45,41.24 100.05,39.84 100.05,35.6 102.19,33.46 102.19,30.46 104.94,27.7 v2(104.94,27.33) ; v2(303.18,5.77) 303.6,6.2 UE1.40
  IN1 w0.097: v2(303.18,5.77) 301.98,6.97 295.23,6.97 294.41,7.79 286.58,7.79 285.97,8.4 278.62,8.4 276.87,10.15 271.91,10.15 268.52,13.54 264.53,13.54 255.73,22.34 239.61,22.34 236.65,25.31 137.01,25.31 135.93,24.22 134.72,24.22 131.93,27.01 122.66,27.01 122.06,26.41 105.87,26.41 v2(104.94,27.33)
FAN1_TACH_D: length 6
  TOP w0.14: v4(100.65,60.05) 100.05,60.65 DE7.1 100.1,61.36 RE82.2 98.85,63.7 JFAN1.2
FAN2_PWM: length 53.5
  TOP w0.14: v2(307.28,45.53) 307.28,46.22 306.95,46.56 Q13.3 305.7,46.56 305.09,47.17 304.18,47.17 RE122.2 304.14,46.7 304.69,46.15 v1(304.69,44.87) ; UE1.34 301.2,8.28 300.98,8.5 299.9,8.5 v2(299.78,8.38)
  IN2 w0.097: v2(299.78,8.38) 300.63,8.38 301.37,9.12 301.37,9.72 303.09,11.44 303.09,20.16 303.78,20.85 304.63,20.85 305.04,21.25 305.04,22.65 304.59,23.1 304.59,25.53 306.18,27.12 306.18,28.34 304.02,30.5 304.02,31.02 304.21,31.21 304.71,31.21 304.95,31.45 304.95,31.45 306.93,33.43 306.93,38.46 306.18,39.21 306.18,44.42 v2(307.28,45.53)
FAN2_PWM_OUT: length 14
  TOP w0.14: JFAN2.3 314.58,50.55 314.75,50.38 314.75,47.72 314.22,47.2 RE101.2 309.59,47.53 Q13.1 308.17,45.53 v4(307.4,44.77)
FAN2_TACH: length 116.6
  TOP w0.14: UE1.41 304,5.82 v2(304.01,5.81) ; v2(310.23,51.16) 309.77,51.62 DE9.2 CE100.1 v4(308.59,53.32)
  IN1 w0.097: v2(304.01,5.81) 303.57,5.37 303.01,5.37 301.61,6.77 295.15,6.77 294.33,7.59 286.5,7.59 285.89,8.2 278.51,8.2 276.97,9.74 272.01,9.74 268.44,13.31 264.48,13.31 256.48,21.31 v2(255.16,21.31)
  IN2 w0.097: v2(304.01,5.81) 304.01,5.93 304.01,5.93 304.01,6.12 305.27,7.38 305.27,9.43 305,9.69 305,13.64 304.12,14.53 304.12,18.99 306.28,21.15 306.28,26.34 306.63,26.69 306.63,28.96 307.52,29.85 307.52,38.71 306.77,39.46 306.77,44.17 307.25,44.65 307.54,44.65 310.23,47.34 v2(310.23,51.16)
  BOTTOM w0.14: v2(255.16,21.31) 255.96,21.31 256.78,22.14 256.78,25.68 RE83.2
FAN2_TACH_D: length 5.9
  TOP w0.14: JFAN2.2 311.97,49.3 RE84.2 310.79,51.48 310.93,51.62 DE9.1 310.96,52.21 310.86,52.31 v4(310.86,53.15)
FB_1.0VS_VGAP: length 2.2
  BOTTOM w0.14: v1(114.03,90.99) 114.03,92.17 114.49,92.62 PR10V2.1
FB_1.2V: length 5.3
  TOP w0.14: PR208.1 113.66,62.62 v1(113.12,62.08)
  TOP w0.203: PU200.6 113.02,66.38 113.02,66.38 113.45,66.38 113.79,66.04
  TOP w0.254: 113.79,66.04 113.79,64.29 PR205.1 113.66,64.11 PR208.1
FB_1.8V: length 5.5
  BOTTOM w0.14: 267.44,79.54 267.09,79.89 265.48,79.89 v1(265.47,79.87)
  BOTTOM w0.254: PU18V00.14 268.21,79.6 268.01,79.4 PR18V05.1 267.44,79.54 PC18V03.2 PR18V02.2
FB_1V: length 5.6
  TOP w0.254: PU100.14 251.37,38.45 252.07,37.75 PR106.2 PC114.2 v2(253.58,37.25)
  BOTTOM w0.127: v1(254.03,37.63) 253.65,37.25 v2(253.58,37.25)
  BOTTOM w0.254: PR107.1 253.09,36.76 v2(253.58,37.25)
FB_2.5V: length 6
  BOTTOM w0.14: v1(162.31,30.46) 162.68,30.83 PC25V03.2
  BOTTOM w0.254: PC25V03.2 164.51,30.83 PR25V04.1 165.74,29.6 PR25V03.2 166.21,29.08 PU25V00.7
FB_3V: length 4.2
  TOP w0.14: PR300.2 85.78,44.31 v1(86.62,44.31)
  TOP w0.203: PR300.2 PR302.2 84.15,43.84 83.52,43.21 83.51,43.22 PU300.4
FB_5V: length 4.4
  TOP w0.14: PR301.1 86.36,41.77 v1(86.82,41.32)
  TOP w0.203: PR303.1 84.28,41.77 83.62,42.42 PU300.2
  TOP w0.254: PR301.1 PR303.1
FB_+1.35V: length 8.8
  TOP w0.14: v1(235.45,49.39) 235.97,49.91 235.97,50.85 235.47,51.35 PC814.1
  TOP w0.254: PC814.1 235.89,51.78 PR812.1 235.88,52.91 234.75,52.91 PR807.1 234.54,53.61 PR809.1 235.27,54.07 235.57,54.37 235.57,54.84 235.95,55.22 PU800.4
FB_GPU: length 6.2
  TOP w0.203: PC6011.2 PR6025.1 153.96,133.58 v2(154.55,134.16) 154.85,134.47 v1(155.09,134.47) 156.21,135.59 PU6000.31
  BOTTOM w0.254: v2(154.55,134.16) 154.55,133.63 154.22,133.3 PR6022.1
FB_RC_1: length 3.9
  TOP w0.14: v1(151.06,133.12) 151.51,132.67 v2(152.16,132.67)
  TOP w0.254: PC6011.1 v2(152.16,132.67)
  BOTTOM w0.254: PR6024.2 152.44,131.66 152.16,131.94 v2(152.16,132.67)
FB_RC_2: length 72.4
  TOP w0.14: v1(154.55,131.59) 154.85,131.89 v2(154.85,132.08)
  TOP w0.254: PR6025.2 154.27,132.67 v2(154.85,132.08) ; v2(195.29,110.89) 196.04,110.89 196.2,110.72 PR6021.1 196.51,110.77 196.51,111.74 PR6023.1
  IN1 w0.254: v2(186.45,104.3) 186.89,103.85 187.49,103.85 190.16,106.52 192.14,106.52 194.37,108.75 194.37,110.41 194.84,110.89 v2(195.29,110.89)
  IN4 w0.254: v2(186.45,104.3) 185.47,105.27 185.47,106.9 183.38,108.99 180.56,108.99 179.81,109.75 179.81,115.57 179.45,115.93 174.63,115.93 174.44,115.74 172.98,115.74 171.4,117.32 171.4,117.34 171.04,117.69 171.04,120.3 168.95,122.39 167.86,122.39 167.3,122.95 165.53,122.95 164.62,123.85 163.68,123.85 162.01,122.18 158.75,122.18 155.26,125.67 155.26,130.36 155.44,130.54 155.44,131.5 v2(154.85,132.08)
  BOTTOM w0.254: PR6024.1 154.43,131.66 v2(154.85,132.08)
FB_VCCIO: length 4.5
  BOTTOM w0.254: PU4000.14 126.65,102.34 127.13,101.86 v1(127.13,101.59) 127.13,101.41 127.48,101.06 PR4009.1 128.04,101.94 PC4010.2 128.06,101.96 PR4006.2
FB_VCCIO_SENSE: length 3
  BOTTOM w0.127: PR4007.1 130.77,103.67 v1(130.51,103.94)
  BOTTOM w0.254: PR4006.1 128.99,102.88 PR4004.2 129.93,102.83 PR4007.1
FB_VDDQ_SENSE: length 147
  TOP w0.254: PR814.2 232.24,53.1 v2(231.47,53.86)
  IN3 w0.254: v2(232.14,122.07) 265.28,122.07 266.55,120.81 266.55,92.61 264.55,90.62 264.55,81.8 265.94,80.42 265.94,80.08 266.49,79.53 266.49,76.49 268.01,74.97 268.01,71.94 267.16,71.08 245.59,71.08 244.89,71.78 237.21,71.78 236.92,71.49 v2(236.2,70.77)
  BOTTOM w0.2: v2(232.14,122.07) v1(232.14,120.88) 232.14,120.46 233.55,119.05 233.55,117.6 233.11,117.16 233.11,115.51 UG9.E52
  BOTTOM w0.254: v2(231.47,53.86) 231.47,56.14 233.6,58.27 233.6,62.08 236.2,64.67 v2(236.2,70.77)
FBA_CLK0: length 33.3
  TOP w0.119: 217.65,133.82 217.77,133.7 218.04,133.7 v2(218.22,133.88)
  TOP w0.137: RG102.1 217.65,133.82
  IN5 w0.102: v2(218.22,133.88) 218.02,133.68 217.92,133.68 217.84,133.76 217.84,135.41 218.42,135.98 219.99,135.98 220.13,135.84 v2(220.13,135.58)
  IN5 w0.119: v2(217.25,110.15) 217.66,110.56 217.66,110.85 218.17,111.36 218.17,114.24 217.84,114.57 217.22,114.57 217.04,114.75 217.04,126.1 218.06,127.11 218.06,131.88 218.29,132.12 218.71,132.12 218.95,132.36 218.95,133.26 218.7,133.5 218.6,133.5 v2(218.22,133.88)
  BOTTOM w0.089: UG1.J12 v2(220.13,135.58)
  BOTTOM w0.119: UG9.AG45 v2(217.25,110.15)
FBA_CLK0#: length 33.4
  TOP w0.119: v2(218.22,133.3) 218.03,133.49 217.83,133.49 217.65,133.31
  TOP w0.137: RG523.1 217.65,133.31
  IN5 w0.102: v2(220.93,135.58) 220.66,135.58 220.07,136.17 218.34,136.17 217.65,135.49 217.65,133.68 217.84,133.49 218.03,133.49 v2(218.22,133.3)
  IN5 w0.119: v2(217.25,110.85) 217.37,110.85 217.96,111.45 217.96,114.15 217.76,114.36 217.13,114.36 216.83,114.66 216.83,126.18 217.85,127.2 217.85,131.97 218.21,132.33 218.62,132.33 218.74,132.45 218.74,133.17 218.61,133.3 v2(218.22,133.3)
  BOTTOM w0.089: UG1.J11 v2(220.93,135.58)
  BOTTOM w0.119: UG9.AG46 v2(217.25,110.85)
FBA_CLK1: length 38.5
  TOP w0.137: v2(211.88,133.27) 212.07,133.47 212.54,133.47 RG103.1
  IN1 w0.089: v2(209.46,135.58) 209.35,135.47 209.22,135.47 209.12,135.58 209.12,135.8 209.18,135.86
  IN1 w0.119: v2(215.15,110.85) 215.15,110.66 215.33,110.48 215.54,110.48 215.62,110.56 215.62,113.95 214.4,115.17 214.4,120.78 210.77,124.41 210.77,125.89 211.01,126.13 212.01,126.13 212.12,126.25 212.12,126.61 212.01,126.72 211,126.72 210.76,126.97 210.76,127.5 211,127.74 212.01,127.74 212.12,127.86 212.12,131.96 212.58,132.41 212.58,133.46 212.42,133.61 212.24,133.61 211.9,133.27 v2(211.88,133.27) 211.88,133.28 211.58,133.57 211.36,133.57 211.16,133.77 211.16,134.46 211.44,134.74 211.44,135.31 210.53,136.22 209.39,136.22 209.18,136.01 209.18,135.86
  BOTTOM w0.089: UG2.J12 v2(209.46,135.58)
  BOTTOM w0.119: UG9.AK46 v2(215.15,110.85)
FBA_CLK1#: length 38.8
  TOP w0.137: v2(211.88,133.86) 212.04,133.7 212.45,133.7 RG524.1
  IN1 w0.089: v2(208.66,135.58) 208.95,135.87 208.95,135.99 208.97,136 208.97,136.01
  IN1 w0.119: 208.97,136.01 208.97,136.09 209.3,136.43 210.61,136.43 211.64,135.4 211.64,134.65 211.37,134.38 211.37,133.85 211.44,133.78 211.67,133.78 211.72,133.82 211.84,133.82 v2(211.88,133.86) 211.91,133.82 212.51,133.82 212.79,133.54 212.79,132.33 212.33,131.87 212.33,127.77 212.09,127.53 211.09,127.53 210.97,127.41 210.97,127.05 211.09,126.93 212.09,126.93 212.33,126.69 212.33,126.16 212.09,125.92 211.1,125.92 210.98,125.8 210.98,124.49 214.61,120.87 214.61,115.26 215.83,114.04 215.83,110.47 215.63,110.27 215.27,110.27 v2(215.15,110.15)
  BOTTOM w0.089: UG2.J11 v2(208.66,135.58)
  BOTTOM w0.119: UG9.AK45 v2(215.15,110.15)
FBA_CMD0: length 31.4
  BOTTOM w0.142: 222.62,118.95 222.62,115.76 222.79,115.59 222.79,115.14 222.45,114.8 UG9.Y51
  BOTTOM w0.173: 222.62,118.95 222.62,120.35 223.57,121.3 225.23,121.3 225.91,121.3 v1(228.66,124.06) 231.92,127.31 231.92,135.46 231.79,135.59 231.79,135.59 230.07,137.31 229.71,137.31 229.59,137.19 228.12,137.19 227.73,137.58 UG1.G3
FBA_CMD1: length 32.2
  TOP w0.178: v2(228.13,136.38) 229.06,137.31 230.59,137.31 RG47.2
  BOTTOM w0.142: 222.37,118.62 222.37,115.43 UG9.Y52 ; UG1.J3 v2(228.13,136.38)
  BOTTOM w0.173: v2(228.13,136.38) 228.13,136.39 230.26,136.39 231.31,135.34 231.31,127.54 v1(226.64,122.87) 225.33,121.56 223.38,121.56 222.15,120.34 222.15,118.84 222.37,118.62
FBA_CMD2: length 30.8
  TOP w0.136: 230.33,135.58 v2(228.92,135.58)
  TOP w0.173: RG54.1 230.54,135.37 230.33,135.58
  BOTTOM w0.089: UG1.J2 228.53,135.98
  BOTTOM w0.142: 222.1,118.36 222.1,113.6 UG9.Y49 ; 228.53,135.98 v2(228.92,135.58)
  BOTTOM w0.173: 222.1,118.36 221.85,118.61 221.85,120.42 223.4,121.97 224.9,121.97 v1(229.93,127) 230.72,127.79 230.72,134.81 230,135.53 228.97,135.53 v2(228.92,135.58)
FBA_CMD3: length 25.9
  BOTTOM w0.142: UG9.AA52 221.75,118.17
  BOTTOM w0.173: 221.75,118.17 221.53,118.39 221.53,120.53 223.33,122.33 224.42,122.33 v1(227.91,125.82) 229.27,127.18 229.27,128.04 230.13,128.9 230.13,134.15 229.53,134.75 228.1,134.75 UG1.L3
FBA_CMD4: length 24
  BOTTOM w0.142: UG1.K5 226.13,135.07 225.76,134.71 225.76,129.36 226.65,128.47 226.65,128.2 ; UG9.AA51 221.75,114.85 221.39,115.21 221.39,115.8 221.48,115.88 221.48,117.92
  BOTTOM w0.173: 221.48,117.92 221.14,118.26 221.14,120.51 223.22,122.59 223.84,122.59 v1(224.51,123.25) 226.65,125.4 226.65,128.2
FBA_CMD5: length 26
  BOTTOM w0.142: UG9.AA50 221.75,114.14 221.41,114.48 221.41,114.84 221.16,115.09 221.16,115.92 221.22,115.98 221.22,117.64 ; 226.13,127.9 226.13,128.58 225.47,129.23 225.47,135.29 225.71,135.53 226.41,135.53 226.77,135.18 UG1.K4
  BOTTOM w0.173: 221.22,117.64 220.82,118.04 220.82,120.56 223.11,122.85 223.27,122.85 226.13,125.71 v1(226.13,127.02) 226.13,127.9
FBA_CMD6: length 25.5
  BOTTOM w0.142: 220.93,117.43 220.93,115.04 220.7,114.81 220.7,114.3 UG9.AC50 ; 225.61,127.9 225.61,128.59 225.19,129.01 225.19,135.58 225.59,135.98 UG1.J5
  BOTTOM w0.173: 225.61,127.9 225.61,126.03 v1(224.87,125.29) 222.35,122.77 222.35,122.59 220.46,120.7 220.46,117.9 220.93,117.43
FBA_CMD7: length 26
  BOTTOM w0.102: UG1.J4 226.61,136.3 225.47,136.3 224.83,135.66 224.83,128.87 225.08,128.61 225.08,127.9
  BOTTOM w0.142: 220.61,117.02 220.61,115.57 220.69,115.49 220.69,115.21 220.61,115.13 220.61,115.13 220.35,114.87 UG9.AC51
  BOTTOM w0.173: 225.08,127.9 225.08,126.34 v1(222.94,124.2) 221.78,123.04 221.78,122.44 220.16,120.82 220.16,117.53 220.61,117.08 220.61,117.02
FBA_CMD8: length 24.7
  BOTTOM w0.102: 224.57,127.9 224.57,136.08 225.27,136.78 UG1.H5
  BOTTOM w0.142: UG9.AC52 220.35,116.97
  BOTTOM w0.173: 224.57,127.9 224.57,126.67 221.26,123.35 v1(221.26,122.74) 221.26,122.33 219.85,120.92 219.85,117.47 220.35,116.97
FBA_CMD9: length 28.7
  BOTTOM w0.102: UG1.H4 226.52,137.19 225.11,137.19 224.31,136.39 224.31,128.22 224.05,127.97
  BOTTOM w0.142: 220,116.85 220,113.6 UG9.AC49
  BOTTOM w0.173: 224.05,127.97 224.05,126.99 v1(223.5,126.44) 220.74,123.67 220.74,122.21 219.44,120.92 219.44,117.41 220,116.85
FBA_CMD10: length 27.1
  BOTTOM w0.102: 223.8,128.43 223.94,128.58 223.94,136.17 222.92,137.19 220.89,137.19 220.53,137.55 UG1.G12
  BOTTOM w0.142: UG9.AD52 219.65,116.67
  BOTTOM w0.173: 223.8,128.43 223.7,128.43 223.46,128.19 223.46,127.23 v1(221.37,125.14) 220.21,123.99 220.21,122.1 219.12,121.01 219.12,117.2 219.65,116.67
FBA_CMD11: length 25.6
  BOTTOM w0.102: UG1.H10 222.83,136.78 223.69,135.92 223.69,128.84 223.54,128.7
  BOTTOM w0.142: 219.38,116.53 219.38,115.62 219.28,115.53 219.28,115.22 219.65,114.85 UG9.AD51
  BOTTOM w0.173: 219.38,116.53 218.84,117.07 218.84,121.17 219.69,122.02 v1(219.69,123.74) 219.69,124.31 ; 223.54,128.7 222.92,128.08
  BOTTOM w0.178: 219.69,124.31 222.92,127.54 222.92,128.08
FBA_CMD12: length 26.8
  BOTTOM w0.102: UG1.H11 221.33,136.75 221.78,136.3 222.92,136.3 223.38,135.85 223.38,129.21 223.11,128.94
  BOTTOM w0.142: 219.1,116.42 219.1,115.79 219.05,115.74 219.05,115.1 219.3,114.85 219.3,114.45 219.65,114.1 UG9.AD50
  BOTTOM w0.173: 219.1,116.42 218.56,116.95 218.56,121.32 219.17,121.93 219.17,124.62 v1(221.62,127.07) 222.62,128.07 222.62,128.21 223.11,128.69 223.11,128.94
FBA_CMD13: length 25.7
  BOTTOM w0.102: 221.45,127.66 223.15,129.36 223.15,134.87 222.48,135.54 221.68,135.54 UG1.K11
  BOTTOM w0.142: UG9.AF50 218.6,114.3 218.6,114.8 218.82,115.02 218.82,116.28
  BOTTOM w0.173: 218.82,116.28 218.26,116.84 218.26,121.46 218.65,121.86 218.65,124.94 v1(219.41,125.7) 221.38,127.66 221.45,127.66
FBA_CMD14: length 23.7
  BOTTOM w0.102: 221.1,128.22 221.45,128.22 221.88,128.65 222.12,128.65 222.8,129.34 222.8,134.64 222.27,135.18 UG1.K10
  BOTTOM w0.142: 218.55,116.15 218.59,116.11 218.59,115.14 218.25,114.8 UG9.AF51
  BOTTOM w0.173: 221.1,128.22 218.13,125.26 v1(218.13,122.67) 218.13,121.72 217.94,121.53 217.94,116.75 218.55,116.15
FBA_CMD15: length 24.5
  BOTTOM w0.102: UG1.L12 220.53,134.41 220.98,134.87 222.13,134.87 222.58,134.42 222.58,129.43 222.02,128.88 221.64,128.88 221.31,128.55
  BOTTOM w0.142: 217.61,116.72 218.25,116.08 UG9.AF52
  BOTTOM w0.173: 217.61,116.72 v1(217.61,124.74) 217.61,125.58 220.59,128.55 221.31,128.55
FBA_CMD16: length 38.1
  BOTTOM w0.142: UG9.AN50 213.35,114.1 213,114.45 213,114.85 212.75,115.09 212.75,115.63 212.82,115.7 212.82,117.96
  BOTTOM w0.173: 212.82,117.96 211.93,118.86 210.29,118.86 210,119.15 203.87,119.15 v1(201.4,121.62) 197.43,125.6 197.43,135.37 199.37,137.32 199.76,137.32 199.89,137.19 201.47,137.19 UG2.L3
FBA_CMD17: length 36.7
  TOP w0.089: v2(201.46,136.38) 201.53,136.45 RG48.2
  BOTTOM w0.142: UG9.AN51 213.35,114.85 213,115.19 213,115.51 213.1,115.6 213.1,118.07
  BOTTOM w0.173: 213.1,118.07 211.79,119.38 210.51,119.38 210.12,119.76 v1(207.71,119.76) 204.1,119.76 197.95,125.91 197.95,135.16 199.17,136.38 v2(201.46,136.38) UG2.J3
FBA_CMD18: length 33.4
  TOP w0.089: v2(200.66,135.58) 200.68,135.55 RG53.1
  BOTTOM w0.142: UG9.AN52 213.35,118.26
  BOTTOM w0.173: 213.35,118.26 211.71,119.89 210.72,119.89 210.24,120.37 204.33,120.37 v1(199.57,125.14) 198.47,126.23 198.47,134.94 199.07,135.53 200.61,135.53 v2(200.66,135.58) 201.06,135.98 UG2.J2
FBA_CMD19: length 34.3
  BOTTOM w0.089: UG2.G3 201.85,134.38
  BOTTOM w0.142: UG9.AM49 213.7,113.6 213.7,118.57
  BOTTOM w0.173: 201.85,134.38 201.45,134.78 200.14,134.78 199.89,134.52 199.43,134.52 198.99,134.09 198.99,126.55 v1(201.79,123.75) 204.56,120.98 210.36,120.98 210.93,120.41 211.86,120.41 213.7,118.57
FBA_CMD20: length 30.2
  BOTTOM w0.173: UG2.H5 203.8,134.83 203.8,129.43 203.6,129.23 203.59,129.23 203.17,128.81 202.41,128.81 201.59,127.98 v1(201.59,126.48) 201.59,124.79 204.79,121.59 210.48,121.59 211.15,120.92 211.79,120.92 214.05,118.66
  BOTTOM w0.178: UG9.AM52 214.05,118.66
FBA_CMD21: length 32.4
  BOTTOM w0.102: UG2.H4 203.01,135.18 203.37,135.54 203.75,135.54 204.38,134.9 204.38,129.65 204.07,129.33 204.07,129.32 203.71,128.97 203.7,128.97 203.13,128.4 202.64,128.4 202.11,127.87
  BOTTOM w0.142: UG9.AM51 214.05,114.8 214.39,115.14 214.39,115.96 214.33,116.01 214.33,118.9
  BOTTOM w0.173: 202.11,127.87 202.11,125.11 205.02,122.2 v1(207.77,122.2) 210.6,122.2 211.36,121.44 211.79,121.44 214.33,118.9
FBA_CMD22: length 32.2
  BOTTOM w0.102: 202.65,127.82 202.65,127.84 202.91,128.1 203.17,128.1 204.64,129.57 204.64,135.09 203.74,135.98 UG2.J5
  BOTTOM w0.142: UG9.AM50 214.05,114.17 214.4,114.52 214.4,114.8 214.63,115.03 214.63,119.15
  BOTTOM w0.173: 202.65,127.82 202.63,127.79 202.63,125.43 v1(204.01,124.04) 205.25,122.81 210.72,122.81 211.75,121.78 211.99,121.78 214.63,119.15
FBA_CMD23: length 33.1
  BOTTOM w0.102: UG2.J4 202.79,135.98 203.11,136.3 203.75,136.3 204.92,135.13 204.92,129.47 203.15,127.7
  BOTTOM w0.142: 214.67,119.59 214.91,119.35 214.91,117.73 214.86,117.68 214.86,115.09 215.1,114.85 215.1,114.3 UG9.AK50
  BOTTOM w0.173: 214.67,119.59 210.84,123.42 v1(209.6,123.42) 205.47,123.42 203.15,125.75 203.15,127.7
FBA_CMD24: length 31.5
  BOTTOM w0.102: 203.73,127.79 203.73,127.9 205.14,129.31 205.14,135.34 203.71,136.78 UG2.K5
  BOTTOM w0.142: UG9.AK51 215.45,114.85 215.1,115.2 215.1,117.57 215.15,117.61 215.15,119.85
  BOTTOM w0.173: 215.15,119.85 210.97,124.03 v1(206.57,124.03) 205.7,124.03 203.73,126 203.73,127.79
FBA_CMD25: length 31.8
  BOTTOM w0.102: UG2.K4 202.83,136.78 203.14,137.09 203.72,137.09 205.46,135.35 205.46,129.25 204.25,128.04 204.25,127.9
  BOTTOM w0.173: UG9.AK52 215.45,120.04 213.66,121.83 213.66,122.07 v1(212.14,123.59) 211.09,124.64 205.93,124.64 204.25,126.32 204.25,127.9
FBA_CMD26: length 34.8
  BOTTOM w0.102: 204.77,128 204.77,128.12 205.77,129.11 205.77,136.04 205.78,136.06 205.78,136.1 206.87,137.19 208.57,137.19 208.96,137.58 UG2.L12
  BOTTOM w0.142: 215.73,120.19 215.73,115.77 215.8,115.71 215.79,115.71 215.8,115.7 215.8,113.6 UG9.AJ49
  BOTTOM w0.173: 215.73,120.19 214.23,121.69 214.23,122.24 211.22,125.25 v1(208.64,125.25) 206.16,125.25 204.77,126.64 204.77,128
FBA_CMD27: length 30.1
  BOTTOM w0.102: 205.29,128.26 206,128.96 206,135.95 206.03,135.99 206.03,136.03 206.78,136.78 UG2.K10
  BOTTOM w0.142: 216.05,120.31 216.05,115.46 UG9.AJ52
  BOTTOM w0.173: 216.05,120.31 214.8,121.55 214.8,122.4 211.35,125.86 206.39,125.86 v1(205.88,126.37) 205.29,126.96 205.29,128.26
FBA_CMD28: length 31.4
  BOTTOM w0.102: UG2.K11 208.16,136.78 207.86,136.47 207.59,136.47 207.59,136.47 207.33,136.47 207.25,136.55 206.92,136.55 206.22,135.85 206.22,128.81 205.84,128.42
  BOTTOM w0.142: 216.28,120.47 216.38,120.37 216.38,118.39 216.28,118.29 216.28,115.76 216.51,115.53 216.51,115.16 216.15,114.8 UG9.AJ51
  BOTTOM w0.173: 216.28,120.47 215.38,121.37 215.38,122.64 211.55,126.47 v1(210.38,126.47) 206.62,126.47 205.84,127.25 205.84,128.42
FBA_CMD29: length 30.9
  BOTTOM w0.102: 206.36,127.93 206.48,128.05 206.48,135.22 206.8,135.54 207.81,135.54 208.17,135.18 UG2.H11
  BOTTOM w0.142: UG9.AJ50 216.5,114.3 216.5,114.8 216.75,115.05 216.75,115.64 216.53,115.86 216.53,118.16
  BOTTOM w0.173: 206.36,127.93 206.36,127.57 206.85,127.08 211.7,127.08 v1(215.45,123.33) 215.95,122.83 215.95,121.37 216.63,120.69 216.63,118.27 216.53,118.16
FBA_CMD30: length 29
  BOTTOM w0.102: 206.87,128.11 206.8,128.19 206.8,134.81 207.16,135.18 UG2.H10
  BOTTOM w0.142: UG9.AG50 217.2,114.3 217.2,114.85 216.98,115.07 216.98,115.81 216.79,116
  BOTTOM w0.173: 206.87,128.11 206.87,127.94 207.12,127.69 211.83,127.69 v1(212.73,126.78) 216.52,123 216.52,121.56 216.96,121.12 216.96,118.12 216.79,117.94 216.79,116
FBA_CMD31: length 29.3
  BOTTOM w0.102: 207.29,128.27 207.11,128.45 207.11,134.46 207.15,134.5 207.15,134.51 207.33,134.69 207.34,134.69 207.42,134.78 208.66,134.78 UG2.G12
  BOTTOM w0.142: 217.05,117.75 217.05,116.14 217.21,115.98 217.21,115.19 217.55,114.85 UG9.AG51
  BOTTOM w0.173: 217.05,117.75 217.29,118 217.29,121.77 217.09,121.97 217.09,123.16 v1(214.79,125.46) 211.98,128.27 207.29,128.27
FBA_D0: length 17.6
  IN5 w0.145: v2(227.33,129.18) 227.33,124.47 224.52,121.67 224.52,118.21 223.96,117.65 v2(223.85,117.65)
  BOTTOM w0.089: v2(227.33,129.18) 226.93,129.58 UG1.U4
  BOTTOM w0.142: 224.51,117.69 224.82,117.38 224.82,115.56 224.89,115.49 224.89,115.14 224.55,114.8 UG9.U51
  BOTTOM w0.178: 224.51,117.69 223.89,117.69 v2(223.85,117.65)
FBA_D1: length 19.3
  IN5 w0.145: v2(228.93,129.18) 229.27,128.83 229.27,124.81 225.47,121.02 225.47,115.82 224.95,115.3 v2(224.95,113.65)
  BOTTOM w0.089: UG1.U2 228.53,129.58 v2(228.93,129.18)
  BOTTOM w0.102: v2(224.95,113.65) 224.9,113.6 224.9,113.13 224.55,112.78 UG9.U48
FBA_D2: length 19.8
  IN5 w0.145: v2(227.33,129.98) 226.54,129.19 226.54,125.48 222.93,121.87 222.93,119.17 223.42,118.68 223.42,118.67 223.67,118.42 223.68,118.42 v2(223.85,118.25)
  BOTTOM w0.089: v2(227.33,129.98) 226.93,130.38 UG1.T4
  BOTTOM w0.142: UG9.U50 224.55,114.16 224.9,114.51 224.9,114.8 225.12,115.02 225.12,115.61 225.05,115.67 225.05,117.55
  BOTTOM w0.178: v2(223.85,118.25) 224.35,118.25 225.05,117.55
FBA_D3: length 22.5
  IN5 w0.089: 225.84,128.39 225.84,129.95 226.29,130.39 227.71,130.39 v2(228.13,129.98)
  IN5 w0.145: 225.84,128.39 225.84,125.56 222.49,122.21 222.49,118.72 223.14,118.07 223.14,116.85 223.68,116.31 224.19,116.31 v2(224.2,116.3)
  BOTTOM w0.089: UG1.T2 v2(228.13,129.98)
  BOTTOM w0.142: v2(224.2,116.3) 224.29,116.21 224.29,115.64 224.2,115.55 224.2,113.6 UG9.U49
FBA_D4: length 26
  IN5 w0.089: v2(227.33,133.18) 227.73,133.59 230.33,133.59
  IN5 w0.145: 230.33,133.59 231.62,132.3 231.62,128.29 230.67,127.34 230.67,123.98 226.09,119.41 v2(225.95,119.41)
  BOTTOM w0.089: UG1.N4 v2(227.33,133.18)
  BOTTOM w0.142: v2(225.95,119.41) 225.86,119.41 v1(225.56,119.11) 225.56,115.93 225.6,115.89 225.6,115.2 225.95,114.85 UG9.R51
FBA_D5: length 22.5
  IN5 w0.089: v2(228.93,132.38) 229.33,131.98 230.1,131.98 230.33,131.74
  IN5 w0.145: 230.33,131.74 230.43,131.64 230.43,128.19 229.9,127.66 229.9,124 v2(225.94,120.04)
  BOTTOM w0.089: UG1.N2 228.53,132.78 v2(228.93,132.38)
  BOTTOM w0.142: 225.22,118.15 225.22,119.31 v2(225.94,120.04) ; UG9.R50 225.95,114.1 225.6,114.45 225.6,114.85 225.35,115.1 225.35,115.76 225.31,115.8 225.31,118.06
  BOTTOM w0.178: 225.31,118.06 225.22,118.15
FBA_D6: length 31.5
  IN5 w0.145: v2(227.33,133.98) 227.33,134.03 227.77,134.48 230.68,134.48 232.94,132.22 232.94,128.67 231.43,127.16 231.43,123.87 226.55,118.99 226.55,112.45 v2(225.65,111.55)
  BOTTOM w0.089: UG1.M4 v2(227.33,133.98)
  BOTTOM w0.17: UG9.R47 v2(225.65,111.55)
FBA_D7: length 24.8
  IN5 w0.089: v2(228.93,133.18) 228.51,132.76 228.51,128.87
  IN5 w0.145: v2(224.85,111.45) 224.39,111.91 224.39,115.31 225.09,116.01 225.09,121.44 228.51,124.85 228.51,128.87
  BOTTOM w0.089: v2(228.93,133.18) 228.53,133.58 UG1.M2
  BOTTOM w0.178: UG9.U46 v2(224.85,111.45)
FBA_D8: length 23.8
  IN3 w0.14: v2(221.73,129.98) 220.73,129.98 220.51,129.76 220.51,129.06 220.51,129.05 220.51,128.93 220.26,128.68 220.26,116.37 222.23,114.4 222.23,110.76 222.5,110.49 223.17,110.49 v2(223.54,110.86)
  BOTTOM w0.089: UG1.U11 v2(221.73,129.98)
  BOTTOM w0.178: UG9.V46 223.83,111.15 v2(223.54,110.86)
FBA_D9: length 22
  IN3 w0.14: v2(219.31,129.18) 219.5,128.99 219.5,116.52 221.9,114.12 221.9,110.53 222.38,110.05 v2(222.86,110.05)
  BOTTOM w0.089: v2(219.31,129.18) 219.7,129.58 UG1.U13
  BOTTOM w0.178: UG9.Y45 v2(222.86,110.05)
FBA_D10: length 19.7
  IN3 w0.14: v2(222.86,112.26) 222.55,112.56 222.55,114.85 220.89,116.5 220.89,116.51 220.91,116.53 220.91,129.02 v2(220.96,129.06)
  BOTTOM w0.089: UG1.T11 220.96,130.01 v2(220.96,129.06)
  BOTTOM w0.178: UG9.Y47 v2(222.86,112.26)
FBA_D11: length 24.8
  IN3 w0.089: v2(219.33,129.98) 219.46,129.98 219.88,130.39 221.96,130.39 221.96,130.39 ; 223.7,111.84 223.7,111.85 223.18,111.85 222.81,111.49 v2(222.81,111.48)
  IN3 w0.14: 221.96,130.39 222.16,130.19 222.16,127.92 221.65,127.41 221.65,116.47 223.96,114.16 223.96,112.1 223.7,111.84
  BOTTOM w0.089: UG1.T13 v2(219.33,129.98)
  BOTTOM w0.178: UG9.Y46 222.49,111.15 v2(222.81,111.48)
FBA_D12: length 21.8
  IN3 w0.14: v2(223.79,120.06) 223.29,120.06 222.96,120.39 222.96,126.87 223.47,127.37 223.47,130.53 222.03,131.98 221.53,131.98 221.13,132.38 v2(220.93,132.38)
  BOTTOM w0.089: UG1.N11 v2(220.93,132.38)
  BOTTOM w0.142: UG9.V50 223.85,114.17 223.5,114.52 223.5,114.85 223.26,115.09 223.26,115.85 223.19,115.92 223.19,119.46 v2(223.79,120.06)
FBA_D13: length 25.8
  IN3 w0.089: 221.97,131.15 220.7,131.15 220.51,131.35 220.51,132.11 220.24,132.38 v2(220.13,132.38)
  IN3 w0.14: 221.97,131.15 222.81,130.31 222.81,127.64 222.31,127.14 222.31,116.68 224.46,114.53 224.46,111.9 224.11,111.55 223.55,111.55 v2(223.45,111.45)
  BOTTOM w0.089: UG1.N13 v2(220.13,132.38)
  BOTTOM w0.178: UG9.V47 v2(223.45,111.45)
FBA_D14: length 21.8
  IN3 w0.14: v2(224.25,117.15) 225.1,118 225.1,130.5 222.03,133.58 UG1.M11 v2(220.93,133.18)
  BOTTOM w0.089: UG1.M11 v2(220.93,133.18)
  BOTTOM w0.142: v2(224.25,117.15) 224.59,116.81 224.59,115.39 UG9.U52
FBA_D15: length 23.4
  IN3 w0.089: 222.03,132.74 222.03,132.74 219.81,132.74 219.38,133.18 v2(219.33,133.18)
  IN3 w0.14: 222.03,132.74 224.45,130.32 224.45,119.71 224.18,119.45 v2(223.8,119.45)
  BOTTOM w0.089: UG1.M13 v2(219.33,133.18)
  BOTTOM w0.142: v2(223.8,119.45) 223.44,119.09 223.44,116.04 223.51,115.97 223.51,115.19 223.85,114.85 UG9.V51
FBA_D16: length 44.1
  IN1 w0.129: 216.06,109.84 216.45,109.45 v2(216.5,109.45)
  IN1 w0.145: 216.06,109.84 216.06,115.03 215.34,115.75 215.34,121.42 213.58,123.18 213.58,140.36 217.71,144.49 220.57,144.49 221.71,143.34 v2(221.71,142.77)
  BOTTOM w0.178: UG1.A11 221.71,142.77 v2(221.71,142.77) ; UG9.AJ44 216.2,109.75 v2(216.5,109.45)
FBA_D17: length 34
  IN1 w0.145: v2(217.8,115.85) 217.86,115.92 217.86,118.12 217.02,118.96 217.02,122.08 215.44,123.67 215.44,139.55 218.3,142.41 218.99,142.41 v2(219.31,142.73)
  BOTTOM w0.089: v2(219.31,142.73) 219.66,142.38 UG1.A13
  BOTTOM w0.142: v2(217.8,115.85) 217.8,115.78 217.89,115.68 217.89,112.89 UG9.AG48
FBA_D18: length 44.1
  IN1 w0.1: v2(216.45,110.15) 216.83,109.77 217.47,109.77
  IN1 w0.129: 216.54,113.69 217.39,112.84 217.39,112.6 217.68,112.31 217.68,109.98 217.47,109.77
  IN1 w0.145: v2(221.73,141.98) 220.96,142.75 220.96,143.02 220.12,143.85 217.97,143.85 214.13,140.02 214.13,123.41 215.9,121.65 215.9,116.08 216.54,115.44 216.54,113.69
  BOTTOM w0.089: UG1.B11 221.33,141.58 v2(221.73,141.98)
  BOTTOM w0.178: UG9.AJ45 v2(216.45,110.15)
FBA_D19: length 35.9
  IN1 w0.145: v2(220.13,141.98) 219.74,142.36 219.74,142.9 219.49,143.15 218.16,143.15 214.79,139.78 214.79,123.54 216.45,121.88 216.45,116.56 217.34,115.66 217.34,113.69 217.25,113.6 v2(217.25,113.55)
  BOTTOM w0.089: UG1.B13 219.73,141.58 v2(220.13,141.98)
  BOTTOM w0.17: v2(217.25,113.55) UG9.AG49
FBA_D20: length 34.3
  IN1 w0.145: v2(220.93,139.58) 221.32,139.19 221.32,138.12 219.49,136.3 218.22,136.3 217.78,135.85 217.78,124.51 219.23,123.06 219.23,119.9 220.33,118.8 220.33,116.57 220.25,116.5 220.25,111.85 v2(219.25,110.85)
  BOTTOM w0.089: UG1.E11 221.32,139.18 v2(220.93,139.58)
  BOTTOM w0.102: v2(219.25,110.85) 218.95,111.15 UG9.AF46
FBA_D21: length 32.6
  IN1 w0.145: v2(219.33,138.78) 218.93,139.18 217.55,139.18 216.13,137.76 216.13,123.82 217.57,122.37 217.57,119.22 218.41,118.38 218.41,114.88 217.9,114.37 217.9,113.04 218.15,112.79 218.15,111.95 v2(218.55,111.55)
  BOTTOM w0.089: UG1.E13 v2(219.33,138.78)
  BOTTOM w0.17: v2(218.55,111.55) UG9.AF47
FBA_D22: length 31.6
  IN1 w0.145: v2(220.93,138.78) 220.53,138.38 217.7,138.38 216.68,137.36 216.68,124.05 218.12,122.6 218.12,119.45 218.96,118.61 218.96,114.61 218.55,114.2 218.55,112.82 v2(218.63,112.74)
  BOTTOM w0.089: v2(220.93,138.78) 221.32,138.38 UG1.F11
  BOTTOM w0.17: v2(218.63,112.74) UG9.AF48
FBA_D23: length 30.1
  IN1 w0.145: v2(219.35,111.55) 219.77,111.97 219.77,118.58 218.67,119.67 218.67,122.83 217.23,124.28 217.23,136.83 217.97,137.57 218.91,137.57 v2(219.33,137.98)
  BOTTOM w0.089: UG1.F13 v2(219.33,137.98)
  BOTTOM w0.17: v2(219.35,111.55) UG9.AD47
FBA_D24: length 35.5
  IN5 w0.145: v2(226.53,142.78) 226.46,142.71 224.94,142.71 223.96,141.73 223.96,140.26 223.3,139.6 223.3,135.72 222.71,135.13 222.2,135.13 221.34,134.27 221.34,131.44 221.09,131.19 220.73,131.19 220.53,130.99 220.53,129.07 219.63,128.17 219.63,127.15 218.42,125.94 218.42,116.67 218.72,116.38 218.72,115.05 219.51,114.26 219.51,113.71 v2(219.35,113.55)
  BOTTOM w0.089: UG1.A4 226.92,142.38 v2(226.53,142.78)
  BOTTOM w0.17: UG9.AD49 v2(219.35,113.55)
FBA_D25: length 38.9
  IN5 w0.145: v2(228.13,142.78) 227.62,143.28 224.57,143.28 223.4,142.11 223.4,141.28 222.22,140.11 222.22,135.83 220.52,134.12 220.52,132.22 220.28,131.98 219.97,131.98 219.72,131.72 219.72,129.04 218.9,128.22 218.9,127.19 217.73,126.02 217.73,116.67 218.23,116.17 218.23,115.19 218.49,114.93 218.49,113.71 219.25,112.95 219.25,112.77 v2(219.27,112.75)
  BOTTOM w0.089: UG1.A2 228.52,142.38 v2(228.13,142.78)
  BOTTOM w0.17: v2(219.27,112.75) UG9.AD48
FBA_D26: length 36.4
  IN5 w0.145: v2(220.65,111.45) 220.65,111.57 219.89,112.33 219.89,114.7 219.18,115.41 219.18,125.83 220.28,126.93 220.28,127.84 222.16,129.71 222.16,133.82 223.81,135.47 223.81,139.34 224.51,140.04 224.51,141.44 225.44,142.37 225.89,142.37 226.28,141.98 v2(226.53,141.98)
  BOTTOM w0.089: UG1.B4 226.92,141.58 v2(226.53,141.98)
  BOTTOM w0.17: v2(220.65,111.45) UG9.AC46
FBA_D27: length 36.1
  IN5 w0.145: v2(228.13,141.98) 228.09,141.98 227.7,141.59 225.35,141.59 224.95,141.19 224.95,139.79 224.25,139.09 224.25,135.22 222.67,133.63 222.67,129.25 220.94,127.52 220.94,126.63 219.74,125.43 219.74,115.61 220.24,115.11 220.24,112.56 v2(220.65,112.15)
  BOTTOM w0.089: v2(228.13,141.98) 228.52,141.58 UG1.B2
  BOTTOM w0.17: v2(220.65,112.15) UG9.AC47
FBA_D28: length 33.8
  IN5 w0.145: v2(227.33,138.78) 227.3,138.78 226.89,139.19 225.05,139.19 224.76,138.9 224.76,135.03 223.19,133.45 223.19,128.99 221.49,127.29 221.49,126.4 220.32,125.23 220.32,115.87 221.82,114.37 221.82,111.92 v2(221.45,111.55)
  BOTTOM w0.089: UG1.E4 226.93,139.18 v2(227.33,138.78)
  BOTTOM w0.178: UG9.AA47 v2(221.45,111.55)
FBA_D29: length 34.1
  IN5 w0.145: v2(221.45,110.85) 221.63,110.85 222.11,111.34 222.11,115.16 220.89,116.38 220.89,122.95 221.53,123.59 221.53,125.66 223.78,127.91 223.78,133.28 225.21,134.71 225.21,138.14 225.44,138.37 227.72,138.37 228.13,138.77 v2(228.13,138.78)
  BOTTOM w0.089: UG1.E2 v2(228.13,138.78)
  BOTTOM w0.178: UG9.AA46 v2(221.45,110.85)
FBA_D30: length 32
  IN5 w0.145: v2(221.45,110.15) 221.8,110.15 222.39,110.74 222.39,112.39 222.54,112.54 222.54,115.56 221.48,116.62 221.48,122.76 224.44,125.72 224.44,133.18 225.76,134.5 225.76,137.21 v2(226.53,137.98)
  BOTTOM w0.089: UG1.F4 v2(226.53,137.98)
  BOTTOM w0.178: UG9.AA45 v2(221.45,110.15)
FBA_D31: length 34.1
  IN5 w0.145: v2(222.75,109.45) 222.82,109.45 223.11,109.74 223.66,109.74 223.96,110.04 223.96,115.03 221.98,117.01 221.98,122.48 225.08,125.58 225.08,133.25 226.22,134.39 226.22,136.74 227.07,137.59 227.74,137.59 v2(228.13,137.98)
  BOTTOM w0.089: UG1.F2 v2(228.13,137.98)
  BOTTOM w0.178: UG9.Y44 v2(222.75,109.45)
FBA_D32: length 20.3
  IN1 w0.145: v2(208.85,114.95) 209.24,115.34 209.24,115.83 208.82,116.25 208.35,116.25 207.37,117.22 206.95,117.22 206.14,118.03 206.14,118.54 205.28,119.4 205.28,120.92 200.95,125.25 200.95,128.36 v2(200.89,128.42)
  BOTTOM w0.089: UG2.A4 202.36,129.58 201.2,128.42 v2(200.89,128.42)
  BOTTOM w0.178: UG9.AW51 v2(208.85,114.95)
FBA_D33: length 20.1
  IN1 w0.089: v2(199.87,128.81) 199.68,128.63 199.68,128.32
  IN1 w0.145: v2(207.45,115.65) 207.45,115.85 207.03,116.26 207.02,116.26 207,116.28 204.15,116.28 199.68,120.75 199.68,128.32
  BOTTOM w0.089: UG2.A2 200.71,129.58 199.94,128.81 v2(199.87,128.81)
  BOTTOM w0.178: UG9.BA52 v2(207.45,115.65)
FBA_D34: length 20.7
  IN1 w0.145: v2(208.85,114.25) 208.95,114.25 209.67,114.96 209.67,115.87 207.37,118.16 207.37,119.68 201.66,125.4 201.66,129.38 v2(202.26,129.98)
  BOTTOM w0.089: UG2.B4 202.66,130.38 v2(202.26,129.98)
  BOTTOM w0.178: UG9.AW50 v2(208.85,114.25)
FBA_D35: length 21
  IN1 w0.145: v2(208.05,114.95) 207.86,115.14 207.86,116 207.15,116.71 204.51,116.71 200.23,120.98 200.23,127.83 200.26,127.86 200.26,129.57 200.26,129.57 200.26,129.58 v2(200.66,129.98)
  BOTTOM w0.089: v2(200.66,129.98) 201.06,130.38 UG2.B2
  BOTTOM w0.106: UG9.BA51 v2(208.05,114.95)
FBA_D36: length 28.9
  IN1 w0.145: v2(207.45,114.25) 207,113.8 205.08,113.8 198.15,120.72 198.15,131.54 199.38,132.77 201.85,132.77 v2(202.26,133.18)
  BOTTOM w0.089: UG2.E4 v2(202.26,133.18)
  BOTTOM w0.178: UG9.BA50 v2(207.45,114.25)
FBA_D37: length 24.2
  IN1 w0.145: v2(200.66,132.38) 200.26,131.98 199.52,131.98 199.05,131.51 199.05,120.61 205.41,114.25 v2(206.75,114.25)
  BOTTOM w0.089: v2(200.66,132.38) 201.06,132.78 UG2.E2
  BOTTOM w0.178: UG9.BB50 v2(206.75,114.25)
FBA_D38: length 33.4
  IN1 w0.145: v2(207.45,112.95) 206.97,112.47 204.52,112.47 196.85,120.15 196.85,132.08 199.14,134.37 201.87,134.37 v2(202.26,133.98)
  BOTTOM w0.089: UG2.F4 v2(202.26,133.98)
  BOTTOM w0.178: UG9.BA49 v2(207.45,112.95)
FBA_D39: length 30.9
  IN1 w0.145: v2(200.66,133.18) 200.27,133.57 199.26,133.57 197.5,131.81 197.5,120.45 204.54,113.41 207.64,113.41 208.1,112.95 v2(208.85,112.95)
  BOTTOM w0.089: v2(200.66,133.18) 201.06,133.58 UG2.F2
  BOTTOM w0.178: UG9.AW49 v2(208.85,112.95)
FBA_D40: length 22.7
  IN5 w0.145: v2(210.15,112.85) 209.29,113.71 209.29,115.84 208.9,116.23 208.39,116.23 207.95,116.67 207.95,117.75 205.4,120.3 205.4,128.49 206.35,129.44 208.39,129.44 v2(208.66,129.18)
  BOTTOM w0.17: UG9.AV48 v2(210.15,112.85)
  BOTTOM w0.213: UG2.A11 v2(208.66,129.18)
FBA_D41: length 21.4
  IN5 w0.113: v2(210.26,129.18) 209.4,128.32
  IN5 w0.145: v2(210.95,113.55) 211.03,113.63 211.03,114.23 210.13,115.13 210.13,116.4 209.34,117.18 209.34,118.9 206.5,121.74 206.5,127.62 207.18,128.3 209.38,128.3 209.4,128.32
  BOTTOM w0.17: UG9.AT49 v2(210.95,113.55)
  BOTTOM w0.213: UG2.A13 v2(210.26,129.18)
FBA_D42: length 26.9
  IN5 w0.089: v2(208.66,129.98) 209.07,130.39 210.41,130.39 210.73,130.07 210.73,128.55 210.5,128.32
  IN5 w0.145: v2(210.95,111.55) 211.44,112.04 211.44,115.06 210.74,115.75 210.74,116.74 209.9,117.58 209.9,119.15 207.05,122 207.05,127.39 207.32,127.66 209.84,127.66 210.5,128.32
  BOTTOM w0.17: UG9.AT47 v2(210.95,111.55)
  BOTTOM w0.213: UG2.B11 v2(208.66,129.98)
FBA_D43: length 23.7
  IN5 w0.089: v2(210.26,129.98) 209.84,129.56 209.26,129.56 209.08,129.37 209.08,128.93 208.95,128.81 208.48,128.81
  IN5 w0.145: 208.48,128.81 206.54,128.81 205.95,128.21 205.95,121.02 208.64,118.32 208.64,117.06 209.63,116.07 209.63,114.17 v2(210.95,112.85)
  BOTTOM w0.089: UG2.B13 v2(210.26,129.98)
  BOTTOM w0.17: UG9.AT48 v2(210.95,112.85)
FBA_D44: length 26.1
  IN5 w0.145: v2(210.95,110.85) 211.8,111.7 211.8,115.87 211.46,116.21 211.46,118.18 210.74,118.9 210.74,127.54 211.62,128.42 211.62,130.9 211.32,131.19 209.23,131.19 209.05,131.37 209.05,131.98 v2(208.66,132.38)
  BOTTOM w0.089: UG2.E11 v2(208.66,132.38)
  BOTTOM w0.17: UG9.AT46 v2(210.95,110.85)
FBA_D45: length 27.5
  IN5 w0.145: v2(210.26,133.18) 209.87,132.79 207.54,132.79 205.91,131.16 205.91,129.95 204.44,128.49 v2(204.44,117.69)
  BOTTOM w0.089: UG2.E13 v2(210.26,133.18)
  BOTTOM w0.102: UG9.AV51 209.85,114.89 210.17,115.21 210.17,115.53 209.03,116.67 205.85,116.67 205.4,117.12
  BOTTOM w0.213: v2(204.44,117.69) 204.95,117.69 205.13,117.51 205.13,117.39 205.4,117.12
FBA_D46: length 27.5
  IN5 w0.145: v2(203.49,118.54) 203.49,119.76 203.73,119.99 203.73,128.85 204.89,130.01 204.89,131.85 206.62,133.59 208.23,133.59 208.64,133.18 v2(208.66,133.18)
  BOTTOM w0.089: UG2.F11 v2(208.66,133.18)
  BOTTOM w0.102: UG9.AV52 209.85,115.55 208.91,116.48 205.22,116.48 205.03,116.67 204.31,116.67
  BOTTOM w0.178: 204.13,117.12 204.13,116.85 204.31,116.67
  BOTTOM w0.213: v2(203.49,118.54) 203.49,117.76 204.13,117.12
FBA_D47: length 34.4
  IN5 w0.145: v2(210.26,133.98) 210.26,134.04 209.91,134.39 204.25,134.39 203.49,133.63 203.49,129.57 202.86,128.93 202.86,119.9 202.49,119.53 v2(202.49,119.4)
  BOTTOM w0.089: UG2.F13 v2(210.26,133.98)
  BOTTOM w0.102: UG9.AV49 209.85,113.31 209.47,113.69 209.47,115.59 208.77,116.29 204.14,116.29
  BOTTOM w0.178: 204.14,116.29 203.31,117.12
  BOTTOM w0.213: 203.31,117.12 202.49,117.94 v2(202.49,119.4)
FBA_D48: length 40
  IN5 w0.145: v2(208.66,142.78) 208.66,143.66 209.51,144.51 212.42,144.51 216.87,140.06 216.87,132.25 217.09,132.03 217.09,127.42 216.29,126.62 216.29,113.01 v2(216.45,112.85)
  BOTTOM w0.089: UG2.U11 208.26,142.38 v2(208.66,142.78)
  BOTTOM w0.178: UG9.AJ48 v2(216.45,112.85)
FBA_D49: length 37.2
  IN5 w0.145: v2(216.45,111.45) 215.53,112.37 215.53,115 215.31,115.22 215.31,120.36 214.93,120.74 214.93,126.84 215.79,127.69 215.79,131.72 215.37,132.13 215.37,139.77 211.93,143.21 210.84,143.21 210.42,142.78 v2(210.26,142.78)
  BOTTOM w0.089: v2(210.26,142.78) 209.86,142.38 UG2.U13
  BOTTOM w0.178: UG9.AJ46 v2(216.45,111.45)
FBA_D50: length 39.9
  IN5 w0.145: v2(208.66,141.98) 208.66,142.1 209.07,142.51 209.07,142.94 209.31,143.18 209.31,143.39 209.78,143.86 212.2,143.86 216.06,140 216.06,132.22 216.44,131.84 216.44,127.57 215.57,126.69 215.57,120.93 215.9,120.6 215.9,112.7 v2(216.45,112.15)
  BOTTOM w0.089: v2(208.66,141.98) 208.26,141.58 UG2.T11
  BOTTOM w0.178: UG9.AJ47 v2(216.45,112.15)
FBA_D51: length 33.8
  IN5 w0.145: v2(210.26,141.98) 210.65,142.37 211.45,142.37 211.47,142.35 211.98,142.35 214.72,139.61 214.72,132 215.13,131.59 215.13,127.82 214.23,126.92 214.23,120.55 214.74,120.04 214.74,115.12 215.03,114.83 215.03,113.81 215,113.78 v2(215,113.7)
  BOTTOM w0.089: v2(210.26,141.98) 209.86,141.58 UG2.T13
  BOTTOM w0.178: UG9.AK49 v2(215,113.7)
FBA_D52: length 34.3
  IN5 w0.089: v2(208.66,139.58) 209.06,139.98 211.62,139.98
  IN5 w0.145: v2(214.35,112.15) 214.05,112.45 214.05,114.64 214.17,114.76 214.17,119.72 213.53,120.36 213.53,127 214.41,127.88 214.41,131.53 213.97,131.98 213.97,138.33 212.31,139.98 211.62,139.98
  BOTTOM w0.089: UG2.N11 v2(208.66,139.58)
  BOTTOM w0.17: UG9.AM47 v2(214.35,112.15)
FBA_D53: length 32.6
  IN5 w0.089: 211.62,139.16 210.64,139.16 v2(210.26,138.78)
  IN5 w0.145: 211.62,139.16 212.18,139.16 213.27,138.07 213.27,131.63 213.71,131.19 213.71,127.96 212.84,127.08 212.84,120.1 213.6,119.34 213.6,114.96 213.74,114.82 213.74,112.06 214.4,111.4 v2(214.45,111.4)
  BOTTOM w0.089: UG2.N13 v2(210.26,138.78)
  BOTTOM w0.17: v2(214.45,111.4) 214.3,111.4 UG9.AM46
FBA_D54: length 31.2
  IN5 w0.089: 211.62,137.5 210.92,137.5 210.66,137.76 210.66,138.2 210.47,138.39 209.04,138.39 v2(208.66,138.78)
  IN5 w0.145: v2(213.05,112.85) 213.44,113.24 213.44,113.71 213.39,113.77 213.39,114.56 213.03,114.92 213.03,119.09 212.14,119.98 212.14,127.16 213.01,128.04 213.01,131.11 212.57,131.55 212.57,136.87 211.93,137.5 211.62,137.5
  BOTTOM w0.089: UG2.M11 v2(208.66,138.78)
  BOTTOM w0.17: v2(213.05,112.85) UG9.AN48
FBA_D55: length 27.5
  IN5 w0.145: v2(210.26,137.98) 210.26,137.4 211.62,136.04 211.62,134.39 211.43,134.2 211.43,132.99 211.74,132.68 211.74,131.6 212.32,131.03 212.32,128.34 211.44,127.46 211.44,119.53 212.45,118.52 212.45,115 213.05,114.4 v2(213.05,113.55)
  BOTTOM w0.089: UG2.M13 v2(210.26,137.98)
  BOTTOM w0.17: v2(213.05,113.55) UG9.AN49
FBA_D56: length 40.6
  IN1 w0.089: 213.85,114.5 213.85,112.49 213.75,112.39 213.75,110.05 v2(214.35,109.45)
  IN1 w0.145: 213.85,114.5 213.83,114.52 213.83,114.72 213.11,115.44 213.11,119.94 208.25,124.81 208.25,134.36 207.47,135.14 207.47,136 206.03,137.44 206.03,140.77 204.26,142.54 202.82,142.54 v2(202.26,141.98)
  BOTTOM w0.089: UG2.U4 202.66,142.38 v2(202.26,141.98)
  BOTTOM w0.17: UG9.AM44 v2(214.35,109.45)
FBA_D57: length 42.4
  IN1 w0.089: 214.07,114.95 214.07,112.41 213.97,112.31 213.97,111.85 214.07,111.75 214.07,110.43 v2(214.35,110.15)
  IN1 w0.145: v2(200.66,141.98) 201.06,142.38 201.71,142.38 202.31,142.98 204.71,142.98 206.61,141.08 206.61,137.71 208.16,136.16 208.16,135.38 209.05,134.49 209.05,124.79 213.66,120.17 213.66,115.59 214.07,115.19 214.07,114.95
  BOTTOM w0.089: UG2.U2 201.06,142.38 v2(200.66,141.98)
  BOTTOM w0.178: UG9.AM45 v2(214.35,110.15)
FBA_D58: length 37.8
  IN1 w0.089: 213.63,114.28 213.63,112.58 213.53,112.47 213.53,111.59 213.45,111.51 213.45,110.55 v2(213.05,110.15)
  IN1 w0.145: 213.63,114.28 212.84,115.07 212.84,119.34 207.36,124.81 207.36,134.54 205.45,136.45 205.45,140.28 204.61,141.12 203.91,141.12 v2(203.06,141.98)
  BOTTOM w0.089: UG2.T4 202.66,141.58 v2(203.06,141.98)
  BOTTOM w0.17: v2(213.05,110.15) UG9.AN45
FBA_D59: length 40.7
  IN1 w0.089: 209.92,110.48 211.21,110.48 211.27,110.53 212.73,110.53 v2(213.05,110.85)
  IN1 w0.145: v2(200.66,141.18) 200.25,140.77 200.25,136.68 200.95,135.98 202.66,135.98 202.92,135.72 202.92,134.71 203.49,134.14 203.49,129.25 203.17,128.93 203.17,124.67 207.97,119.87 207.97,118.35 210.03,116.29 210.03,113.54 209.73,113.24 209.73,110.66 209.92,110.48
  BOTTOM w0.089: UG2.T2 201.06,141.58 v2(200.66,141.18)
  BOTTOM w0.17: v2(213.05,110.85) UG9.AN46
FBA_D60: length 32.4
  IN1 w0.145: v2(212.25,112.85) 212.25,113.26 212.06,113.45 212.06,114.83 211.69,115.2 211.69,115.97 211.5,116.16 211.5,119.11 205.44,125.18 205.44,128.85 205.97,129.37 205.97,134.26 204.38,135.85 204.38,138.2 204.2,138.38 202.66,138.38 v2(202.26,138.78)
  BOTTOM w0.089: v2(202.26,138.78) 202.66,139.18 UG2.N4
  BOTTOM w0.17: v2(212.25,112.85) UG9.AR48
FBA_D61: length 35.6
  IN1 w0.089: v2(213.05,111.55) 213.33,111.83 213.33,112.56 213.43,112.66 213.43,113.75 213.08,114.1
  IN1 w0.145: v2(201.46,138.78) 201.46,138.9 201.74,139.18 204.23,139.18 204.9,138.51 204.9,136.03 206.35,134.58 206.35,125.05 212.05,119.34 212.05,118.47 212.52,118 212.52,114.92 213.08,114.36 213.08,114.1
  BOTTOM w0.089: UG2.N2 v2(201.46,138.78)
  BOTTOM w0.17: v2(213.05,111.55) UG9.AN47
FBA_D62: length 31.1
  IN1 w0.145: v2(203.06,137.98) 203.82,137.22 203.82,135.71 205.2,134.33 205.2,129.37 204.7,128.87 204.7,125.14 209.19,120.64 209.19,118.82 210.93,117.08 210.93,116.55 210.82,116.44 210.82,115.5 211.72,114.6 211.72,112.68 v2(212.25,112.15)
  BOTTOM w0.089: UG2.M4 v2(203.06,137.98)
  BOTTOM w0.17: v2(212.25,112.15) UG9.AR47
FBA_D63: length 33.3
  IN1 w0.145: v2(200.66,137.98) 200.66,137.73 201.61,136.78 202.75,136.78 203.23,136.3 203.23,134.84 203.93,134.14 203.93,124.68 208.52,120.09 208.52,118.65 208.54,118.63 208.54,118.57 210.42,116.69 210.42,115.34 211.37,114.39 211.37,111.88 211.8,111.45 v2(212.25,111.45)
  BOTTOM w0.089: v2(200.66,137.98) 201.06,138.38 UG2.M2
  BOTTOM w0.17: UG9.AR46 v2(212.25,111.45)
FBA_DBI0: length 23.6
  IN2 w0.145: v2(228.93,131.58) UG1.P2 227.92,131.98 227.72,131.79 227.72,127.89 224.71,124.88 224.71,115.02 224.5,114.81 224.5,112.45 224.8,112.15 v2(224.85,112.15)
  BOTTOM w0.089: v2(228.93,131.58) 228.53,131.98 UG1.P2
  BOTTOM w0.178: UG9.U47 v2(224.85,112.15)
FBA_DBI1: length 21
  IN2 w0.102: 220.51,127.91 220.51,131.2 v2(220.13,131.58)
  IN2 w0.145: 220.51,127.91 220.51,124.37 221.8,123.07 221.8,116.33 222.82,115.31 222.82,113.86 v2(222.94,113.74)
  BOTTOM w0.089: UG1.P13 v2(220.13,131.58)
  BOTTOM w0.102: UG9.Y48 222.45,112.79 222.78,113.12 222.78,113.58 v2(222.94,113.74)
FBA_DBI2: length 34.6
  IN2 w0.145: v2(219.36,140.36) 218.94,140.79 218.36,140.79 218.35,140.8 216.6,140.8 215.33,139.54 215.3,139.54 214.86,139.09 214.86,121.44 216.1,120.2 216.1,115.87 217.64,114.33 217.64,112.54 v2(217.25,112.15)
  BOTTOM w0.089: v2(219.36,140.36) 219.73,140 UG1.D13
  BOTTOM w0.17: UG9.AG47 v2(217.25,112.15)
FBA_DBI3: length 39.9
  IN2 w0.145: v2(220.75,113.65) 220.75,114.35 219.82,115.28 219.82,121.62 217.78,123.66 217.78,126.71 217.18,127.31 217.18,135 218.54,136.36 219.49,136.36 219.9,136.77 226.12,136.77 226.94,137.58 228.34,137.58 228.52,137.77 228.52,139.97 v2(228.93,140.38)
  BOTTOM w0.089: UG1.D2 228.53,139.98 v2(228.93,140.38)
  BOTTOM w0.102: UG9.AC48 220.35,112.79 220.68,113.12 220.68,113.58 v2(220.75,113.65)
FBA_DBI4: length 23.7
  IN2 w0.145: v2(200.66,131.58) 200.26,131.18 199.71,131.18 199.03,130.5 199.03,120.82 205.17,114.67 207.07,114.67 v2(207.35,114.95)
  BOTTOM w0.089: v2(200.66,131.58) 201.06,131.98 UG2.D2
  BOTTOM w0.178: UG9.BB51 v2(207.35,114.95)
FBA_DBI5: length 24.9
  IN2 w0.145: v2(210.26,131.64) 209.79,131.17 207.7,131.17 206.14,129.61 206.14,117.92 v2(205.84,117.62)
  BOTTOM w0.089: v2(210.26,131.64) 209.92,131.98 UG2.D13
  BOTTOM w0.102: UG9.AV50 210.17,114.27 210.17,114.77 210.36,114.96 210.36,115.62 209.05,116.93
  BOTTOM w0.178: 209.05,116.93 206.49,116.93 206.3,117.12
  BOTTOM w0.213: v2(205.84,117.62) 205.98,117.62 206.3,117.3 206.3,117.12
FBA_DBI6: length 30.8
  IN2 w0.089: v2(210.26,140.38) 210.7,139.94 211.54,139.94 211.62,139.86
  IN2 w0.145: 211.62,139.86 213.4,138.08 213.4,118.33 213.59,118.14 213.59,114.51 v2(214.45,113.65)
  BOTTOM w0.089: UG2.P13 v2(210.26,140.38)
  BOTTOM w0.102: v2(214.45,113.65) 214.4,113.6 214.4,113.12 214.05,112.77 UG9.AM48
FBA_DBI7: length 35
  IN2 w0.145: v2(210.94,118.01) 210.94,118.44 210.66,118.71 210.66,134.2 210.47,134.39 210.42,134.39 210.42,134.39 207.81,134.39 204.76,137.44 204.76,138.58 204.17,139.17 201.07,139.17 v2(200.66,139.58)
  BOTTOM w0.089: 211.6,115.48 211.67,115.55 ; v2(200.66,139.58) 201.06,139.98 UG2.P2 ; 211.31,116.42 211.31,116.61
  BOTTOM w0.102: UG9.AR49 211.6,113.6 211.6,115.48 ; 211.67,115.55 211.67,116.06 211.31,116.42
  BOTTOM w0.178: 210.94,117.12 210.94,117.11 211.31,116.73 211.31,116.61
  BOTTOM w0.213: 210.94,117.12 v2(210.94,118.01)
