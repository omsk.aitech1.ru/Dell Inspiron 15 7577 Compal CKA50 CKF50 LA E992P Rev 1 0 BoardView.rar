# Allegro board Dell_Inspiron_15_7577_Compal_CKA50_CKF50_LA_E992P_Rev_1_0_BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+5VS_KBL: length 1.1
  TOP w0.127: v2(197.77,30.74) v4(196.64,30.74)
+5VS_OUT:
  vias: v1(258.83,33.67)
+5VS_TS: length 2
  TOP w0.127: v2(94.39,50.19) 95.15,49.43 v4(95.15,48.54)
+VCC_3IN1: length 13.6
  TOP w1.016: CR5.1 20.37,41.06 v4(19.51,41.93) 17.57,41.93 17.1,42.39 JREAD1.4 ; 18.45,31.21 19.28,32.03 19.28,38.57 19.91,39.21
  vias: v2(17.77,29.96) v2(18.25,30.33)
+VCC_CORE: length 109.3
  TOP w0.203: PR5134.2 157.63,115.89 153.01,115.89 152.58,115.46 149.47,115.46 149.02,115.9 145.95,115.9 145.56,116.3 142.41,116.3 142.3,116.41 140.45,116.41 140.06,116.8 140.06,118.06 PR5124.1 ; PR5135.1 157.23,116.37 157.23,116.37 157.08,116.22 152.87,116.22 152.44,115.79 149.6,115.79 149.16,116.23 146.09,116.23 145.66,116.67 142.51,116.67 142.31,116.87 141.01,116.87 140.63,117.25 v2(140.63,117.49) ; PR5111.1 149.21,116.61 146.22,116.61 145.84,117 142.65,117 142.18,117.47
  TOP w0.254: v2(142.91,117.47) 142.18,117.47 PR5122.2 ; PR5136.1 152.81,116.73 152.25,116.17 149.84,116.17 149.33,116.68 PR5111.1 ; v2(159.11,116.73) PR5134.2 ; PR5109.2 v2(151.03,116.73) ; PR5123.1 v2(140.63,117.49) ; PR5112.1 v2(147.8,117.11)
  IN1 w0.254: v2(140.63,117.49) 141.89,117.49 142.34,117.95 149.81,117.95 v2(151.03,116.73) ; v2(147.8,117.11) 149.85,117.11 150.72,116.23 151.3,116.23 151.79,116.73 v2(159.11,116.73)
  BOTTOM w0.102: 174.8,86.31 UH1.K13 174.78,85.77 ; UH1.L14 174.3,86.41 UH1.K14 174.66,86.64 175.01,86.46 ; UH1.L14 173.64,86.36 ; UH1.L14 174.07,87.07 ; 173.59,85.76 173.75,85.76 UH1.L13 174.41,86 v2(174.53,86.12)
  BOTTOM w0.152: 163.32,86.34 UH1.AE14 ; UH1.AE14 UH1.AE13 163.28,86 163.33,86.05 ; UH1.AE14 163.32,86.96 ; UH1.W14 UH1.W13 167.79,86 167.91,86.12 ; UH1.W14 167.89,86.96 ; UH1.W14 167.89,86.34 ; UH1.W14 167.27,86.96 ; UH1.AD14 164.02,86.65 v2(164.34,86.32) ; UH1.AD14 163.61,86.96 ; UH1.AD14 163.61,86.34 ; UH1.AC14 164.67,86.65 v2(164.34,86.32) ; UH1.AC14 164.97,86.65 v2(165.29,86.32) 165.62,86 UH1.AA13 165.91,86 166.12,86.21 ; UH1.AC14 UH1.AC13 164.7,86 164.38,86.32 v2(164.34,86.32) ; UH1.AC14 164.84,87.16 ; 171.55,86.34 UH1.P14 ; UH1.P14 171.55,86.96 ; UH1.P14 170.91,86.32 ; 171.56,86 UH1.P13 ; UH1.P13 170.91,86.32 ; UH1.P13 171.15,85.91 170.41,85.91 UH1.R13 170.65,86.32 v2(170.78,86.32) 170.91,86.32 ; 168.18,86.34 UH1.V14 ; UH1.V14 168.8,86.96 ; UH1.V14 168.18,86.96 ; UH1.V14 UH1.V13 168.28,86 168.17,86.11 ; v2(164.34,86.32) 164.02,86 UH1.AD13 163.67,86 163.6,86.07
  BOTTOM w0.254: v2(159.11,116.73) 159.88,115.95 PL5103.1 ; v2(161.48,109.57) 160.72,110.33 RH197.1 ; v2(151.03,116.73) 151.03,114.67 PL5101.1
  vias: v2(142.91,115.62) v2(142.9,112.78) v2(143.5,115.62) v2(143.49,112.78) v2(144.08,115.62) v2(144.07,112.78) v2(144.67,115.62) v2(144.65,112.78) v2(145.21,115.37) v2(145.21,114.79) v2(145.21,114.2) v2(145.21,113.62) v2(145.8,115.37) v2(145.8,114.79) v2(145.8,114.2) v2(145.8,113.62) v2(146.38,115.37) v2(146.38,114.79) v2(146.38,114.2) v2(146.38,113.62) v2(146.97,115.37) v2(146.97,114.79) v2(146.97,114.2) v2(146.97,113.62) v2(147.17,106.23) v2(147.55,115.37) v2(147.55,114.79) v2(147.55,114.2) v2(147.55,113.62) v2(147.55,110.39) v2(147.68,113.03) v2(147.76,106.23) v2(148.13,115.37) v2(148.13,114.79) v2(148.13,114.2) v2(148.13,113.62) v2(148.13,110.39) v2(148.26,112.87) v2(148.34,106.22) v2(148.72,115.37) v2(148.72,114.79) v2(148.72,114.2) v2(148.72,113.62) v2(148.72,110.39) v2(148.85,112.87) v2(149,106.2) v2(149.3,110.39) v2(149.43,112.87) v2(149.65,106.2) v2(149.89,110.39) v2(150.01,112.87) v2(150.28,106.2) v2(150.47,110.39) v2(150.6,112.87) v2(151.18,112.87) v2(151.77,112.87) v2(152.35,112.87) v2(152.93,112.87) v2(153.54,115.18) v2(153.54,114.59) v2(153.54,114.01) v2(153.54,113.43) v2(153.54,112.84) v2(153.67,110.39) v2(154.13,115.18) v2(154.13,114.59) v2(154.13,114.01) v2(154.13,113.43) v2(154.13,112.84) v2(154.28,110.42) v2(154.71,115.18) v2(154.71,114.59) v2(154.71,114.01) v2(154.71,113.43) v2(154.71,112.84) v2(154.86,110.42) v2(155.3,115.18) v2(155.3,114.59) v2(155.3,114.01) v2(155.3,113.43) v2(155.3,112.84) v2(155.49,110.42) v2(155.88,115.18) v2(155.88,114.59) v2(155.88,114.01) v2(155.88,113.43) v2(155.88,112.84) v2(156.47,115.18) v2(156.47,114.59) v2(156.47,114.01) v2(156.47,113.43) v2(156.47,112.84) v2(157.05,115.18) v2(157.05,114.59) v2(157.05,114.01) v2(157.05,113.43) v2(157.05,112.84) v2(157.63,115.18) v2(157.63,114.59) v2(157.63,114.01) v2(157.63,113.43) v2(157.63,112.84) v2(159.07,113) v2(159.65,113) v2(160.24,113) v2(160.82,113) v2(161.41,113) v2(161.57,95.25) v2(161.57,94.61) v2(161.57,93.98) v2(161.57,93.21) v2(161.72,96.54) v2(161.75,95.88) v2(161.99,114.9) v2(161.99,114.32) v2(161.99,113.73) v2(161.99,113.15) v2(162.2,106.28) v2(162.34,104.49) v2(162.33,103.83) v2(162.34,103.18) v2(162.33,102.59) v2(162.34,100.58) v2(162.36,105.2) v2(162.51,105.79) v2(162.57,114.9) v2(162.57,114.32) v2(162.57,113.73) v2(162.57,113.15) v2(162.8,109.57) v2(162.78,108.16) v2(162.8,107.11) v2(162.83,106.28) v2(162.94,96.96) v2(163.15,105.74) v2(163.13,105.14) v2(163.12,104.49) v2(163.13,103.84) v2(163.12,103.22) v2(163.13,102.53) v2(163.1,100.61) v2(163.16,114.9) v2(163.16,114.32) v2(163.16,113.73) v2(163.16,113.15) v2(163.47,106.28) v2(163.48,86.31) v2(163.74,114.9) v2(163.74,114.32) v2(163.74,113.73) v2(163.74,113.15) v2(163.78,105.79) v2(163.86,105.2) v2(163.91,104.49) v2(163.88,103.83) v2(163.91,103.18) v2(163.91,102.56) v2(163.91,101.27) v2(163.91,100.58) v2(164.1,106.28) v2(164.33,114.9) v2(164.33,114.32) v2(164.33,113.73) v2(164.33,113.15) v2(164.72,103.2) v2(164.7,102.53) v2(164.7,101.23) v2(164.7,100.61) v2(164.7,99.94) v2(164.84,96.96) v2(164.95,96.36) v2(165.03,95.75) v2(165.03,95.17) v2(165.03,94.53) v2(165.03,93.9) v2(165.03,93.26) v2(165,90.04) v2(165.41,106.4) v2(165.43,105.79) v2(165.48,105.18) v2(165.49,104.49) v2(165.48,103.83) v2(165.49,103.18) v2(165.48,102.59) v2(165.48,101.22) v2(165.49,100.58) v2(165.49,88.32) v2(165.64,90.04) v2(165.74,96.9) v2(166.01,106.28) v2(166.27,105.74) v2(166.28,105.14) v2(166.27,104.52) v2(166.28,103.84) v2(166.27,103.2) v2(166.28,102.53) v2(166.27,101.9) v2(166.28,101.23) v2(166.3,100.61) v2(166.64,106.28) v2(166.68,96.96) v2(166.68,96.29) v2(166.65,95.6) v2(167.03,102.56) v2(167.05,99.94) v2(167.06,103.83) v2(167.08,103.2) v2(167.08,101.87) v2(167.06,101.24) v2(167.06,100.58) v2(167.14,86.98) v2(167.58,96.9) v2(167.85,104.49) v2(167.85,103.2) v2(167.91,106.28) v2(167.85,105.14) v2(167.85,103.84) v2(167.85,102.53) v2(168.15,105.71) v2(168.55,106.28) v2(168.64,105.14) v2(168.64,104.49) v2(168.63,103.83) v2(168.64,103.18) v2(168.63,102.56) v2(168.64,101.88) v2(168.64,100.58) v2(168.56,97.56) v2(168.59,96.88) v2(168.68,101.24) v2(168.81,105.71) v2(168.97,86.98) v2(169.12,92.35) v2(169.43,103.84) v2(169.42,103.17) v2(169.43,102.53) v2(169.42,101.88) v2(169.43,101.23) v2(169.39,100.58) v2(169.43,99.94) v2(169.39,90.52) v2(169.49,96.9) v2(169.82,106.28) v2(170.18,105.76) v2(170.21,105.14) v2(170.21,104.49) v2(170.21,103.83) v2(170.21,103.18) v2(170.23,102.56) v2(170.39,97.48) v2(170.37,96.88) v2(170.49,106.27) v2(170.82,105.79) v2(170.79,90.39) v2(170.97,105.18) v2(170.97,104.49) v2(171,103.84) v2(170.98,103.2) v2(171,102.53) v2(170.97,101.88) v2(171,101.23) v2(170.99,100.61) v2(171.58,92.35) v2(171.74,105.16) v2(171.71,86.31) v2(171.77,103.82) v2(171.76,103.2) v2(171.78,101.27) v2(173.53,87.05) v4(166.46,115.24)
+VCCGT: length 57.8
  TOP w0.254: PR5211.1 128.96,124.56 129.85,125.45 129.85,133.85 129.74,133.95 PR5221.2 130.07,134.69 130.3,134.46 130.3,133.99 130.6,133.7 v2(130.85,133.7) ; PR5222.1 127.93,134.14 128.87,133.2 PR5209.2 v2(128.23,127.1)
  BOTTOM w0.152: UH1.AN14 156.74,86.65 v2(157.06,86.32) ; UH1.AN14 156.29,86.34 ; UH1.AN14 156.29,86.96 ; UH1.AM13 UH1.AM14 ; UH1.AM13 157.39,86 v2(157.06,86.32) ; UH1.AM13 UH1.AL13 ; UH1.AM14 157.52,87.1 157.51,87.1 ; UH1.AM14 157.39,86.65 v2(157.06,86.32) ; UH1.AM14 157.7,86.47 157.97,86.47 UH1.AL13 ; 155.99,86.11 155.88,86 UH1.AP13 UH1.AP14 ; v2(149.74,86.37) 150.1,86 UH1.BA13 UH1.BA14 ; v2(149.74,86.37) 149.37,86 UH1.BB13 149.02,86 148.94,86.07 ; v2(149.74,86.37) 149.45,86.65 UH1.BB14 ; v2(149.74,86.37) 150.02,86.65 UH1.BA14 ; UH1.AW14 151.72,86.96 ; UH1.AW14 152.35,86.96 ; UH1.AW14 151.72,86.34 ; v2(157.06,86.32) 156.74,86 UH1.AN13 156.43,86 156.31,86.12 ; UH1.AU14 152.64,86.96 ; UH1.AU14 153.26,86.96 ; UH1.AU14 153.26,86.34 ; 156,86.34 UH1.AP14 ; UH1.AP14 156,86.96 ; UH1.AP14 155.38,86.96 ; 148.98,86.34 UH1.BB14 ; UH1.BB14 148.98,86.96 ; 147.11,86.14 147.25,86 UH1.BD13 147.59,86 v2(147.92,86.32) 147.59,86.65 UH1.BD14 ; UH1.BA14 150.21,87.08 150.21,87.09 ; UH1.BD14 147.15,86.96 ; UH1.BD14 147.15,86.34 ; UH1.BF14 146.24,86.96 ; UH1.BF14 146.86,86.96 ; UH1.BF14 146.24,86.34 ; UH1.BF14 146.86,86.34 ; 153.55,86.34 UH1.AT14 ; UH1.AT14 154.17,86.96 ; UH1.AT14 153.55,86.96 ; 146.86,86.31 UH1.BF13 146.24,86.31 ; 158.78,86.26 158.52,86 UH1.AL13
  BOTTOM w0.254: RH203.1 158.84,106.09 158.85,106.07 ; PL5202.1 130.25,131.44 129.83,131.85 129.83,133.44 130.09,133.7 v2(130.85,133.7) ; v2(128.23,127.1) 128.74,127.1 129.33,126.52 129.33,124.3 130.04,123.59 PL5201.1
  vias: v2(127.23,119.03) v2(127.67,119.47) v2(127.99,119.98) v2(128.37,120.42) v2(128.82,120.87) v2(129.26,121.31) v2(129.71,121.76) v2(130.1,122.28) v2(130.54,129.2) v2(130.54,128.62) v2(130.54,128.03) v2(130.54,127.45) v2(130.54,126.86) v2(130.54,126.28) v2(130.85,134.28) v2(131.13,129.2) v2(131.13,128.62) v2(131.13,128.03) v2(131.13,127.45) v2(131.13,126.86) v2(131.13,126.28) v2(131.43,134.28) v2(131.43,133.7) v2(131.71,129.2) v2(131.71,128.62) v2(131.71,128.03) v2(131.71,127.45) v2(131.71,126.86) v2(131.71,126.28) v2(132.02,134.28) v2(132.02,133.7) v2(132.3,129.2) v2(132.3,128.62) v2(132.3,128.03) v2(132.3,127.45) v2(132.3,126.86) v2(132.3,126.28) v2(132.6,134.28) v2(132.6,133.7) v2(132.88,129.2) v2(132.88,128.62) v2(132.88,128.03) v2(132.88,127.45) v2(132.88,126.86) v2(132.88,126.28) v2(132.97,123.19) v2(133,122.6) v2(133,122.01) v2(133,121.43) v2(133,120.84) v2(133.19,134.28) v2(133.19,133.7) v2(133.47,129.2) v2(133.47,128.62) v2(133.47,128.03) v2(133.47,127.45) v2(133.47,126.86) v2(133.47,126.28) v2(133.59,123.76) v2(133.58,123.18) v2(133.58,122.6) v2(133.58,122.01) v2(133.58,121.43) v2(133.58,120.84) v2(133.77,134.28) v2(134.18,123.76) v2(134.18,123.09) v2(134.18,122.51) v2(134.18,121.92) v2(134.18,121.34) v2(134.18,120.75) v2(134.74,120.93) v2(135.32,120.93) v2(135.32,120.35) v2(135.9,120.93) v2(135.9,120.35) v2(142.09,105.91) v2(142.62,106.23) v2(143.67,106.23) v2(144.23,105.16) v2(144.25,103.85) v2(144.25,106.23) v2(144.83,106.23) v2(145.02,104.49) v2(145.02,103.18) v2(145.02,102.53) v2(145.02,100.58) v2(145.42,106.23) v2(145.8,102.53) v2(145.8,101.23) v2(145.8,99.94) v2(145.8,98.52) v2(146,106.23) v2(145.99,97.92) v2(146.01,97.18) v2(145.96,89.23) v2(146.06,87.71) v2(146.59,106.23) v2(146.59,104.49) v2(146.59,103.18) v2(146.59,100.58) v2(147,86.97) v2(147.38,105.14) v2(147.38,103.84) v2(147.38,102.53) v2(147.38,101.23) v2(147.45,95.85) v2(147.36,88.61) v2(147.54,90.19) v2(147.6,92.57) v2(147.67,94.25) v2(148.17,103.18) v2(148.17,101.88) v2(148.17,100.58) v2(148.17,99.94) v2(148.83,86.96) v2(148.95,105.14) v2(148.95,103.84) v2(149.66,105.2) v2(149.74,104.49) v2(149.74,103.18) v2(149.74,101.88) v2(149.74,100.58) v2(149.82,95.56) v2(149.77,88.61) v2(150.53,102.53) v2(150.53,101.23) v2(150.53,99.94) v2(150.61,93.98) v2(151.28,105.23) v2(151.32,104.49) v2(151.32,103.18) v2(151.32,100.58) v2(152.1,105.14) v2(152.1,103.84) v2(152.1,102.53) v2(152.1,101.23) v2(152.19,88.61) v2(152.38,95.7) v2(152.49,86.97) v2(152.89,103.18) v2(152.89,101.88) v2(152.89,100.58) v2(152.9,99.96) v2(153.41,94.42) v2(153.43,93.05) v2(153.38,92.45) v2(153.57,90.19) v2(153.68,105.14) v2(153.68,103.84) v2(154.47,104.49) v2(154.47,103.18) v2(154.47,101.88) v2(154.47,100.58) v2(154.52,97.92) v2(154.6,88.61) v2(154.73,92.74) v2(154.78,93.98) v2(154.95,96.47) v2(155.25,102.53) v2(155.25,101.23) v2(155.25,99.94) v2(156.04,104.49) v2(156.04,103.18) v2(156.04,100.58) v2(156.15,86.32) v2(156.63,96.88) v2(156.83,105.14) v2(156.83,103.84) v2(156.83,102.53) v2(156.83,101.23) v2(156.81,100.6) v2(157.01,88.55) v2(157.47,95.69) v2(157.61,105.14) v2(157.62,103.18) v2(157.62,100.58) v2(158.4,104.49) v2(158.4,103.84) v2(158.4,102.53) v2(158.4,101.23) v2(158.59,94.34) v2(158.59,92.94) v2(158.59,91.46) v2(159.04,97.06) v2(159.19,103.18) v2(159.19,101.88) v2(159.19,100.58) v2(159.98,102.53) v2(159.98,101.23) v2(159.98,99.94) v4(135.99,124.2)
+VCCIO: length 40.8
  TOP w0.381: RH30.2 176.29,104.02 177.52,105.25 178.21,105.25 178.57,104.89 179.2,104.89 179.36,105.06 v2(179.36,106.14)
  TOP w0.508: v2(184.71,62.92) 184.71,61.88 v4(188.83,57.76) 191.94,54.66 197.37,54.66 198.29,55.58 RH526.1
  IN3 w0.381: v2(179.36,106.14) 179.36,106.52 178.59,107.29 175.41,107.29 173.94,105.81 173.19,105.81 172.81,105.43 172.81,99.45 173.94,98.32
  BOTTOM w0.254: UH1.AG12 161.52,85.69 v2(161.65,85.69)
  vias: v2(129.9,85.85) v2(130.33,86.24) v2(130.74,86.66) v2(131.17,87.09) v2(131.61,87.53) v2(133.14,80.36) v2(133.14,79.77) v2(133.14,79.19) v2(133.52,80.93) v2(133.72,80.36) v2(133.71,79.59) v2(134.21,80.67) v2(134.21,80.04) v2(174.47,96.42) v2(174.53,89.76) v2(174.55,97.05) v2(174.58,94.08) v2(174.63,91.54) v2(174.6,88.39) v2(176.1,92.32) v2(176.08,91.57) v2(176.1,90.75) v2(176.1,89.17) v2(176.74,92.33) v2(176.71,89.2) v2(176.69,86.82) v2(177.38,86.02) v2(182.71,65.57) v2(183.11,82.83) v2(183.24,65.9) v2(183.24,65.31) v2(183.24,64.73) v2(183.71,82.83) v2(183.82,64.75) v2(183.81,64.15) v2(184.09,63.6)
+VCCIO_PG: length 341.7
  TOP w0.127: v1(305.69,31.92) 306.07,31.54 306.93,31.54 RH103.1
  TOP w0.254: RH103.1 306.95,31.31 307.56,30.7 v2(307.95,30.7)
  IN2 w0.254: v2(124.25,62.83) 121.8,60.39 121.8,31.93 126.02,27.71 152.82,27.71 158.03,22.51 161.9,22.51 163.04,21.36 184.82,21.36 185.9,22.44 224.62,22.44 226.97,24.79 236.59,24.79 240.09,21.3 251.83,21.3 253.01,20.12 257.47,20.12 263.16,14.44 263.16,13.23 264.88,11.51 270.72,11.51 274.3,7.93 275.5,7.93 276.01,8.44 v2(276.01,8.79)
  IN5 w0.254: v2(276.01,8.79) 276.65,8.16 286.04,8.16 287.12,7.08 296.08,7.08 298.41,9.41 299.63,9.41 301.41,7.64 301.41,5.62 302.68,4.35 320.08,4.35 320.75,5.02 320.75,13.96 320.02,14.7 320.02,17.11 319.57,17.55 318.02,17.55 317.38,18.19 312.57,18.19 311.81,18.95 306.87,18.95 305.25,20.57 305.25,22.92 306.36,24.03 306.36,28.79 307.95,30.38 v2(307.95,30.7) ; v2(124.25,62.83) 124.25,82.69 130.53,88.98 130.53,98.63 125.39,103.77 125.39,104.95 v2(125.26,105.07)
  BOTTOM w0.254: PR4001.2 125.52,105.37 125.26,105.12 v2(125.26,105.07) 125.26,105.07 125,104.82 PU4000.9
+VCCIOP: length 14
  TOP w0.14: v2(128,95.48) v4(124.02,95.48)
  BOTTOM w0.254: PC4007.1 131.23,95.69 131.23,101.5 130.77,101.97 PR4004.1 129.86,101.94 PC4010.1
+VCCSA:
  vias: v2(167.15,113.3) v2(167.78,113.3) v2(168.42,113.3) v2(169.8,114.82) v2(169.8,114.24) v2(169.8,113.66) v2(173.04,98.28) v2(173.04,97.01) v2(173.09,95.32) v2(173.26,106.42) v2(173.26,93.88) v2(173.26,92.55) v2(173.38,105.13) v2(173.38,104.49) v2(173.38,103.86) v2(173.38,103.2) v2(173.39,102.53) v2(173.38,101.88) v2(173.38,101.24) v2(173.37,100.58) v2(174.07,105.2) v2(174.12,104.49) v2(174.14,100.63) v2(174.15,103.84) v2(174.17,103.2) v2(174.18,102.54) v2(174.15,101.23) v2(174.93,101.24) v2(177.24,115.05) v2(177.24,113.81) v2(177.25,113.17) v2(177.25,112.54) v2(177.94,115.05) v2(177.88,113.81) v2(177.92,113.17) v2(177.92,112.54) v2(178.51,113.81) v2(178.52,113.17) v2(178.52,112.54) v2(178.58,115.05) v2(179.15,114.62) v2(179.15,113.99) v2(179.15,113.35) v4(181.05,114.48)
+VCCST: length 300.3
  TOP w0.508: RH152.1 137.15,94.74 RH151.1 138.02,94.06 v2(138.28,93.8) ; v2(133.28,97.56) 135.16,99.44 RH144.1 ; v2(186.16,82.31) 185.1,82.31 183.72,80.93 RH164.1 ; v2(304.42,38.91) 304.42,38.12 304.01,37.71 v4(304.01,36.46) 304.01,34.13 303.67,33.78 RH97.1 RH100.1 RH98.1
  IN1 w0.508: v2(135.04,141.67) 135.04,142.7 134.45,143.28 133.4,143.28 132.5,142.38 v2(132.36,142.38) ; v2(135.04,141.67) 135.04,136.62 135.54,136.12 135.54,135.15 135.04,134.65 135.04,131.98 136.75,130.27 136.75,111.51 131.26,106.01 v2(129.64,106.01) ; v2(135.04,141.67) v2(140.6,141.67)
  IN2 w0.508: v2(215.05,75.4) 212.64,75.4 209.97,72.74 207.66,72.74 206.54,73.85 205.27,73.85 205.05,74.07 203.62,74.07 202.6,75.09 202.6,75.43 202.12,75.92 201.06,75.92 200.66,75.51 200.66,74.01 200.15,73.5 198.97,73.5 197.59,74.88 197.59,77.31 196.6,78.3 191.21,78.3 190.95,78.03 189.61,78.03 188.71,77.13 187.56,77.13 186.16,78.53 v2(186.16,82.31)
  IN3 w0.508: v2(304.42,38.91) 303.65,38.14 299.84,38.14 298.37,39.61 297.25,39.61 297.06,39.42 295.56,39.42 295.14,39.84 295.14,40.18 294.78,40.54 293.47,40.54 292.45,39.52 291.05,39.52 290.87,39.33 289,39.33 288.97,39.37 282.18,39.37 280.77,40.78 277.94,40.78 277.4,40.23 276.27,40.23 275.86,40.65 275.86,41.74 275.29,42.31 275.29,46.7 273.49,48.5 273.49,53.08 273,53.57 273,60.11 266.43,66.68 236.89,66.68 236.49,67.08 231.52,67.08 229.19,69.41 222.84,69.41 222.4,69.85 221.35,69.85 218.67,72.53 218.67,73.98 218.31,74.34 217.32,74.34 216.51,75.15 215.3,75.15 v2(215.05,75.4)
  IN4 w0.762: v2(138.28,93.8) 138.07,93.59 138.07,92.21 138.56,91.72 139.71,91.72 140.1,92.1 144.76,92.1 145.15,91.72 157.1,91.72 157.57,92.19 164.24,92.19 165.23,91.21 168.12,91.21 168.41,91.49 173.85,91.49 173.87,91.51
  IN5 w0.508: v2(138.28,93.8) 137.05,95.02 134.28,95.02 133.77,95.53 133.77,97.06 v2(133.28,97.56) 134.21,98.5 134.21,101.95 133.33,102.83 128.82,102.83 127.93,103.72 127.93,104.8 129.13,106.01 v2(129.64,106.01)
  BOTTOM w0.14: v2(133.28,97.56) 133.34,97.56 133.69,97.91 RH156.1
  BOTTOM w0.203: v2(174.6,97.87) 174.98,98.25 UH1.J28 UH1.H28 ; v2(176.1,99.43) 176.09,99.44 176.09,99.44 UH1.H30
  BOTTOM w0.508: PC5001.1 v2(132.36,142.38) ; v2(135.04,141.67) 135.84,141.67 137.07,142.9 PR5002.1 PR5001.1 ; PR5003.1 139.84,142.43 v2(140.6,141.67)
+VCCST_OUT: length 12.1
  TOP w0.508: RZ66.1 184.19,100.93 184.95,101.69 184.95,103.98 v1(184.23,104.7) 181.78,107.15 v2(181.78,108.42)
  BOTTOM w0.508: v2(181.78,108.42) 181.27,108.93 CZ28.1
+VCCSTG: length 134.5
  TOP w0.254: v2(176.5,100.49) v4(177.09,100.49) 178.9,100.49 180.8,102.39 181.76,102.39 CZ47.1 CH106.1 183.05,102 183.72,102.67 v2(183.72,102.79) ; RH56.1 136.59,100.73 135.42,100.73 133.99,99.31 v2(133.38,99.31) 133.05,99.31 132.87,99.49 132.37,99.49 131.89,99.01 131.89,97.77 133.73,95.93 v2(134.44,95.93) 134.76,96.25 134.76,96.65 135.44,97.33 136.02,97.33 136.35,97.66 RH497.1
  IN3 w0.254: 184.44,99.22 185.35,99.22 186.79,97.77 186.79,75.66 182.68,71.54 182.68,69.76 181.28,68.37 v2(181.28,67.41)
  IN4 w0.254: v2(181.28,67.41) 181.14,67.55 181.14,69.95 180.52,70.58 178.22,70.58 177.71,70.07 138.58,70.07 135.19,73.46 135.19,88.33 134.99,88.53 134.99,95.39 v2(134.44,95.93)
  BOTTOM w0.203: v2(176.5,100.49) 176.4,100.4 UH1.G30
  BOTTOM w0.254: v2(133.38,99.31) 133.63,99.06 RH165.1 ; RH496.1 v2(134.44,95.93) ; UH1.H29 175.75,99 176.1,98.65 v2(176.1,98.62)
+VCCSTG_OUT: length 0.9
  BOTTOM w0.127: 188.04,105.39 v1(188.91,105.39)
AVCC33: length 12.4
  TOP w0.127: v2(325.79,35.33) v1(325.79,34.55)
  TOP w0.508: v2(325.79,35.33) 325.95,35.49 325.95,36.66 325.49,37.11 RVGA6.2
  IN1 w0.508: v2(317.35,36.54) 325.34,36.54 325.79,36.08 v2(325.79,35.33)
GND: length 6217.1
  TOP w0.089: 263.75,86.38 CG427.2 ; v2(259.37,120.61) 259.41,120.65 ; 262.89,86.38 CG429.2 ; 261.74,92.23 CG176.2
  TOP w0.127: v4(209.81,23.66) 211.41,23.66 v2(211.45,23.7) ; v4(171.04,23.78) v2(171.82,23.78) ; v2(278.87,75.59) 278.99,75.72 v4(280.04,75.72) ; v2(102.17,54.61) 102.16,54.6 v4(102.16,53.81) ; v2(183.81,138.23) 183.05,138.23 v4(183.01,138.19) ; v2(95.28,38.75) v4(96.31,38.75) ; v4(272.11,19.54) v2(272.11,18.63) ; v2(301.77,52.99) v4(301.77,53.97) ; v2(123.03,136.91) v4(123.03,137.63)
  TOP w0.203: UE1.64 313.2,6.39 313.4,6.19 v2(313.41,6.19) ; v2(318.14,40.39) 318.64,40.39 UVGA1.24 ; UE1.100 312,24.02 v2(312.27,24.29) ; UZ1.11 UZ1.15 ; UE1.124 302.4,22.06 302.71,21.75 v2(302.71,21.62)
  TOP w0.254: v2(204.58,87.78) 205.32,87.78 CG294.2 ; CG307.2 212.71,88.64 v2(212.25,89.1) v2(212.25,89.8) ; v2(223.55,89.1) 223.55,89.01 PC6535.2 PC6536.2 ; CG196.2 223.55,106.2 v2(223.55,105.9) v2(223.55,105.2) 223.55,105.2 PC6554.2 223.55,104.48 v2(223.55,103.8) 223.55,103.09 PC6549.2 223.55,103.08 v2(223.55,102.4) 223.55,102.4 PC6559.2 223.55,101.68 v2(223.55,101) 223.55,101 PC6558.2 223.55,100.29 v2(223.55,99.6) v2(223.55,98.9) 223.55,98.9 PC6553.2 223.55,98.2 v2(223.55,97.5) 223.54,97.49 PC6504.2 223.55,96.79 v2(223.55,96.1) ; CG206.2 CG237.2 224.95,106.11 v2(224.95,105.9) v2(224.95,105.2) ; v2(210.85,103.8) 210.78,103.87 PC6520.2 ; v2(216.45,98.9) 216.45,98.4 PC6527.2 216.45,97.87 v2(216.45,97.5) 216.45,97.07 PC6528.2 216.45,96.54 v2(216.45,96.1) ; v2(215.05,95.4) 215.05,94.96 PC6518.2 215.05,94.45 v2(215.05,94) 215.05,93.56 PC6501.2 215.05,93.05 v2(215.05,92.6) 214.79,92.34 PC6500.2 214.79,91.46 v2(215.05,91.2) 215.05,90.91 PC6508.2 215.05,90.11 v2(215.05,89.8) ; v2(220.75,105.9) 220.75,106.32 CG203.2 ; CG204.2 222.15,107.06 v2(222.15,105.9) 222.15,105.11 PC6589.2 ; 270.49,5.93 266.61,5.93 266.42,6.13 U5603.5 ; v2(213.65,89.8) 213.65,90.37 PC6509.2 213.79,91.06 v2(213.65,91.2) 213.65,91.62 PC6510.2 213.65,92.2 v2(213.65,92.6) 213.65,93.02 PC6516.2 213.65,93.6 v2(213.65,94) 213.94,94.29 PC6517.2 213.94,95.11 v2(213.65,95.4) ; v2(215.05,96.1) 214.74,96.41 PC6572.2 215.05,97.11 v2(215.05,97.5) ; DT4.2 372.34,75.91 v2(372.66,76.23) ; v2(220.75,90.5) 220.91,90.34 PC6538.2 220.91,89.27 v2(220.75,89.1) 220.75,88.91 220.28,88.44 CG210.2 ; v2(219.35,101) 219.35,102.31 PC6589.2 ; v2(205.25,96.05) 205.49,96.29 CG306.2 205.95,96.36 v2(205.95,96.85) ; v2(227.05,110.75) 226.67,110.75 RG68.2 ; CG198.2 222.1,88.4 PC6536.2 ; RG22.2 206.65,80.8 v2(206.17,80.8) ; v2(372.85,72.67) 372.59,72.67 372.34,72.93 DT5.2 ; CG202.2 214.86,106.58 CG54.2 ; CG202.2 214.93,106.02 v2(215.05,105.9) ; CG202.2 CG200.2 CG201.2 ; CG197.2 213.72,107.44 213.67,107.4 CG54.2 ; CG54.2 213.65,106.55 v2(213.65,105.9) 214.31,105.24 PC6506.2 213.65,104.52 v2(213.65,104.5) v2(213.65,103.8) ; PC6540.2 217.6,88.75 v2(217.25,89.1) ; v2(212.25,91.2) 212.25,91.81 PC6546.2 212.25,92.01 v2(212.25,92.6) 212.25,93.21 PC6547.2 212.25,93.41 v2(212.25,94) 212.25,94.6 PC6548.2 212.15,95.3 v2(212.25,95.4) v2(212.25,96.1) 211.79,96.56 PC6573.2 212.25,97.25 v2(212.25,97.5) ; PC6536.2 222.15,88.54 v2(222.15,89.1) 222.15,89.44 PC6537.2 221.77,90.12 v2(222.15,90.5) v2(222.15,91.2) 222.34,91.39 PC6514.2 222.15,92.1 v2(222.15,92.6) 222.09,92.66 PC6515.2 222.15,93.37 v2(222.15,94) 222.15,94.43 PC6562.2 ; CG507.2 214.49,88.54 214.21,88.54 v2(213.65,89.1) ; CG523.2 205.77,103.33 v2(205.95,103.15) ; UE1.51 308,6.2 v2(308.14,6.06) ; PC6589.2 222.15,102.34 v2(222.15,101) ; PC6589.2 219.35,105.14 v2(219.35,105.9) 219.35,106.15 CG59.2 CG212.2 CG201.2 ; v2(212.25,105.9) 212.25,106.24 PC6503.2 211.57,106.92 CG199.2 ; v2(373.42,67.31) 373.2,67.53 372.57,67.53 DT7.2 ; v2(216.45,94) 216.56,93.89 PC6513.2 216.45,93.2 v2(216.45,92.6) 216.56,92.49 PC6505.2 216.56,91.31 v2(216.45,91.2) 216.45,90.52 PC6507.2 ; v2(224.95,89.1) 224.95,88.54 CG214.2 224.01,87.6 CG58.2 ; CG201.2 216.71,106.16 v2(216.45,105.9) 216.52,105.83 216.52,105.21 PC6522.2 216.54,104.57 v2(216.48,104.5) 216.4,104.43 v2(216.4,103.8) 216.4,102.29 CG244.2 216.45,100.76 v2(216.45,99.6) ; CZ57.2 227.46,53.03 UZ16.5 ; v2(217.85,97.45) 217.79,97.39 PC6571.2 ; PC6534.2 224.46,90.71 v2(224.95,91.2) 225.59,91.84 225.59,94.45 224.95,95.09 v2(224.95,95.4) v2(224.95,96.1) ; 270.44,6.34 267.1,6.34 266.92,6.52 U5603.6 ; v2(219.35,95.4) 219.35,94.97 PC6563.2 219.67,94.32 v2(219.35,94) 219.25,93.9 PC6512.2 219.35,93.21 v2(219.35,92.6) 219.25,92.5 PC6557.2 219.25,91.35 v2(219.4,91.2) v2(219.4,90.5) 219.4,90.14 PC6539.2 219.14,89.37 v2(219.4,89.1) 219.4,88.97 CG234.2 ; U5603.8 269.41,7.39 ; U5603.7 269.66,6.89 ; v2(225.55,112.25) 225.8,112.25 RG69.2 ; v2(210.85,89.8) 211.14,90.09 PC6555.2 210.85,90.8 v2(210.85,91.2) ; v2(373.17,70.96) 373.08,70.87 DT14.2 ; v2(214.41,85.6) 214.29,85.48 CG520.2 ; UE1.17 300.43,14.99 v2(300.46,15.01) ; PC6570.2 217.21,94.81 v2(217.85,95.45) ; v2(220.75,91.2) 220.75,91.63 PC6552.2 220.75,92.19 v2(220.75,92.6) 221.03,92.88 PC6511.2 220.75,93.59 v2(220.75,94) ; v2(313.58,16.47) 313.69,16.59 UE1.84 ; v2(212.25,103.8) 212.25,104.6 211.67,105.18 PC6502.2 ; v2(213.65,97.5) 213.65,96.88 PC6532.2 213.73,96.18 v2(213.65,96.1) ; v2(362.76,55.72) 362.44,55.4 CT48.2 ; v2(173.38,99.95) 174.24,99.09 CH204.2 ; v2(215.05,104.5) v2(215.05,103.8) ; v2(215.05,89.1) 215.05,89.09 CG213.2 ; DT6.2 v2(372.4,64.79) ; v2(234.28,136.83) 234.01,136.56 RG116.2
  TOP w0.3: v2(213.65,102.4) 213.57,102.48 213.57,103.72 v2(213.65,103.8) ; v2(210.85,89.8) v2(210.85,89.1) ; v2(215.05,89.8) v2(215.05,89.1) ; v2(217.25,89.8) v2(217.25,89.1) ; v2(216.45,96.1) v2(216.45,95.4) 216.58,95.27 216.58,94.13 v2(216.45,94) ; v2(213.65,95.4) v2(213.65,96.1) ; v2(213.65,89.8) v2(213.65,89.1) ; v2(215.05,99.6) v2(215.05,98.9) ; v2(216.45,99.6) v2(216.45,98.9) ; v2(215.05,95.4) v2(215.05,96.1) ; v2(215.05,105.9) v2(215.05,104.5) ; v2(213.65,98.9) v2(213.65,99.6)
  TOP w0.305: v2(206.57,59.43) 206.57,59.88 206.07,60.38 UG14.5 ; UC16.3 182.74,79.8 v2(183.24,80.29) ; v2(210.85,89.1) 211.05,88.91 PC6541.2 210.89,88.2 CG303.2
  TOP w0.356: v2(203.24,66.19) 203.24,65.74 203.11,65.61 CG439.2 ; RT39.2 358.29,49.17 v2(357.57,48.45) ; v2(349.2,47.85) 348.82,47.47 CT56.2 ; v2(362.05,67.07) 361.48,67.64 RT108.2 ; CT58.2 355.05,43.03 354.77,43.3 v2(353.96,43.3) ; v2(353.84,40.37) 354.78,40.37 355.04,40.63 CT54.2 CT57.2 ; v2(360.47,54.77) 360.44,54.77 360.3,54.63 RT35.2 ; RT37.2 360.17,55.4 v2(360.4,55.4) ; RT79.2 RT78.2 352.59,41.75 v2(352.46,41.62) ; CT61.2 356.41,53.25 v2(356.44,53.22) ; CT85.2 351.36,55.04 v2(351.24,55.17) ; v2(206.17,80.8) 205.62,80.8 RG24.2 ; CG246.2 222.43,61.68 222.73,61.99 v2(222.73,62.29) ; 357.71,51.3 357.6,51.4 CT78.2 ; CT79.2 354.33,53.41 353.93,53.81 353.89,53.81 v2(353.84,53.87) 353.65,53.68 RT3.2 ; CG438.2 v2(208.57,65.65) ; CG440.2 v2(213.08,77.37) ; v2(355.14,53.87) 355.02,53.99 354.92,53.99 354.88,54.02 354.77,54.02 354.75,54.04 CT60.2
  TOP w0.381: PC5610.2 151.85,97.14 152.38,96.61 v2(152.38,96.37) 152.78,96.37 PC5558.2 ; CG106.2 199.64,132.16 v2(199.86,132.38) ; QG503.4 218.73,64.11 218.34,63.72 217.78,63.72 ; PC5608.2 PC5607.2 156.1,97.14 v2(156.61,97.64) ; PC5578.2 156.32,94.72 v2(156,95.04) ; v2(170.79,89.64) 170.79,89.03 PC5538.2 ; CA3.2 336.35,23.13 336.46,23.02 v2(336.46,22.89) 336.97,23.4 CA62.2 ; CG121.2 256.44,112.36 v2(256.43,112.37) 256.4,112.4 256.4,112.99 256.71,113.31 RG117.2 ; PC5579.2 156.38,93.33 v2(156.06,93.64) ; CH124.2 152.03,86.32 v2(152.49,86.32) ; v2(357.74,54.52) 357.78,54.56 CT62.2 ; UH7.3 287.77,18.15 287.16,18.76 287.16,20.12 v2(286.86,20.42) ; v2(147.42,96.49) 147.42,96.93 147.59,97.1 PC5592.2 ; v2(216.13,57.57) 216.84,58.28 QE23.4 ; CT59.2 353.94,51.31 354.45,51.31 v2(354.49,51.27) ; CG156.2 257.74,77.78 v2(258.4,78.43) 258.4,79.04 258.1,79.34 RG58.2 ; v2(208.85,82.1) 208.7,81.95 QG23.1 ; v2(200.32,79.23) 199.69,78.6 RG91.1 ; CH210.2 179.85,82.38 v2(179.32,82.9) ; v2(223.33,58.13) 223.33,57.62 QE21.1 ; v2(207.06,137.98) 206.53,137.45 RG107.2 ; v2(221.73,133.98) 221.71,133.99 RG106.2 ; v2(314.36,26.32) 314,25.95 UE6.3 ; UG22.3 222.11,63.19 222.73,62.56 v2(222.73,62.29) ; RP39.1 340.66,44.16 v2(340.9,44.4) ; CG89.2 221.87,133.83 221.73,133.97 ; v2(147.35,89.25) 147.64,89.25 PC5565.2 ; v2(201.65,92.48) 202.3,92.48 CG47.2 ; v2(157.98,86.96) 158.13,86.82 CH119.2 ; v2(211.31,137.03) 211.46,136.88 RG109.2 ; v2(173.27,93.26) 172.8,93.26 172.59,93.48 ; v2(157.02,89.18) 157.37,89.18 PC5574.2 ; RG56.2 257.91,110.65 v2(258.03,110.77) ; v2(210.35,83.72) 210,83.37 QG23.4 ; v2(309.36,29.53) 309.65,29.82 UH14.3 ; v2(17.5,60.99) DI12.3 ; v2(154.52,97.21) 154.04,97.21 153.97,97.14 PC5600.2 ; v2(149.76,89.25) 150.06,89.25 PC5575.2 ; v2(176.07,95.53) 175.26,94.71 CH104.2 ; CG84.2 225.38,141.98 v2(225.73,141.98) ; UZ21.3 298.07,30.32 297.76,30.63 v2(297.46,30.63) ; PC18V10.2 270.68,84.48 270.12,83.92 v2(270.12,82.06) ; QG505.1 212.1,62.82 211.77,63.15 v2(211.77,63.35) 211.56,63.35 210.75,62.54 UG25.3 ; v2(256.9,94.75) 257.54,94.75 CG175.2 ; v2(204.65,85.65) 205.12,86.12 CG235.2 ; PC5596.2 149.84,96.92 v2(149.84,96.37) 150.16,96.06 PC5559.2 ; CG438.2 208.34,65.09 207.93,65.51 CG322.2 ; v2(257.25,104.6) 257.03,104.82 257.03,106.07 256.83,106.27 RG127.2 ; v2(220.93,130.78) v2(221.73,130.78) ; v2(257.92,92.8) 257.58,93.14 RG131.2 ; CT46.2 357.71,51.3 v2(357.74,51.27) ; CT48.2 361.99,55.43 CT115.2 ; PC5587.2 152.47,89.25 v2(152.18,89.25) ; v2(348.46,58) 348.91,57.56 CT83.2 ; RG54.2 230.46,134.44 229.94,134.96 ; v2(154.59,89.25) 154.88,89.25 PC5564.2 ; v2(207.06,138.78) 206.6,138.32 CG104.2 ; QE24.4 281.49,10.05 281.97,10.53 v2(281.97,10.84) ; CG86.2 222.89,138.19 v2(222.68,137.98) ; RG105.2 199.53,136.75 v2(199.61,136.83) ; v2(208.89,79.03) 209.35,79.03 209.57,79.26 UG27.3 ; CT80.2 355.21,53.8 v2(355.14,53.87) ; CG122.2 259.78,113.3 CG125.2 260.36,113.31 v2(260.43,113.24) ; v2(359.02,52.57) 359.02,53.12 RT41.2 ; v2(280.52,7.08) 280.19,7.41 QE24.1 ; QE21.4 225.91,59.54 v2(226.6,60.23) ; QG509.4 197.92,63.04 197.59,62.7 197.27,62.7 196.62,62.05 QG509.1 ; PC5534.2 166.62,87.73 v2(166.13,87.23) ; v2(157.46,96.31) 157.63,96.31 157.95,95.99 PC5570.2 ; v2(262.43,116.17) 262.45,116.14 CG124.2 ; DI9.3 v2(361.86,40.35)
  TOP w0.4: v2(221.73,133.98) 221.73,133.97 ; 229.94,134.96 v2(229.88,135.03)
  TOP w0.406: PQ6.1 51.1,27.51 51.5,27.9 v2(52.06,27.9) 52.4,28.25 PQ6.4 ; v2(205.18,64.16) 205.18,64 205.18,63.99 205.18,63.44 205.17,63.43 205.17,63.43 204.65,62.91 UG26.3 ; v2(62.86,28.83) 62.86,29.21 62.45,29.62 PD3.1 ; PR6036.2 158.41,132.49 157.77,131.85 v2(157.27,131.85) ; PQ7.1 54.95,26.68 55.17,26.46 PR33.1 ; DI7.3 v2(358.37,29.3) ; v2(200.36,64.86) 200.11,64.61 UG30.3 ; QZ13.4 v2(67.73,57.31) ; v2(221.35,57.49) 221.45,57.59 QE20.1 ; QZ13.1 v2(66.43,56.76)
  TOP w0.432: v2(55.5,27.9) 56.25,28.66 PQ7.4 ; v2(214.34,63.35) 214.34,62.88 QG504.1 ; v2(217.73,63.77) 217.78,63.72 217.78,63.12 217.43,62.77 QG503.1 ; v2(168.83,132.23) 168.14,132.93 PQ6000.1 ; v2(216.13,57.57) 215.54,56.98 QE23.1 ; QG502.1 v2(227.22,63.4) ; v2(198.89,64.1) 198.38,63.59 QG509.4 ; PQ6000.4 164.81,131.28 v2(164.06,131.28) ; QE20.4 220.15,56.81 220.66,57.32 v2(220.66,57.56) ; v2(216.38,65.12) 216.07,64.8 QG504.4 ; v2(213.4,65.16) 213.4,65.15 QG505.4
  TOP w0.457: v2(23.61,83.22) 22.52,82.13 CL33.2 ; CH52.2 293.21,29.11 v2(293.21,28.98) ; v2(359.96,71.78) 358.86,70.69 CT100.2 ; QH6.3 290.37,8.07 v2(290.37,8.79) 290.04,8.79 289.99,8.84 RTPM9.2 ; QG9.3 199.49,60.4 RG573.2 198.86,60.15 v2(198.86,59.33) ; v2(141.95,94.48) 141.87,94.41 RH183.2 140.67,94.41 RH184.2 ; CG230.2 CG235.2 ; v2(180.66,143.73) 181.2,143.18 181.2,141.54 180.24,140.58 PC6127.2 ; CG187.2 234.95,96.75 v2(234.5,96.3) ; v2(234.49,87.88) 234.66,87.88 235.37,88.59 CG184.2 ; CD4.2 CD3.2 v2(173.31,43.61) ; CG243.2 235.37,85.67 v2(235.35,85.65) ; v2(211.06,141.18) 211.97,141.18 CG102.2 ; RE152.2 227.22,56.54 227.83,56.54 v2(228.1,56.27) ; CH186.2 288.65,32.9 v2(288.19,33.37) ; v2(277.47,42.47) 277.04,42.04 CH190.2 ; v2(201.46,135.58) 201.6,135.44 RG53.2 ; CG185.2 235.31,90.94 v2(234.62,90.25) ; CG238.2 CG236.2 203.86,88.34 v2(203.85,88.35) ; PC5554.2 139.33,101.63 v2(139.17,101.47) ; CG139.2 238.81,139.06 v2(238.53,138.78)
  TOP w0.508: CG335.2 264.32,77.18 CG361.2 264.14,77.05 263.8,76.71 v2(263.2,76.71) ; CH122.2 160.52,85.84 v2(160.71,85.65) ; v2(315.76,28.98) 315.38,29.37 RVGA4.2 ; v2(332.83,7.09) 332.25,7.09 CA7.2 ; CH214.2 282.26,42.45 281.88,42.07 v2(281.88,41.39) ; CG383.2 258.73,99.89 v2(259.2,100.35) ; CZ11.2 259.41,28.86 v2(259.17,29.1) ; PR303.2 v2(84.61,40.27) ; PR302.1 83.8,44.75 v2(83.72,44.68) ; v2(265.35,30.55) 264.83,31.07 CZ12.2 ; v2(234.5,94.2) 235.31,95.01 CG186.2 ; v2(279.63,40.16) 279.73,40.26 CH191.2 ; CG140.2 241.31,138.39 241.72,137.98 v2(241.73,137.98) 240.89,137.14 RG118.2 CG337.2 ; v2(232.32,44.16) 232.32,44.16 CD23.2 ; v2(171.73,81.79) 172.67,81.79 CH128.2 ; PC5577.2 156.78,94.66 PC5578.2 ; RG129.2 CG170.2 258.4,97.71 v2(258.4,97.15) 258.02,97.15 257.49,96.62 CG172.2 ; CG221.2 v2(229.54,81.08) ; PR22.1 50.57,26 50.06,25.49 v2(50.06,25.26) 50.28,25.05 PR701.1 ; CG393.2 224.22,134.77 CG399.2 225.83,134.1 CG91.2 226.42,134.09 v2(226.53,133.98) ; v2(166.78,33.43) 167.16,33.81 CD13.2 CD14.2 ; CA36.2 323,18.44 322.82,18.26 v2(322.82,18.25) 322.82,17.96 323.21,17.58 CA37.2 ; CA30.2 335.43,20.66 v2(335.45,20.65) ; JFAN1.6 90.73,58.35 v2(89.94,59.15) ; v2(259.72,123.85) CG315.2 ; v2(259.72,123.85) 259.52,123.65 CG419.2 ; v2(259.72,123.85) 259,124.57 CG411.2 ; v2(21.25,66.07) 20.87,65.69 CI21.2 ; PC5514.2 167.75,92.12 v2(167.73,92.14) ; v2(65.76,56.29) 65.76,55.65 66.26,55.16 R5.2 ; v2(142.6,96.05) 142.81,95.84 PC5546.2 ; v2(234.5,108.9) 235.37,109.77 CG191.2 ; v2(180.57,67.4) 180.62,67.35 CH129.2 CH130.2 CH131.2 CH132.2 ; v2(200.49,55.82) 200.19,56.12 CH206.2 ; v2(291.75,27.27) 291.75,27.01 292.26,26.5 CH53.2 ; PC5036.1 131.76,135.35 v2(131.28,135.83) 131.75,136.3 PR5047.2 ; PC5101.2 149.3,127.98 149.57,128.25 149.57,130.67 ; v2(32.37,44.11) 31.55,44.11 30.99,44.67 CL15.2 CL43.2 ; CZ57.2 229.74,53.6 v2(230.91,52.43) ; CH182.2 276.1,49.15 v2(276.21,49.04) ; PC3.2 v2(55.39,57.57) ; CVGA7.2 324.98,35.94 v2(324.98,35.34) ; PR305.1 84.01,38.66 v2(84.23,38.66) ; CG384.2 206.92,65.74 207.42,66.23 v2(207.76,66.23) ; v2(30.46,63.59) 29.95,64.1 CL49.2 ; CG423.2 CG431.2 264.33,80.35 v2(264.09,80.59) ; CG375.2 207.11,129.23 v2(207.86,129.98) ; v2(299.01,25.17) 299.01,25.45 300.03,26.48 CE101.2 ; v2(258.63,105.99) 258.64,106.01 CG347.2 CG367.2 ; v2(237.73,129.98) 237.73,129.17 238.11,128.79 CG358.2 238.67,128.79 CG342.2 ; CG410.2 262.51,115.23 CG124.2 ; v2(157.1,86.98) 157.12,86.99 PC5598.2 ; v2(342.91,45.6) 342.56,45.95 RP44.1 RP40.1 ; CD20.2 191.54,33.65 v2(191.27,33.39) ; v2(283.23,29.29) 283.19,29.34 CH70.2 CH208.2 ; PC5125.1 157.77,130.6 156.83,129.66 v2(156.59,129.66) ; v2(317.19,10.29) 317.34,10.43 RE23.2 CE82.2 ; RA13.2 v2(355.36,19.85) ; CH133.2 172.28,104.49 v2(171.76,104.49) ; v2(205.25,98.15) 205.25,97.81 CG522.2 ; v2(236.2,99.25) 236.11,99.34 CG188.2 ; v2(129.74,44.24) 128.96,43.46 CD73.2 128.96,42.56 CD1.2 ; v2(95.67,61.43) 95.9,61.2 JFAN1.4 ; CG336.2 207.04,140.36 v2(207.06,140.38) ; CD76.2 125.76,35.78 v2(125.91,35.93) ; v2(234.53,132.38) 234.2,132.38 233.59,132.99 RG55.2 ; PC5557.2 154.63,105.76 v2(155.25,105.14) ; v2(170.51,87.14) 170.73,87.14 170.97,86.9 PC5537.2 ; v2(147.59,93.26) 147.25,93.26 146.75,92.75 PC5544.2 ; PR35.1 58.87,22.85 PQ9.3 60.12,22.85 60.48,23.21 60.48,24.49 v2(60.82,24.83) ; v2(173.09,94.68) 172.78,94.68 172.38,95.09 CH117.2 ; CG371.2 205.47,139.45 CG101.2 204.38,139.58 v2(203.86,139.58) ; v2(160.56,90.93) 160.57,90.94 PC5512.2 ; CG83.2 CG402.2 222.62,141.88 v2(222.53,141.98) ; PC7.2 59.36,31.91 59.83,31.44 v2(59.83,31.02) ; v2(343.68,54.2) 342.44,52.96 CP7.2 CP5.2 CP6.2 ; v2(181.28,33.38) 181,33.66 CD83.2 ; CI25.2 v2(20.23,68.29) ; RG94.1 199.86,82.15 v2(200.45,82.15) ; CG313.2 217.89,134.9 RG108.2 218.41,134.89 v2(218.53,134.78) ; v2(160.76,101.88) 160.76,101.11 PC5505.2 ; v2(150.76,145.09) 151.27,144.58 PC6009.2 ; CG409.2 v2(255.82,123.66) ; CG217.2 229.85,85.55 v2(229.15,84.85) ; CG395.2 226.06,136.26 226.29,136.49 226.29,137.25 225.73,137.81 v2(225.73,137.98) ; v2(289.15,12.66) 289.76,12.06 RH571.2 ; RVGA11.2 RVGA12.2 318.07,43.54 317.64,43.97 v2(317.13,43.97) 316.64,43.47 RVGA13.2 ; PR6038.1 165.28,137.65 165.06,137.43 v2(164.2,137.43) PC6016.1 ; v2(234.5,92.1) 235.31,92.91 CG220.2 ; PC1.2 v2(48.18,63.68) ; PR5110.1 148.68,120.61 v2(149.2,120.61) ; v2(18.35,40.32) JREAD1.3 ; v2(154.25,44.87) 154.28,44.85 CD6.2 154.28,42.73 CD77.2 ; v2(250.67,32.67) v4(250.67,33.87) 250.67,35.08 251.12,35.52 PC107.2 PR102.2 ; v2(234.5,106.8) 235.23,107.53 CG190.2 ; 38.91,35.63 40.3,37.01 PC714.2 ; 38.91,35.63 PR715.2 ; 38.91,35.63 38.91,35.72 38.57,36.06 v2(37.91,36.06) ; RP41.1 327.24,45.88 CP3.2 CP4.2 326.87,47.53 326.57,47.22 v2(326.57,46.95) ; CVGA3.2 321.17,42.84 CVGA2.1 321.67,45.21 322.45,45.99 v2(322.45,46) ; PC5601.2 153.36,87.82 153.14,88.04 153.14,88.17 152.9,88.4 PC5587.2 ; v2(170.32,33.49) 170.74,33.91 CD12.2 ; CZ108.2 278.87,64.86 v2(279.01,65) ; CD74.2 104.67,35.82 v2(105.07,36.22) ; CD84.2 224.38,44.47 v2(224.37,44.48) ; v2(82.84,38.29) 82.6,38.29 PR306.2 ; v2(263.2,81.51) 263.2,81.41 CG426.2 CG430.2 ; PC720.1 36.73,31.82 v2(36.73,31.21) ; PC108.2 255.69,37.49 v2(255.74,37.55) ; CH123.2 164.39,79.66 v2(164.21,79.84) ; PQ708.3 31.28,50.95 PR734.2 31.46,51.34 32.02,51.9 v2(32.21,51.9) ; v2(222.68,139.98) 222.79,140.09 CG87.2 CG403.2 ; CG400.2 222.53,133.78 CG89.2 ; PD1.1 v2(45.92,51.25) ; v2(166.65,92.2) 166.67,92.18 PC5513.2 ; CG189.2 234.93,100.87 v2(234.61,100.55) ; PQ2.3 v2(40.66,57.03) ; v2(89.35,58.86) 88.86,58.37 RZ40.2 ; PC5529.2 PC5518.2 164.59,87.18 v2(164.37,86.96) ; CR5.2 22.43,40.3 v2(22.87,39.86) ; v2(156.76,125.95) 156.77,125.94 PC5124.2 ; CD9.2 v2(169.46,41.43) ; CH207.2 202.03,65.36 202.03,65.18 v2(201.78,64.93) ; CD35.2 v2(244.39,44.29) ; v2(147.42,96.49) 147.42,96.48 147.17,96.48 146.91,96.23 146.9,96.23 PC5576.2 ; RH548.2 271.21,34.36 v2(271.06,34.51) ; 160.77,99.87 160.1,99.2 PC5605.2 PC5606.2 160.1,97.02 v2(160.09,97) 160.09,96.68 PC5516.2 161.08,96.71 v2(161.08,97.09) 161.1,97.12 PC5531.2 161.09,97.98 PC5535.2 161.09,99.54 160.77,99.87 ; 160.77,99.87 v2(160.77,99.91) ; v2(222.85,82.75) 222.77,82.83 CG216.2 ; v2(290.41,29.34) 290.41,30.06 290.95,30.6 CH213.2 ; PC2.2 v2(50.56,63.68) ; v2(116.42,67.58) 115.88,67.58 PC215.2 ; v2(243.96,44.78) 243.37,44.2 CD34.2 ; CD72.2 148.06,35.97 v2(148.39,36.3) ; CP24.2 CP26.2 330.82,49.95 CP47.2 330.81,49.89 330.81,48.55 v2(330.81,48.54) ; v2(159.19,103.84) 160.2,103.84 PC5503.2 PC5517.2 ; JREAD1.12 14.07,30.7 v2(13.31,29.94) ; v2(288.07,29.99) 288.13,29.92 CH187.2 ; v2(328.37,17.36) 327.91,17.36 DA2.1 ; v2(326.87,35.26) 326.87,36.66 325.53,38 RVGA5.2 ; v2(134.1,129.71) 137.24,129.71 137.61,129.34 138.62,129.34 139.09,129.81 PC5030.2 ; CH51.1 293.79,30.81 294.3,31.32 v2(294.3,31.78) ; RH211.2 v2(109.01,58.26) ; v2(167.83,99.94) 167.73,99.84 PC5528.2 ; RT5.2 357.75,54.51 v2(357.74,54.52) ; CD39.2 282.39,22.86 CD41.2 283.2,22.9 v2(284.24,21.86) ; v2(28.23,63.59) 27.91,63.91 CL57.2 ; v2(180.77,103.12) 181.95,103.12 CZ47.2 CH106.2 ; v2(336.02,38.71) CP11.2 ; CG359.2 241.86,134.64 v2(242.53,133.98) ; v2(201.18,87.93) 201.18,87.5 CG511.1 CG510.2 ; PC5584.2 PC5573.2 156.51,90.66 v2(156.19,90.98) ; PC5590.2 PC5610.2 ; v2(89.96,67.34) 90.42,67.8 JFAN1.5 ; v2(169.15,45.56) 169.14,45.56 169.52,45.18 CD10.2 ; PC5547.2 151.07,92.98 v2(150.65,92.98) ; PC5547.2 152.05,92 PC5580.2 ; PC5547.2 152.32,93.39 PC5561.2 ; v2(260.4,81.36) 260.09,81.05 CG351.2 ; v2(147.92,86.97) 147.64,87.25 PC5609.2 ; CG354.2 260.44,124.43 CG381.2 260.52,125.66 260.47,125.72 CG418.2 260.47,127.71 v2(260.48,127.72) ; v2(203.06,133.98) 203.1,134.02 CG105.2 CG346.2 ; RH112.2 292.63,41.58 292.3,41.91 v2(292.3,42.43) ; v2(256.8,83.91) 256.93,83.91 CG155.2 ; v2(63.84,25.68) 64.25,26.09 PQ5.3 ; v2(33.43,48.86) 33.74,49.17 PQ8.3 ; CD24.2 239.5,43.93 v2(239.1,44.33) ; v2(355.77,5.4) DA5.1 ; v2(242.38,23.61) 242.38,23.59 242.43,23.54 CZ102.2 ; PC5583.2 172.59,93.48 CH136.2 ; CD15.2 170.92,35.91 v2(170.03,36.79) ; v2(234.68,79.34) 234.54,79.2 CG225.2 ; v2(218.42,136.85) 218.69,137.12 CG398.2 ; CD80.2 207.36,35.21 206.74,35.83 v2(206.74,36.48) ; v2(241.73,141.98) 241.67,142.04 CG137.2 ; CG296.2 205.52,99.79 205.34,99.97 205.34,100.16 v2(205.25,100.25) ; v2(263.06,32.92) 262.94,32.81 UZ1.15 ; v2(163.77,143.12) 163.3,142.65 PC6014.2 ; v2(223.11,36.03) 223.07,35.99 CD29.2 ; v2(114.59,118.32) 114.89,118.32 PC5200.1 ; v2(169.24,79.18) 168.86,79.18 168.77,79.09 CH126.2 ; CA9.2 v2(337.03,17.24) ; CG223.2 235.37,112.83 v2(235.35,112.85) ; CD16.2 CD17.2 166.82,45.21 v2(166.54,45.49) ; v2(36.36,51.43) PC14.2 ; PC5572.2 PC5579.2 ; PC5554.2 141.75,101.63 PC5548.2 ; CH127.2 172.45,85.2 v2(172.61,85.03) ; v2(92.37,52.73) 91.92,52.73 91.78,52.87 CV576.2 CZ41.2 ; RH109.2 297.5,38.89 v2(297.45,38.94) 297.16,38.94 296.65,38.43 CH202.2 ; v2(79.03,39.4) 78.78,39.4 77.82,40.36 PC315.2 ; v2(269.22,40.03) RH552.2 RH554.2 ; PC5581.2 172.67,97.65 v2(173.04,97.65) ; PC6000.1 v2(151.56,136.6) ; v2(31.66,64.34) CL54.2 ; 149.57,130.67 150.27,130.67 PC5100.1 ; 149.57,130.67 149.14,130.67 148.63,131.18 v2(148.63,131.22) ; v2(161.39,90.93) 161.41,90.91 HT1.2 CTH2.2 ; CH120.2 154.48,80.1 v2(154.15,80.42) ; v2(225.73,140.36) 225.59,140.36 225.08,139.85 CG360.2 CG350.2 ; CG176.2 261.74,93.01 v2(261.6,93.15) ; v2(343.7,41.11) 343.45,41.11 342.69,41.87 RN4.2 ; PR802.1 233.55,56.85 v2(233.5,56.8) ; PC5542.2 147.17,90.82 v2(147.54,90.82) ; RVGA10.1 315.3,37.07 315.56,36.82 v2(315.56,36.5) ; CH203.2 289.83,35.44 v2(289.6,35.21) ; v2(189.4,66.14) CH205.2 ; CH188.2 291.75,39.9 291.48,39.63 v2(291.48,38.87) ; CH200.2 290.32,34.18 v2(290.57,34.18) ; v2(201.46,142.78) 201.64,142.96 CG328.2 ; v2(254.4,101.15) 254.42,101.13 CG174.2 ; v2(273.09,29.54) 273.09,29.94 272.89,30.15 CH192.2 ; v2(229.46,44.54) 229.07,44.15 CD21.2 ; CH111.2 171.37,99.2 PC5524.2 PC5520.2 171.28,96.84 v2(171.26,96.83) ; v2(261.86,127.7) 261.46,127.3 CG365.2 CG374.2 CG376.2 ; v2(254.4,82.31) 254.4,82.31 CG433.2 ; PR29.2 36.48,46.27 37.2,46.27 v2(37.33,46.4) ; CG355.2 241,128.79 CG103.2 242.44,129.26 v2(242.53,129.18) ; PC5604.2 153.77,97.97 153.77,97.25 PC5600.2 ; v2(234.56,104.69) 235.31,103.94 CG219.2 ; PC5511.2 170.16,92.26 v2(170.14,92.27) ; CD87.2 180.2,34.59 v2(180.2,33.39) ; v2(257.48,109.02) 257.29,108.83 CG405.2 257.27,108.19 RG57.2 ; CI31.2 v2(357.73,22.95) ; CG343.2 262.98,99.8 v2(262.41,100.37) 262.41,100.27 261.86,99.72 CG407.2 ; v2(128.41,139.73) 128.73,140.05 PC5005.1 129.16,140.07 PC5007.1 129.15,140.97 PR5013.1 130.04,141.91 PC5006.1 ; CC298.2 178.86,79.33 v2(179.04,79.52) ; PC5504.2 168,89.8 PC5530.2 167.99,90.16 v2(168.3,90.47) ; RH209.2 114.33,57.37 v2(114.53,57.18) ; v2(204.7,36.1) 205.19,35.6 CD97.2 ; CH184.2 284.39,46.49 284.39,47.47 v2(284.8,47.88) ; CH176.2 282.51,33.44 v2(282.58,33.51) ; CD85.2 212.76,44.4 213.11,44.74 v2(213.63,44.74) ; CG417.2 256.85,98.83 CG415.2 257.65,100.13 CG377.2 CG126.2 258.36,101.12 v2(258.4,101.15) ; v2(58.01,30.67) 57.87,30.67 PR23.2 ; JREAD1.6 16.68,47.82 v2(15.94,47.08) ; v2(262.56,88.54) 262.44,88.43 CG154.2 263.25,87.78 263.75,87.29 CG160.2 263.75,86.38 ; PR26.2 26.25,35.96 v2(25.66,35.96) ; v2(225.55,83.55) 225.59,83.59 CG224.2 ; PC8.2 59.16,32.86 59.52,33.22 59.52,34.15 v2(59.35,34.32) ; v2(117.15,128.3) 117.86,128.3 PC5212.1 ; CP28.2 338.43,38.59 v2(337.64,39.37) ; v2(27.8,62.98) 26.96,63.82 CL56.2 ; v2(257.6,85.5) 257.62,85.48 RG130.2 ; v2(53.52,30.97) PC13.2 ; CE86.2 RE27.1 315.06,26.33 314.38,26.33 v2(314.36,26.32) ; JFAN2.5 317.41,45.2 v2(316.34,44.13) ; CG222.2 220.73,82.83 v2(220.75,82.85) ; v2(176.72,93.14) 175.85,93.14 175.45,93.53 CH103.2 ; CG334.2 264.4,93.42 CG349.2 263.88,93.67 263.36,93.15 v2(263.2,93.15) 263.52,92.83 CG171.2 ; v2(221.84,36.03) 222.05,35.82 RH210.2 ; CP12.2 334.11,51.4 v2(334.3,51.59) ; v2(262.4,78.31) 262.51,78.42 CG153.2 ; v2(237.73,133.97) 237.73,133.98 237.96,134.21 237.96,134.58 CG338.2 CG141.2 ; PC115.2 v2(255.69,39.33) ; v2(297.53,34.09) 297.11,34.51 CH212.2 296.51,34.36 RH13.1 296.51,32.99 296.38,32.86 RH581.1 ; v2(218.66,82.16) 218.28,82.54 CG228.2 ; CD22.2 215.37,35.14 216.19,35.97 216.19,35.99 v2(216.2,35.99) ; CG416.2 256.42,113.96 RG117.2 ; DA6.1 v2(362.88,18.7) ; v2(260.8,78.31) 260.78,78.33 260.78,78.96 260.33,79.4 CG435.2 ; v2(284.79,34.46) 284.93,34.32 285.4,34.32 CH173.2 CH80.2 ; PC5560.2 PC5558.2 ; RG95.1 v2(203.82,76.79) ; PR5.1 v2(41.96,52.7) ; CH102.2 175.02,90.87 v2(174.5,90.34) ; v2(23.98,39.97) 24,40 CL21.2 ; v2(171.77,101.89) 172.3,102.42 CH135.2 ; CA27.2 v2(336.91,20.28) ; CP13.2 CP14.2 338.13,50.88 338.31,50.69 v2(338.68,50.69) ; CV577.2 93.31,53.43 93.77,53.89 v2(93.77,54.26) ; v2(336.75,14.86) CA25.2 ; CG366.2 261.22,107.49 v2(261.31,107.58) 261.25,107.64 CG408.2 ; v2(350.69,20.98) CA15.1 ; PC100.2 v2(257.16,50.14) ; v2(265.15,96.28) 265.47,95.96 CG344.2 ; CL44.2 25.01,46.66 v2(25.21,46.45) ; CG317.2 258.39,87.02 v2(258.39,86.13) ; v2(111.04,63.27) 111.05,63.26 PC212.2 111.84,63.2 PR208.2 ; v2(203.06,131.6) 203.19,131.6 203.8,132.2 CG368.2 ; CL41.2 22.01,63.72 v2(21.78,63.49) ; CD81.2 237.22,33.73 v2(237.53,33.42) ; R4.2 v2(68.01,59.8) ; v2(35.79,31.19) 35.99,31.4 PC722.2 ; v2(258.8,81.36) 258.17,80.73 RG128.2 ; CG100.2 203.33,130.25 v2(203.06,129.98) ; v2(316.32,53.5) 316.18,53.5 314.49,51.8 JFAN2.4 ; v2(279.75,34.64) 280.38,35.26 RH127.2 ; v2(147.67,94.89) 147.23,94.89 PC5543.2 ; CG391.2 222.59,130.71 CG88.2 221.77,130.82 v2(221.73,130.78) ; v2(347.38,5.36) RA9.2 ; v2(324.12,44.36) 323.57,43.82 CVGA14.2 324,43.09 CVGA15.2 ; PR804.2 v2(239.27,52.9) ; v2(20.61,67.66) 20.17,67.21 CI26.2 ; PC102.2 PC101.2 247.23,44.68 v2(247.56,44.35) ; CG314.2 211.4,130.77 v2(211.17,130.77) ; CD96.2 145.62,35.45 v2(145.62,36.33) ; v2(327.19,40.35) 327.19,40.68 327.5,40.99 RP32.2 CP27.2 ; v2(260,93.15) 259.97,93.12 CG119.2 ; v2(85.32,46.45) 85.32,46.45 PR304.1 ; PR6070.1 v2(151.99,133.57) ; CE62.2 318.62,16.79 v2(319.13,16.28) 318.69,15.84 RE21.2 ; v2(169.87,87) 169.69,87.18 PC5533.2 169.77,87.76 169.77,88.84 PC5532.2 ; PC5599.2 PC5603.2 158.22,97.05 158.22,96.04 PC5570.2 ; RP42.1 325.67,53.43 v2(325.41,53.69) ; CE102.2 303.66,26.48 304.14,26.95 v2(304.14,27.84) ; CG325.2 CG340.2 237.76,131.61 v2(237.73,131.58) ; v2(22.45,63.22) 22.96,63.73 CL55.2 ; CN6.2 342,32.59 CN7.2 v2(340.67,32.59) ; v2(89.7,54.66) 89.19,54.15 UZ8.2 ; RG101.2 203.39,82.99 v2(203.17,82.77) ; CZ44.2 CV583.2 CV582.2 286.3,64.87 CV584.2 286.49,66 287,66.51 v2(287,66.89) ; v2(41.26,36.88) 41.78,36.36 PC709.2 PC708.2 ; CE103.2 292.99,17.96 v2(292.77,17.74) ; v2(200.42,77.69) 200.88,77.69 RG90.1 ; CN22.2 270.65,13.05 271.2,12.5 v2(271.2,9.74) ; v2(254.95,123.66) CG370.2 CG413.2 ; CG118.2 262.39,121.93 CG120.2 262.83,120.62 v2(262.83,120.37) ; PC800.2 234.09,54.94 PR809.2 v2(232.84,54.07) ; v2(169.88,119.28) PC5232.2 ; DV12.1 289.73,57.94 v2(288.77,56.99) ; v2(237.74,137.99) 237.74,137.97 237.89,137.81 CG401.2 237.96,137.31 CG396.2 ; v2(288.69,43.94) 288.88,43.94 CH82.2 ; CD71.2 115.36,35.98 v2(115.58,36.2) ; UE3.1 215.26,143.16 v2(215.27,143.15) ; CD78.2 159.42,33.64 159.11,33.32 v2(159.11,33.3) ; v2(260,97.15) 259.94,97.21 CG356.2 259.94,98.14 259.43,98.65 CG173.2 ; PC5597.2 158.96,88.41 v2(158.94,88.42) ; v2(152.07,138.78) 152.26,138.59 PR6013.1 ; RG119.2 259.65,120.89 259.41,120.65 ; CD19.2 202.21,35.69 v2(202.57,36.06) ; v2(226.23,33.41) 226.23,34.05 CD82.2 ; PC300.2 86.07,43.15 v2(86.07,43.85) ; CT116.2 CT115.2 ; CD79.2 163.98,44.63 163.64,44.98 v2(163.27,44.98) ; v2(176.74,97.04) 176.71,97.07 176.7,97.07 176.64,97.13 CH110.2 ; v2(139.06,102.7) 138.94,102.58 PC5556.2 PC5553.2 ; v2(165.29,118.66) 165.42,118.79 PR5231.1 ; 188.76,43.46 188.76,44.13 v2(189.07,44.44) ; CD70.2 144.06,41.43 143.42,40.8 v2(142.79,40.8) ; PC18V11.2 267.31,78.51 v2(265.91,78.51) ; PC5595.2 PC5596.2 ; CG227.2 v2(233.25,80.05) ; v2(239.19,140.18) 239.24,140.23 CG345.2 CG135.2 ; CG123.2 262.21,108.99 v2(262.03,109.17) ; CVGA6.1 CVGA5.2 315.43,39.46 v2(315,39.46) ; CG353.2 CG341.2 205.77,131.6 206.17,131.99 CG348.2 207.1,131.99 207.51,131.58 v2(207.86,131.58) ; v2(77.45,39.59) 77.09,39.59 76.72,39.22 76.72,35.47 PC306.2 PC305.2 ; v2(227.04,33.42) 227.24,33.62 CD25.2 ; v2(20.87,66.77) 20.07,65.97 CI27.2 ; v2(155.23,86.32) 155.26,86.35 PC5602.2 ; CG378.2 261.21,98.65 261.78,98.08 CG414.2 261.78,97.84 262.04,97.58 262.04,97.56 262.23,97.37 262.23,97.31 262.29,97.25 262.37,97.25 262.4,97.22 v2(262.4,97.15) ; RZ71.2 v2(298.59,27.28) ; v2(226.53,129.98) 226.51,130 CG90.2 CG394.2 224.43,130 223.6,130.82 CG397.2 ; CG86.2 223.38,138.11 CG373.2 223.39,137.13 CG380.2 ; v2(326.62,49.62) 326.85,49.85 CP29.2 ; CG392.2 225.87,132.36 v2(226.53,132.36) ; CG385.2 CG323.2 RH518.2 v2(211.09,57.81) ; v2(293.68,38.85) 294.34,38.85 295.38,37.81 CH201.2 ; v2(338.96,39.38) 338.43,39.91 CP8.2 ; v2(33.25,45.05) 33.11,44.91 PR725.2 PC724.2 ; 262.89,86.38 262.89,86.69 v2(262.62,86.96) ; CA26.2 CA62.2 ; v2(252.8,92.98) 252.8,92.52 253.26,92.05 CG318.2 ; CE18.2 262.42,29.39 v2(262.05,29.02) ; PR6057.1 152.4,141.25 152.11,140.96 v2(152.11,140.13) ; PC5020.2 v2(143.8,135.45) ; v2(357.35,5.43) RA12.2 ; RA15.2 v2(354.24,24.41) ; v2(53.85,25.3) 53.85,25.57 54.41,26.13 PR33.1 ; CH183.2 282.23,44.29 v2(281.85,44.67) ; v2(165.5,99.94) 165.5,99.13 PC5509.2 ; CG442.2 226.88,59.95 v2(226.6,60.23) ; CH112.2 172.61,89.7 v2(173.18,90.27) 172.5,90.95 CH114.2 ; CG432.2 260.92,86.69 v2(260.78,86.83) 260.65,86.96 CG424.2 ; RH560.2 279.06,45.12 v2(279.06,44.8) ; PC201.2 v2(100.92,72.16) ; CG226.2 v2(231.63,79.78) ; PC209.1 114.23,72.28 v2(113.83,72.68) ; CH121.2 152.38,81.89 v2(152.48,81.78) ; PC5201.2 120.04,115.99 v2(120.04,116.59) ; v2(265.22,80.34) CG428.2 ; v2(244.25,36.6) 244.77,36.09 CD32.2 ; CD26.2 196.64,43.54 v2(197.3,44.21) ; CI11.2 v2(357.61,24.73) ; CA10.1 v2(337.1,11.78) ; CE17.2 217.29,141.94 v2(217.91,141.32) ; v2(274.72,52.49) 274.4,52.8 CH181.2 ; CH189.2 292.46,34.95 v2(292.3,35.11) ; v2(15.22,54.76) 15.3,54.83 JREAD1.13 ; PC806.2 241.31,62.95 PC807.2 v2(241.31,61.12) ; v2(228.61,51.02) 228.49,51.15 UZ16.9 ; CG218.2 230.1,82.67 v2(229.65,82.22) ; v2(204.42,59.14) 204.42,59.15 204.42,59.32 204.41,59.32 204.41,59.74 CG487.2 ; v2(207.86,133.18) 207.66,132.98 CG330.2 CG357.2 ; PC5013.2 145.78,140.61 v2(145.77,140.62) ; v2(176.71,87.6) 176.48,87.37 RH516.2 ; UA1.2 337.15,8.92 337.24,8.83 v2(337.34,8.83) ; PC4.2 v2(55.41,56.62) ; CH125.2 164.27,85.17 v2(164.38,85.06) ; v2(238.53,141.98) 238.59,142.04 CG136.2 ; v2(228.13,129.18) 228.13,129.15 227.57,128.59 226.88,128.59 226.41,129.06 CG85.2 ; CE76.2 296.44,10.87 295.83,11.48 v2(295.83,12.73) ; CD7.2 111.74,43.35 CD2.2 111.18,44.48 v2(110.95,44.71) ; v2(320.84,14.82) 321.54,15.52 CE89.2 ; v2(163.27,44.32) 163.27,43.17 CD5.2 ; CH124.2 151.45,86.23 PC5593.2 ; v2(313.03,36.54) 312.84,36.35 CVGA8.2 ; SW5.4 v2(279.62,15.14) ; v2(28.84,42.56) 28.84,41.82 29.11,41.56 PC723.1 ; DA3.1 v2(325.65,22.35) ; v2(221.53,55.49) 221.57,55.46 CZ49.2 ; CG412.2 258.72,126.44 v2(258.72,126.44) ; CG329.2 204.37,142.48 v2(203.86,141.98) ; v2(39.83,41.68) 39.98,41.53 39.98,40.8 PC715.1 ; PC5555.2 143.49,101.28 v2(143.44,101.23) ; v2(241.73,51.9) 241.19,51.35 PC813.2 239,51.35 PQ802.3 ; v2(203.96,137.98) 204.64,137.29 CG363.2 CG331.2 CG332.2 ; CH180.2 274.46,50.05 v2(274.6,50.2) ; v2(163.83,96.95) 163.85,96.97 PC5536.2 PC5519.2 ; v2(243.69,33.3) 243.69,33.93 CD90.2 ; PC204.2 v2(101.32,71.12) ; PC5582.2 172.67,96.38 v2(173.04,96.38) ; PC105.2 v2(254.67,50.14) ; v2(25.34,63.39) 24.93,63.79 CL53.2 ; v2(143.07,36.02) 143.07,35.68 CD75.2 ; v2(149.71,86.98) 149.61,87.07 PC5594.2 ; v2(265.88,81.19) 265.7,81.37 CG434.2 CG425.2 264.93,83.19 CG158.2 CG159.2 ; v2(211.11,128.81) 211.42,129.11 CG327.2 ; v2(139.42,125.79) 136.2,125.79 PC5113.2 ; CG55.2 217.13,80 v2(216.52,80) ; CG372.2 241.02,131.61 241.34,131.93 CG352.2 241.96,131.93 242.31,131.58 v2(242.53,131.58) ; v2(28.53,40.07) 28.53,40.1 29.03,40.6 PC725.1 PR728.1 ; PR21.1 v2(67.41,29.53) ; v2(342.42,9.18) 342.91,9.67 RA33.2 ; CD8.2 122.34,44.16 v2(122.29,44.21) ; v2(263.64,88.99) 263.71,89.06 CG379.2 CG157.2 ; CA8.2 v2(336.74,16.13) ; v2(307.67,50.96) CE100.2 ; CA28.2 v2(337.03,18.19) ; PC5562.2 156.73,91.98 PC5563.2 156.69,91.99 v2(156.06,92.62) ; PC316.2 v2(86.4,48.72) ; CE99.2 102.06,62.46 v2(101.68,62.08) ; PC5211.2 v2(114.9,125.89) ; CD36.2 282.22,19.08 v2(282.48,19.33) ; v2(333.53,38.71) CP10.2 CP9.2 ; v2(24.54,63.2) 23.91,63.82 CL52.2 ; v2(246.67,44.35) 246.1,44.35 245.59,43.84 CD28.2 CD27.2 245.89,41.9 245.89,41.1 CD30.2 CD31.2 ; PC5571.2 151.8,94.71 PC5549.2 151.13,94.47 v2(150.71,94.89) ; v2(218.42,33.37) 218.54,33.24 RH212.2 ; RH95.1 v2(194.48,55.89) ; CA39.2 323.32,21.9 v2(322.87,22.34) 323.29,22.76 CA38.2 ; v2(309.36,29.53) 309.31,29.58 RH94.2 ; CR6.2 v2(21.83,38.39) ; CG161.2 261.74,90.57 CG326.2 CG339.2 261.74,92.23 ; PC5515.2 170.2,89.96 170.52,89.64 v2(170.79,89.64) ; PC5541.2 PC5545.2 151.22,90.4 150.8,90.82 v2(150.52,90.82) ; v2(115.7,62.97) PC216.2 ; v2(282.36,46) 282.44,46.09 CH185.2 ; v2(195.57,112.8) 196.46,112.8 PC6521.2 ; RG557.2 v2(207.49,77.55) ; v2(314.36,28.92) 313.92,28.48 CE85.2 ; v2(215.45,79.2) 215.33,79.08 CG240.2 ; PC205.2 v2(100.37,71.12) ; v2(316.59,33.49) CVGA1.1 ; PD4.1 v2(62.35,25.71) ; PC5591.2 PC5592.2 ; v2(208.66,138.01) 208.66,137.6 208.96,137.3 CG369.2 ; JFAN2.6 v2(318.38,53.5) ; PR5048.1 v2(133.97,130.84) ; CN19.2 263.99,11.13 v2(263.49,11.62) ; v2(242.53,133.18) 242.28,133.18 241.89,132.79 CG333.2 CG362.2 CG382.2 CG138.2 ; CE8.2 321.41,20.76 v2(321.2,20.97) ; v2(340.17,42.51) CP25.2
  GND1 w0.254: 14.09,61.25 JUSB3.11 ; JUSB3.11 16.75,61.25 ; JUSB3.11 14.09,60.42 ; JUSB3.11 16.75,60.42 ; JUSB3.11 14.09,62.08 ; JUSB3.11 16.75,62.08 ; JUSB3.11 15.42,62.08 ; JUSB3.11 15.42,60.42 ; H5.1 73.42,61.08 ; H5.1 71.9,60.52 ; H5.1 74.94,60.52 ; H5.1 73.42,56.92 ; H5.1 74.94,57.48 ; H5.1 75.5,59 ; H5.1 71.34,59 ; H5.1 71.9,57.48 ; 375.68,118.83 JCRT1.10 ; JCRT1.10 376.72,118.83 ; JCRT1.10 375.68,117.8 ; JCRT1.10 376.72,117.8 ; JCRT1.10 376.86,118.32 ; JCRT1.10 375.54,118.32 ; 375.32,66.03 JUSBC1.1 ; JUSBC1.1 377.78,66.03 ; JUSBC1.1 375.32,66.81 ; JUSBC1.1 377.78,65.26 ; JUSBC1.1 376.55,65.26 ; JUSBC1.1 377.78,66.81 ; JUSBC1.1 375.32,65.26 ; JHDMI1.22 371.65,100.83 ; JHDMI1.22 370.32,99.85 ; JHDMI1.22 370.32,100.83 ; JHDMI1.22 372.98,98.87 ; JHDMI1.22 370.32,98.87 ; JHDMI1.22 372.98,99.85 ; JHDMI1.22 371.65,98.87 ; JHDMI1.22 372.98,100.83 ; 186.46,72.7 HCPU3.1 ; HCPU3.1 190.42,74.37 ; HCPU3.1 188.75,74.99 ; HCPU3.1 188.75,70.41 ; HCPU3.1 187.08,71.03 ; HCPU3.1 190.42,71.03 ; HCPU3.1 187.08,74.37 ; HCPU3.1 191.04,72.7 ; H17.1 363.59,10.34 ; H17.1 360.42,9 ; H17.1 364.08,9 ; H17.1 363.59,7.66 ; H17.1 360.91,7.66 ; H17.1 362.25,7.17 ; 9.37,82.27 JLAN.9 ; JLAN.9 9.37,80.93 ; JLAN.9 11.73,82.27 ; JLAN.9 11.73,80.93 ; JLAN.9 10.55,82.27 ; JLAN.9 9.37,81.6 ; JLAN.9 10.55,80.93 ; JLAN.9 11.73,81.6 ; JUSB1.13 377.01,56.9 ; JUSB1.13 375.83,57.73 ; JUSB1.13 374.65,57.73 ; JUSB1.13 374.65,56.9 ; JUSB1.13 377.01,57.73 ; JCRT1.17 376.3,112.56 ; JCRT1.17 374.5,112.56 ; JCRT1.17 378.1,112.56 ; JCRT1.17 378.1,111.7 ; JCRT1.17 376.3,110.84 ; JCRT1.17 378.1,110.84 ; JCRT1.17 374.5,111.7 ; JCRT1.17 374.5,110.84 ; JUSB1.11 367.91,54.77 ; JUSB1.11 365.25,55.6 ; JUSB1.11 367.91,56.43 ; JUSB1.11 366.58,56.43 ; JUSB1.11 365.25,56.43 ; JUSB1.11 365.25,54.77 ; JUSB1.11 367.91,55.6 ; JUSB1.11 366.58,54.77 ; H1.1 8.74,104.64 ; H1.1 5.57,103.3 ; H1.1 6.06,101.96 ; H1.1 7.4,101.47 ; H1.1 8.74,101.96 ; H1.1 7.4,105.13 ; H1.1 6.06,104.64 ; H1.1 9.23,103.3 ; JLAN.11 2.75,99.07 ; JLAN.11 3.93,97.73 ; JLAN.11 2.75,97.73 ; JLAN.11 1.57,97.73 ; JLAN.11 3.93,98.4 ; JLAN.11 1.57,99.07 ; JLAN.11 1.57,98.4 ; JLAN.11 3.93,99.07 ; 356.16,81.24 H15.1 ; H15.1 358.84,81.24 ; H15.1 359.33,79.9 ; H15.1 356.16,78.56 ; H15.1 357.5,81.73 ; H15.1 357.5,78.07 ; H15.1 355.67,79.9 ; H15.1 358.84,78.56 ; 117.2,135.47 H7.1 ; H7.1 115.86,138.64 ; H7.1 115.86,135.96 ; H7.1 118.54,135.96 ; H7.1 117.2,139.13 ; H7.1 115.37,137.3 ; H7.1 119.03,137.3 ; H7.1 118.54,138.64 ; 375.83,19.57 JUSB2.12 ; JUSB2.12 377.01,19.57 ; JUSB2.12 374.65,20.4 ; JUSB2.12 377.01,20.4 ; JUSB2.12 374.65,19.57 ; JREAD1.14 7.58,29.83 ; JREAD1.14 7.58,29.05 ; JREAD1.14 7.58,28.28 ; JREAD1.14 5.45,29.83 ; JREAD1.14 3.32,28.28 ; JREAD1.14 5.45,28.28 ; JREAD1.14 3.32,29.83 ; JREAD1.14 3.32,29.05 ; H16.1 377.34,137.66 ; H16.1 377.83,139 ; H16.1 374.17,139 ; H16.1 374.66,137.66 ; H16.1 376,137.17 ; H16.1 377.34,140.34 ; H16.1 374.66,140.34 ; H16.1 376,140.83 ; JUSB2.11 367.91,35.33 ; JUSB2.11 366.58,33.67 ; JUSB2.11 367.91,34.5 ; JUSB2.11 365.25,35.33 ; JUSB2.11 367.91,33.67 ; JUSB2.11 365.25,33.67 ; JUSB2.11 366.58,35.33 ; JUSB2.11 365.25,34.5 ; 380.18,75.5 JUSBC1.6 ; JUSBC1.6 381.6,75.5 ; JUSBC1.6 380.18,73.84 ; JUSBC1.6 380.18,74.67 ; JUSBC1.6 381.6,73.84 ; 375.32,73.9 JUSBC1.4 ; JUSBC1.4 375.32,75.45 ; JUSBC1.4 375.32,74.67 ; JUSBC1.4 377.78,75.45 ; JUSBC1.4 376.55,75.45 ; JUSBC1.4 377.78,74.67 ; 260.47,137.3 H11.1 ; H11.1 262.3,139.13 ; H11.1 262.3,135.47 ; H11.1 260.96,135.96 ; H11.1 263.64,135.96 ; H11.1 260.96,138.64 ; H11.1 264.13,137.3 ; H11.1 263.64,138.64 ; JCRT1.16 378.1,131.8 ; JCRT1.16 374.5,130.94 ; JCRT1.16 374.5,132.66 ; JCRT1.16 378.1,132.66 ; JCRT1.16 378.1,130.94 ; JCRT1.16 376.3,130.94 ; JCRT1.16 376.3,132.66 ; JCRT1.16 374.5,131.8 ; JUSB1.12 377.01,40.67 ; JUSB1.12 374.65,40.67 ; JUSB1.12 375.83,40.67 ; JUSB1.12 377.01,41.5 ; JUSB1.12 374.65,41.5 ; 369.67,96.6 JHDMI1.2 ; JHDMI1.2 370.83,96.6 ; JHDMI1.2 370.25,97.18 ; JHDMI1.2 369.79,96.14 ; JHDMI1.2 369.79,97.06 ; JHDMI1.2 370.71,97.06 ; JHDMI1.2 370.71,96.14 ; 7.4,76.57 H2.1 ; H2.1 5.57,78.4 ; H2.1 6.06,77.06 ; H2.1 8.74,77.06 ; H2.1 7.4,80.23 ; H2.1 9.23,78.4 ; H2.1 6.06,79.74 ; H2.1 8.74,79.74 ; 371.34,95.56 JHDMI1.5 ; JHDMI1.5 372.26,95.56 ; JHDMI1.5 371.22,95.1 ; JHDMI1.5 372.38,95.1 ; JHDMI1.5 371.34,94.64 ; JHDMI1.5 372.26,94.64 ; JUSB1.4 366.88,53.53 ; JUSB1.4 366.88,51.87 ; JUSB1.4 366.05,52.7 ; JUSB1.4 366.25,52.06 ; JUSB1.4 366.25,53.33 ; JUSB1.4 367.52,52.06 ; JHDMI1.20 381.73,101.35 ; JHDMI1.20 381.73,102.33 ; JHDMI1.20 378.27,101.35 ; JHDMI1.20 380,102.33 ; JHDMI1.20 378.27,102.33 ; JUSB1.10 367.91,43.63 ; JUSB1.10 365.25,41.97 ; JUSB1.10 367.91,42.8 ; JUSB1.10 366.58,43.63 ; JUSB1.10 366.58,41.97 ; JUSB1.10 365.25,42.8 ; JUSB1.10 367.91,41.97 ; JUSB1.10 365.25,43.63 ; HGPU2.1 271.45,74.94 ; HGPU2.1 269.02,72.51 ; HGPU2.1 271.45,70.08 ; HGPU2.1 273.88,72.51 ; HGPU2.1 269.68,74.28 ; HGPU2.1 273.22,74.28 ; HGPU2.1 273.22,70.74 ; HGPU2.1 269.68,70.74 ; 23.16,27.66 H4.1 ; H4.1 25.84,27.66 ; H4.1 23.16,30.34 ; H4.1 24.5,30.83 ; H4.1 24.5,27.17 ; H4.1 25.84,30.34 ; H4.1 26.33,29 ; H4.1 22.67,29 ; JHDMI1.21 381.73,82.87 ; JHDMI1.21 380,82.87 ; JHDMI1.21 381.73,83.85 ; JHDMI1.21 378.27,82.87 ; JHDMI1.21 378.27,83.85 ; JUSB3.7 14.25,68.29 ; JUSB3.7 12.98,68.29 ; JUSB3.7 13.62,68.48 ; JUSB3.7 14.45,67.65 ; JUSB3.7 13.62,66.82 ; JUSB3.7 14.25,67.02 ; JUSB3.7 12.98,67.02 ; 1.57,81.6 JLAN.10 ; JLAN.10 3.93,80.93 ; JLAN.10 1.57,80.93 ; JLAN.10 2.75,80.93 ; JLAN.10 2.75,82.27 ; JLAN.10 3.93,81.6 ; JLAN.10 1.57,82.27 ; JLAN.10 3.93,82.27 ; JCRT1.5 376.72,116.65 ; JCRT1.5 376.72,117.69 ; JCRT1.5 376.86,117.17 ; JCRT1.5 375.68,116.65 ; JCRT1.5 376.2,116.51 ; JCRT1.5 375.54,117.17 ; JCRT1.5 375.68,117.69 ; H3.1 7.4,25.83 ; H3.1 8.74,25.34 ; H3.1 9.23,24 ; H3.1 8.74,22.66 ; H3.1 7.4,22.17 ; H3.1 5.57,24 ; H3.1 6.06,25.34 ; H3.1 6.06,22.66 ; JHDMI1.17 372.26,88.64 ; JHDMI1.17 371.22,89.1 ; JHDMI1.17 372.38,89.1 ; JHDMI1.17 371.34,89.56 ; JHDMI1.17 372.26,89.56 ; JHDMI1.17 371.34,88.64 ; JREAD1.15 5.45,56.13 ; JREAD1.15 7.58,55.35 ; JREAD1.15 7.58,54.58 ; JREAD1.15 3.32,56.13 ; JREAD1.15 3.32,54.58 ; JREAD1.15 5.45,54.58 ; JREAD1.15 7.58,56.13 ; JREAD1.15 3.32,55.35 ; 365.25,22.53 JUSB2.10 ; JUSB2.10 367.91,21.7 ; JUSB2.10 367.91,22.53 ; JUSB2.10 366.58,20.87 ; JUSB2.10 365.25,20.87 ; JUSB2.10 366.58,22.53 ; JUSB2.10 367.91,20.87 ; JUSB2.10 365.25,21.7 ; JUSB3.12 6.17,76.18 ; JUSB3.12 4.99,76.18 ; JUSB3.12 4.99,75.35 ; JUSB3.12 7.35,75.35 ; JUSB3.12 7.35,76.18 ; 366.25,32.24 JUSB2.4 ; JUSB2.4 366.88,30.77 ; JUSB2.4 366.88,32.43 ; JUSB2.4 366.25,30.97 ; JUSB2.4 367.52,30.97 ; JUSB2.4 366.05,31.6 ; H14.1 360.7,118.53 ; H14.1 360.7,114.87 ; H14.1 358.57,114.87 ; H14.1 358.57,116.7 ; H14.1 362.83,118.53 ; H14.1 358.57,118.53 ; H14.1 362.83,114.87 ; H14.1 362.83,116.7 ; 14.09,73.22 JUSB3.10 ; JUSB3.10 16.75,74.88 ; JUSB3.10 14.09,74.05 ; JUSB3.10 16.75,73.22 ; JUSB3.10 16.75,74.05 ; JUSB3.10 15.42,73.22 ; JUSB3.10 14.09,74.88 ; JUSB3.10 15.42,74.88 ; JUSBC1.5 377.77,73.44 ; JUSBC1.5 377.77,74.35 ; JUSBC1.5 377.77,75.45 ; JUSBC1.5 377.05,73.44 ; JUSBC1.5 377.05,75.45 ; JUSBC1.5 376.33,75.45 ; JUSBC1.5 376.33,73.44 ; HGPU1.1 253.76,132.43 ; HGPU1.1 256.19,130 ; HGPU1.1 251.99,131.77 ; HGPU1.1 253.76,127.57 ; HGPU1.1 251.99,128.23 ; HGPU1.1 251.33,130 ; HGPU1.1 255.53,128.23 ; HGPU1.1 255.53,131.77 ; 371.34,92.56 JHDMI1.11 ; JHDMI1.11 372.26,92.56 ; JHDMI1.11 372.38,92.1 ; JHDMI1.11 371.34,91.64 ; JHDMI1.11 371.22,92.1 ; JHDMI1.11 372.26,91.64 ; HCPU1.1 134.58,117.86 ; HCPU1.1 131.04,114.32 ; HCPU1.1 130.38,116.09 ; HCPU1.1 132.81,118.52 ; HCPU1.1 135.24,116.09 ; HCPU1.1 134.58,114.32 ; HCPU1.1 132.81,113.66 ; HCPU1.1 131.04,117.86 ; H18.1 378.92,80.89 ; H18.1 376.08,78.05 ; H18.1 379.43,79.47 ; H18.1 377.5,77.54 ; H18.1 376.08,80.89 ; H18.1 375.57,79.47 ; H18.1 378.92,78.05 ; H18.1 377.5,81.4 ; JUSBC1.2 377.77,66.36 ; JUSBC1.2 377.77,65.25 ; JUSBC1.2 377.05,67.26 ; JUSBC1.2 376.33,65.25 ; JUSBC1.2 377.77,67.26 ; JUSBC1.2 377.05,65.25 ; JUSBC1.2 376.33,67.26 ; 367.75,27.47 JUSB2.7 ; JUSB2.7 369.02,27.47 ; JUSB2.7 369.02,28.74 ; JUSB2.7 367.75,28.74 ; JUSB2.7 368.38,28.93 ; JUSB2.7 368.38,27.27 ; JUSB2.7 367.55,28.1 ; HCPU2.1 129.32,75.05 ; HCPU2.1 131.75,72.62 ; HCPU2.1 126.89,72.62 ; HCPU2.1 131.09,74.39 ; HCPU2.1 127.55,70.85 ; HCPU2.1 131.09,70.85 ; HCPU2.1 127.55,74.39 ; HCPU2.1 129.32,70.19 ; JUSB3.13 7.35,59.95 ; JUSB3.13 4.99,59.95 ; JUSB3.13 6.17,59.12 ; JUSB3.13 7.35,59.12 ; JUSB3.13 4.99,59.12 ; JUSB1.7 368.38,50.03 ; JUSB1.7 367.75,49.84 ; JUSB1.7 368.38,48.37 ; JUSB1.7 369.02,48.57 ; JUSB1.7 369.02,49.84 ; JUSB1.7 367.55,49.2 ; JUSB1.7 367.75,48.57 ; JUSB3.4 15.12,64.98 ; JUSB3.4 15.12,63.32 ; JUSB3.4 15.95,64.15 ; JUSB3.4 14.49,64.79 ; JUSB3.4 15.76,64.79 ; JUSB3.4 15.76,63.52 ; JCRT1.7 376.86,125.19 ; JCRT1.7 375.68,124.67 ; JCRT1.7 375.68,125.7 ; JCRT1.7 376.72,124.67 ; JCRT1.7 375.54,125.19 ; JCRT1.7 376.72,125.7 ; 309.24,42.55 H13.1 ; H13.1 312.84,41.03 ; H13.1 312.84,44.07 ; H13.1 311.32,44.63 ; H13.1 309.8,44.07 ; H13.1 313.4,42.55 ; H13.1 309.8,41.03 ; H13.1 311.32,40.47 ; JCRT1.6 376.86,127.48 ; JCRT1.6 376.2,128.14 ; JCRT1.6 375.68,126.96 ; JCRT1.6 375.54,127.48 ; JCRT1.6 376.72,126.96 ; JCRT1.6 375.68,127.99 ; JCRT1.6 376.72,127.99 ; JLAN.12 11.73,98.4 ; JLAN.12 10.55,99.07 ; JLAN.12 9.37,97.73 ; JLAN.12 11.73,99.07 ; JLAN.12 11.73,97.73 ; JLAN.12 9.37,99.07 ; JLAN.12 10.55,97.73 ; JLAN.12 9.37,98.4 ; H19.1 379.43,61.23 ; H19.1 378.92,62.65 ; H19.1 376.08,62.65 ; H19.1 377.5,59.3 ; H19.1 378.92,59.81 ; H19.1 375.57,61.23 ; H19.1 377.5,63.16 ; H19.1 376.08,59.81 ; HCPU4.1 190.5,112.79 ; HCPU4.1 188.83,112.17 ; HCPU4.1 192.79,110.5 ; HCPU4.1 188.21,110.5 ; HCPU4.1 192.17,108.83 ; HCPU4.1 190.5,108.21 ; HCPU4.1 188.83,108.83 ; HCPU4.1 192.17,112.17 ; JUSB2.13 377.01,35.8 ; JUSB2.13 377.01,36.63 ; JUSB2.13 375.83,36.63 ; JUSB2.13 374.65,35.8 ; JUSB2.13 374.65,36.63 ; 380.18,65.2 JUSBC1.3 ; JUSBC1.3 380.18,66.03 ; JUSBC1.3 381.6,66.86 ; JUSBC1.3 381.6,65.2 ; JUSBC1.3 380.18,66.86 ; 370.32,84.37 JHDMI1.23 ; JHDMI1.23 370.32,86.33 ; JHDMI1.23 370.32,85.35 ; JHDMI1.23 371.65,86.33 ; JHDMI1.23 371.65,84.37 ; JHDMI1.23 372.98,84.37 ; JHDMI1.23 372.98,85.35 ; JHDMI1.23 372.98,86.33 ; 369.79,93.14 JHDMI1.8 ; JHDMI1.8 370.83,93.6 ; JHDMI1.8 369.79,94.06 ; JHDMI1.8 369.67,93.6 ; JHDMI1.8 370.71,94.06 ; JHDMI1.8 370.71,93.14 ; 375.54,122.9 JCRT1.8 ; JCRT1.8 375.68,122.38 ; JCRT1.8 375.68,123.41 ; JCRT1.8 376.86,122.9 ; JCRT1.8 376.72,123.41 ; JCRT1.8 376.72,122.38
  IN1 w0.15: v2(218.65,112.15) 218.65,112.08 218.95,111.78 218.95,111.24 218.65,110.94 v2(218.65,110.75) ; v2(233.25,103.03) 233.13,103.03 v2(232.69,102.59) 232.51,102.59 v2(231.95,103.15) 231.6,103.15 v2(231.37,102.92) 230.68,102.92 v2(230.53,103.07) 229.77,103.07 v2(229.75,103.05) ; v2(230.26,109.17) 230.34,109.09 231.16,109.09 v2(231.3,109.23) ; v2(216.97,112.68) 216.85,112.55 216.85,111.57 v2(217,111.42) 216.55,110.97 v2(216.55,110.75) ; v2(212.95,112.15) UG9.AP47 212.65,111.12 v2(212.45,110.92) ; v2(234.64,83.56) 234.95,83.87 235.73,83.87 v2(236,83.6) 236.32,83.92 237.31,83.92 v2(237.43,83.8) ; v2(232.64,96.18) 232.37,96.45 231.45,96.45 v2(231.15,96.75)
  IN1 w0.2: v2(232.6,106.62) 232.6,106.68 232.72,106.79 232.72,107.18 v2(232.72,107.18) ; v2(225.55,112.25) 225.1,112.7 v2(225.05,112.7)
  IN1 w0.25: v2(232.6,108.74) 232.55,108.79 v2(232.55,109.45) 232.45,109.35 v2(231.95,109.35) 231.83,109.23 v2(231.3,109.23) ; v2(218.65,112.15) v2(219.25,112.15) ; v2(234.5,96.3) 234.31,96.11 v2(233.94,96.11) 233.4,96.65 v2(233.11,96.65) ; v2(232.6,110.82) 232.01,111.42 v2(231.86,111.42) 231.27,110.83 230.77,110.83 230.53,110.59 v2(230.53,110.35) ; v2(218.65,109.42) 219.32,109.42 v2(219.35,109.45) 219.35,109.78 v2(219.13,110) 219.13,110.27 v2(218.65,110.75)
  IN1 w0.3: v2(230.53,110.35) 230.13,109.95 230.13,109.3 v2(230.26,109.17) ; v2(231.15,96.75) v2(230.55,96.15) 229.83,96.15 v2(229.82,96.14)
  GND2 w0.254: H19.1 378.92,59.81 ; H19.1 379.43,61.23 ; H19.1 377.5,63.16 ; H19.1 377.5,59.3 ; H19.1 376.08,59.81 ; H19.1 376.08,62.65 ; H19.1 378.92,62.65 ; H19.1 375.57,61.23 ; 374.5,131.8 JCRT1.16 ; JCRT1.16 378.1,132.66 ; JCRT1.16 376.3,132.66 ; JCRT1.16 378.1,131.8 ; JCRT1.16 374.5,132.66 ; JCRT1.16 376.3,130.94 ; JCRT1.16 374.5,130.94 ; JCRT1.16 378.1,130.94 ; JREAD1.15 7.58,54.58 ; JREAD1.15 5.45,56.13 ; JREAD1.15 3.32,54.58 ; JREAD1.15 7.58,56.13 ; JREAD1.15 5.45,54.58 ; JREAD1.15 7.58,55.35 ; JREAD1.15 3.32,56.13 ; JREAD1.15 3.32,55.35 ; 5.57,24 H3.1 ; H3.1 6.06,22.66 ; H3.1 7.4,25.83 ; H3.1 9.23,24 ; H3.1 7.4,22.17 ; H3.1 8.74,22.66 ; H3.1 6.06,25.34 ; H3.1 8.74,25.34 ; H13.1 311.32,44.63 ; H13.1 311.32,40.47 ; H13.1 309.8,41.03 ; H13.1 313.4,42.55 ; H13.1 312.84,41.03 ; H13.1 309.8,44.07 ; H13.1 309.24,42.55 ; H13.1 312.84,44.07 ; JUSB1.10 366.58,43.63 ; JUSB1.10 365.25,41.97 ; JUSB1.10 365.25,42.8 ; JUSB1.10 367.91,42.8 ; JUSB1.10 367.91,41.97 ; JUSB1.10 365.25,43.63 ; JUSB1.10 366.58,41.97 ; JUSB1.10 367.91,43.63 ; 371.65,98.87 JHDMI1.22 ; JHDMI1.22 370.32,100.83 ; JHDMI1.22 372.98,98.87 ; JHDMI1.22 372.98,99.85 ; JHDMI1.22 372.98,100.83 ; JHDMI1.22 370.32,99.85 ; JHDMI1.22 370.32,98.87 ; JHDMI1.22 371.65,100.83 ; H4.1 24.5,30.83 ; H4.1 26.33,29 ; H4.1 22.67,29 ; H4.1 25.84,30.34 ; H4.1 23.16,27.66 ; H4.1 23.16,30.34 ; H4.1 25.84,27.66 ; H4.1 24.5,27.17 ; JUSB2.11 366.58,35.33 ; JUSB2.11 367.91,34.5 ; JUSB2.11 367.91,35.33 ; JUSB2.11 365.25,34.5 ; JUSB2.11 366.58,33.67 ; JUSB2.11 367.91,33.67 ; JUSB2.11 365.25,33.67 ; JUSB2.11 365.25,35.33 ; 7.4,76.57 H2.1 ; H2.1 6.06,79.74 ; H2.1 8.74,79.74 ; H2.1 7.4,80.23 ; H2.1 9.23,78.4 ; H2.1 8.74,77.06 ; H2.1 5.57,78.4 ; H2.1 6.06,77.06 ; 378.27,83.85 JHDMI1.21 ; JHDMI1.21 380,82.87 ; JHDMI1.21 381.73,82.87 ; JHDMI1.21 381.73,83.85 ; JHDMI1.21 378.27,82.87 ; JCRT1.17 378.1,111.7 ; JCRT1.17 374.5,111.7 ; JCRT1.17 374.5,110.84 ; JCRT1.17 378.1,112.56 ; JCRT1.17 378.1,110.84 ; JCRT1.17 376.3,110.84 ; JCRT1.17 374.5,112.56 ; JCRT1.17 376.3,112.56 ; 376,137.17 H16.1 ; H16.1 377.34,140.34 ; H16.1 376,140.83 ; H16.1 377.34,137.66 ; H16.1 374.66,137.66 ; H16.1 374.66,140.34 ; H16.1 374.17,139 ; H16.1 377.83,139 ; 127.55,74.39 HCPU2.1 ; HCPU2.1 131.09,74.39 ; HCPU2.1 129.32,70.19 ; HCPU2.1 129.32,75.05 ; HCPU2.1 131.09,70.85 ; HCPU2.1 131.75,72.62 ; HCPU2.1 127.55,70.85 ; HCPU2.1 126.89,72.62 ; JUSBC1.3 381.6,66.86 ; JUSBC1.3 380.18,66.86 ; JUSBC1.3 380.18,65.2 ; JUSBC1.3 380.18,66.03 ; JUSBC1.3 381.6,65.2 ; 14.49,64.79 JUSB3.4 ; JUSB3.4 15.12,63.32 ; JUSB3.4 15.95,64.15 ; JUSB3.4 15.76,63.52 ; JUSB3.4 15.12,64.98 ; JUSB3.4 15.76,64.79 ; 1.57,80.93 JLAN.10 ; JLAN.10 1.57,81.6 ; JLAN.10 2.75,80.93 ; JLAN.10 1.57,82.27 ; JLAN.10 2.75,82.27 ; JLAN.10 3.93,82.27 ; JLAN.10 3.93,81.6 ; JLAN.10 3.93,80.93 ; 356.16,78.56 H15.1 ; H15.1 358.84,81.24 ; H15.1 359.33,79.9 ; H15.1 357.5,78.07 ; H15.1 357.5,81.73 ; H15.1 356.16,81.24 ; H15.1 355.67,79.9 ; H15.1 358.84,78.56 ; 380.18,73.84 JUSBC1.6 ; JUSBC1.6 380.18,75.5 ; JUSBC1.6 381.6,75.5 ; JUSBC1.6 380.18,74.67 ; JUSBC1.6 381.6,73.84 ; JCRT1.6 376.72,127.99 ; JCRT1.6 375.68,127.99 ; JCRT1.6 375.54,127.48 ; JCRT1.6 376.86,127.48 ; JCRT1.6 375.68,126.96 ; JCRT1.6 376.72,126.96 ; JCRT1.6 376.2,128.14 ; 6.06,101.96 H1.1 ; H1.1 9.23,103.3 ; H1.1 5.57,103.3 ; H1.1 7.4,105.13 ; H1.1 7.4,101.47 ; H1.1 8.74,104.64 ; H1.1 8.74,101.96 ; H1.1 6.06,104.64 ; 358.57,116.7 H14.1 ; H14.1 360.7,118.53 ; H14.1 360.7,114.87 ; H14.1 362.83,114.87 ; H14.1 358.57,118.53 ; H14.1 362.83,118.53 ; H14.1 362.83,116.7 ; H14.1 358.57,114.87 ; JHDMI1.5 372.26,95.56 ; JHDMI1.5 371.34,95.56 ; JHDMI1.5 372.26,94.64 ; JHDMI1.5 371.34,94.64 ; JHDMI1.5 372.38,95.1 ; JHDMI1.5 371.22,95.1 ; 14.09,60.42 JUSB3.11 ; JUSB3.11 14.09,61.25 ; JUSB3.11 14.09,62.08 ; JUSB3.11 16.75,62.08 ; JUSB3.11 16.75,60.42 ; JUSB3.11 15.42,62.08 ; JUSB3.11 16.75,61.25 ; JUSB3.11 15.42,60.42 ; HGPU1.1 255.53,128.23 ; HGPU1.1 255.53,131.77 ; HGPU1.1 251.99,128.23 ; HGPU1.1 253.76,132.43 ; HGPU1.1 251.99,131.77 ; HGPU1.1 251.33,130 ; HGPU1.1 253.76,127.57 ; HGPU1.1 256.19,130 ; JCRT1.7 376.72,124.67 ; JCRT1.7 376.86,125.19 ; JCRT1.7 375.68,124.67 ; JCRT1.7 376.72,125.7 ; JCRT1.7 375.68,125.7 ; JCRT1.7 375.54,125.19 ; JUSB2.7 369.02,28.74 ; JUSB2.7 367.75,28.74 ; JUSB2.7 367.75,27.47 ; JUSB2.7 368.38,28.93 ; JUSB2.7 368.38,27.27 ; JUSB2.7 369.02,27.47 ; JUSB2.7 367.55,28.1 ; JCRT1.5 376.72,116.65 ; JCRT1.5 375.68,117.69 ; JCRT1.5 375.68,116.65 ; JCRT1.5 376.86,117.17 ; JCRT1.5 375.54,117.17 ; JCRT1.5 376.2,116.51 ; JCRT1.5 376.72,117.69 ; 9.37,81.6 JLAN.9 ; JLAN.9 10.55,82.27 ; JLAN.9 9.37,80.93 ; JLAN.9 11.73,81.6 ; JLAN.9 11.73,80.93 ; JLAN.9 10.55,80.93 ; JLAN.9 11.73,82.27 ; JLAN.9 9.37,82.27 ; 377.05,73.44 JUSBC1.5 ; JUSBC1.5 377.05,75.45 ; JUSBC1.5 377.77,75.45 ; JUSBC1.5 376.33,73.44 ; JUSBC1.5 377.77,73.44 ; JUSBC1.5 377.77,74.35 ; JUSBC1.5 376.33,75.45 ; JHDMI1.17 372.38,89.1 ; JHDMI1.17 372.26,88.64 ; JHDMI1.17 371.34,88.64 ; JHDMI1.17 371.22,89.1 ; JHDMI1.17 371.34,89.56 ; JHDMI1.17 372.26,89.56 ; JUSB2.4 367.52,30.97 ; JUSB2.4 366.05,31.6 ; JUSB2.4 366.88,30.77 ; JUSB2.4 366.25,30.97 ; JUSB2.4 366.88,32.43 ; JUSB2.4 366.25,32.24 ; JHDMI1.23 371.65,86.33 ; JHDMI1.23 370.32,85.35 ; JHDMI1.23 370.32,84.37 ; JHDMI1.23 372.98,84.37 ; JHDMI1.23 370.32,86.33 ; JHDMI1.23 372.98,85.35 ; JHDMI1.23 372.98,86.33 ; JHDMI1.23 371.65,84.37 ; JUSB3.7 14.25,68.29 ; JUSB3.7 14.25,67.02 ; JUSB3.7 14.45,67.65 ; JUSB3.7 13.62,68.48 ; JUSB3.7 13.62,66.82 ; JUSB3.7 12.98,67.02 ; JUSB3.7 12.98,68.29 ; JHDMI1.2 370.25,97.18 ; JHDMI1.2 370.83,96.6 ; JHDMI1.2 370.71,96.14 ; JHDMI1.2 370.71,97.06 ; JHDMI1.2 369.79,96.14 ; JHDMI1.2 369.79,97.06 ; JHDMI1.2 369.67,96.6 ; 375.68,118.83 JCRT1.10 ; JCRT1.10 376.72,118.83 ; JCRT1.10 376.86,118.32 ; JCRT1.10 376.72,117.8 ; JCRT1.10 375.54,118.32 ; JCRT1.10 375.68,117.8 ; JUSB3.10 16.75,74.88 ; JUSB3.10 14.09,73.22 ; JUSB3.10 14.09,74.05 ; JUSB3.10 16.75,73.22 ; JUSB3.10 16.75,74.05 ; JUSB3.10 15.42,73.22 ; JUSB3.10 15.42,74.88 ; JUSB3.10 14.09,74.88 ; HCPU3.1 190.42,71.03 ; HCPU3.1 187.08,71.03 ; HCPU3.1 187.08,74.37 ; HCPU3.1 188.75,74.99 ; HCPU3.1 188.75,70.41 ; HCPU3.1 186.46,72.7 ; HCPU3.1 191.04,72.7 ; HCPU3.1 190.42,74.37 ; H11.1 263.64,135.96 ; H11.1 264.13,137.3 ; H11.1 260.96,135.96 ; H11.1 263.64,138.64 ; H11.1 260.96,138.64 ; H11.1 260.47,137.3 ; H11.1 262.3,135.47 ; H11.1 262.3,139.13 ; 10.55,97.73 JLAN.12 ; JLAN.12 9.37,97.73 ; JLAN.12 11.73,99.07 ; JLAN.12 9.37,99.07 ; JLAN.12 11.73,97.73 ; JLAN.12 11.73,98.4 ; JLAN.12 10.55,99.07 ; JLAN.12 9.37,98.4 ; JUSB1.12 377.01,40.67 ; JUSB1.12 377.01,41.5 ; JUSB1.12 374.65,41.5 ; JUSB1.12 375.83,40.67 ; JUSB1.12 374.65,40.67 ; 365.25,56.43 JUSB1.11 ; JUSB1.11 367.91,56.43 ; JUSB1.11 366.58,56.43 ; JUSB1.11 367.91,55.6 ; JUSB1.11 367.91,54.77 ; JUSB1.11 365.25,54.77 ; JUSB1.11 365.25,55.6 ; JUSB1.11 366.58,54.77 ; JUSB2.13 377.01,35.8 ; JUSB2.13 374.65,36.63 ; JUSB2.13 375.83,36.63 ; JUSB2.13 377.01,36.63 ; JUSB2.13 374.65,35.8 ; 378.27,102.33 JHDMI1.20 ; JHDMI1.20 378.27,101.35 ; JHDMI1.20 381.73,101.35 ; JHDMI1.20 380,102.33 ; JHDMI1.20 381.73,102.33 ; JUSBC1.1 377.78,66.81 ; JUSBC1.1 375.32,65.26 ; JUSBC1.1 375.32,66.03 ; JUSBC1.1 375.32,66.81 ; JUSBC1.1 377.78,66.03 ; JUSBC1.1 376.55,65.26 ; JUSBC1.1 377.78,65.26 ; 132.81,113.66 HCPU1.1 ; HCPU1.1 131.04,117.86 ; HCPU1.1 131.04,114.32 ; HCPU1.1 134.58,117.86 ; HCPU1.1 130.38,116.09 ; HCPU1.1 132.81,118.52 ; HCPU1.1 134.58,114.32 ; HCPU1.1 135.24,116.09 ; JUSBC1.4 376.55,75.45 ; JUSBC1.4 375.32,74.67 ; JUSBC1.4 375.32,73.9 ; JUSBC1.4 375.32,75.45 ; JUSBC1.4 377.78,74.67 ; JUSBC1.4 377.78,75.45 ; HCPU4.1 192.17,108.83 ; HCPU4.1 190.5,112.79 ; HCPU4.1 188.83,108.83 ; HCPU4.1 188.83,112.17 ; HCPU4.1 190.5,108.21 ; HCPU4.1 192.79,110.5 ; HCPU4.1 188.21,110.5 ; HCPU4.1 192.17,112.17 ; JHDMI1.8 370.83,93.6 ; JHDMI1.8 370.71,94.06 ; JHDMI1.8 369.67,93.6 ; JHDMI1.8 369.79,94.06 ; JHDMI1.8 370.71,93.14 ; JHDMI1.8 369.79,93.14 ; H17.1 364.08,9 ; H17.1 360.42,9 ; H17.1 363.59,7.66 ; H17.1 363.59,10.34 ; H17.1 360.91,7.66 ; H17.1 362.25,7.17 ; 269.68,74.28 HGPU2.1 ; HGPU2.1 269.02,72.51 ; HGPU2.1 273.22,70.74 ; HGPU2.1 269.68,70.74 ; HGPU2.1 273.88,72.51 ; HGPU2.1 271.45,74.94 ; HGPU2.1 273.22,74.28 ; HGPU2.1 271.45,70.08 ; 366.25,53.33 JUSB1.4 ; JUSB1.4 366.25,52.06 ; JUSB1.4 366.05,52.7 ; JUSB1.4 366.88,51.87 ; JUSB1.4 367.52,52.06 ; JUSB1.4 366.88,53.53 ; 367.55,49.2 JUSB1.7 ; JUSB1.7 367.75,49.84 ; JUSB1.7 369.02,48.57 ; JUSB1.7 368.38,50.03 ; JUSB1.7 367.75,48.57 ; JUSB1.7 368.38,48.37 ; JUSB1.7 369.02,49.84 ; JLAN.11 3.93,99.07 ; JLAN.11 1.57,97.73 ; JLAN.11 1.57,99.07 ; JLAN.11 1.57,98.4 ; JLAN.11 2.75,97.73 ; JLAN.11 3.93,98.4 ; JLAN.11 3.93,97.73 ; JLAN.11 2.75,99.07 ; 4.99,76.18 JUSB3.12 ; JUSB3.12 4.99,75.35 ; JUSB3.12 6.17,76.18 ; JUSB3.12 7.35,75.35 ; JUSB3.12 7.35,76.18 ; 371.34,92.56 JHDMI1.11 ; JHDMI1.11 372.26,91.64 ; JHDMI1.11 372.38,92.1 ; JHDMI1.11 371.34,91.64 ; JHDMI1.11 372.26,92.56 ; JHDMI1.11 371.22,92.1 ; H7.1 119.03,137.3 ; H7.1 117.2,139.13 ; H7.1 115.86,138.64 ; H7.1 115.37,137.3 ; H7.1 115.86,135.96 ; H7.1 118.54,138.64 ; H7.1 117.2,135.47 ; H7.1 118.54,135.96 ; H18.1 379.43,79.47 ; H18.1 376.08,80.89 ; H18.1 377.5,81.4 ; H18.1 377.5,77.54 ; H18.1 378.92,80.89 ; H18.1 376.08,78.05 ; H18.1 378.92,78.05 ; H18.1 375.57,79.47 ; JUSB2.10 367.91,22.53 ; JUSB2.10 367.91,20.87 ; JUSB2.10 365.25,20.87 ; JUSB2.10 366.58,20.87 ; JUSB2.10 367.91,21.7 ; JUSB2.10 365.25,22.53 ; JUSB2.10 366.58,22.53 ; JUSB2.10 365.25,21.7 ; 3.32,28.28 JREAD1.14 ; JREAD1.14 7.58,29.05 ; JREAD1.14 7.58,29.83 ; JREAD1.14 3.32,29.05 ; JREAD1.14 7.58,28.28 ; JREAD1.14 5.45,29.83 ; JREAD1.14 5.45,28.28 ; JREAD1.14 3.32,29.83 ; JUSB1.13 375.83,57.73 ; JUSB1.13 377.01,56.9 ; JUSB1.13 374.65,56.9 ; JUSB1.13 377.01,57.73 ; JUSB1.13 374.65,57.73 ; H5.1 73.42,61.08 ; H5.1 73.42,56.92 ; H5.1 74.94,60.52 ; H5.1 71.9,57.48 ; H5.1 71.9,60.52 ; H5.1 74.94,57.48 ; H5.1 71.34,59 ; H5.1 75.5,59 ; JCRT1.8 376.86,122.9 ; JCRT1.8 375.68,122.38 ; JCRT1.8 375.68,123.41 ; JCRT1.8 375.54,122.9 ; JCRT1.8 376.72,122.38 ; JCRT1.8 376.72,123.41 ; JUSB2.12 377.01,20.4 ; JUSB2.12 377.01,19.57 ; JUSB2.12 375.83,19.57 ; JUSB2.12 374.65,20.4 ; JUSB2.12 374.65,19.57 ; 4.99,59.95 JUSB3.13 ; JUSB3.13 7.35,59.95 ; JUSB3.13 6.17,59.12 ; JUSB3.13 7.35,59.12 ; JUSB3.13 4.99,59.12 ; JUSBC1.2 377.05,67.26 ; JUSBC1.2 377.77,65.25 ; JUSBC1.2 377.77,67.26 ; JUSBC1.2 377.05,65.25 ; JUSBC1.2 376.33,67.26 ; JUSBC1.2 377.77,66.36 ; JUSBC1.2 376.33,65.25
  IN2 w0.508: 362.22,84.88 v2(362.22,104.61) 362.22,108.79 367.98,114.55 369.1,114.55 369.61,115.05 369.61,118.9 368.59,119.92 368.59,122.65 v2(368.28,122.96) 366.06,122.96 365.7,122.6 365.7,115.81 359.81,109.92 v2(359.81,109.18) v2(359.81,86.45) 359.81,83.88 360.85,82.85 360.85,78.96 358.69,76.8 356.28,76.8 344.72,65.24 344.72,62.5 341.73,59.52 v2(337.73,59.52) 335.93,59.52 334.02,57.6 330.66,57.6 328.4,55.34 325.01,55.34 v2(323.24,53.57) 321.1,51.43 321.1,47.64 317.42,43.97 v2(317.13,43.97) 316.97,44.13 v2(316.34,44.13) 316.34,42.9 316.99,42.25 316.99,41.44 318.04,40.39 v2(318.14,40.39) 319.21,40.39 324.1,45.29 324.1,47.56 324.39,47.84 324.39,50.38 326.93,52.92 329.47,52.92 v2(330.3,53.75) 331.74,55.19 335.02,55.19 336.93,57.1 342.8,57.1 345.63,59.93 348.48,59.93 348.69,60.14 349.77,60.14 351.7,62.07 351.7,68.62 353.48,70.4 354.35,70.4 356.21,72.25 356.21,73.32 357.23,74.34 359.64,74.34 363.26,77.96 v2(363.26,83.85) 362.22,84.88
  VCC w0.203: HCPU2.1 131.09,70.85 ; HCPU2.1 127.55,70.85 ; HCPU2.1 126.89,72.62 ; HCPU2.1 127.55,74.39 ; HCPU2.1 131.75,72.62 ; HCPU2.1 129.32,75.05 ; HCPU2.1 129.32,70.19 ; HCPU2.1 131.09,74.39
  VCC w0.254: 380.18,75.5 JUSBC1.6 ; JUSBC1.6 381.6,73.84 ; JUSBC1.6 380.18,74.67 ; JUSBC1.6 380.18,73.84 ; JUSBC1.6 381.6,75.5 ; 365.25,33.67 JUSB2.11 ; JUSB2.11 365.25,34.5 ; JUSB2.11 367.91,35.33 ; JUSB2.11 366.58,35.33 ; JUSB2.11 365.25,35.33 ; JUSB2.11 366.58,33.67 ; JUSB2.11 367.91,33.67 ; JUSB2.11 367.91,34.5 ; JUSBC1.3 381.6,66.86 ; JUSBC1.3 380.18,66.03 ; JUSBC1.3 380.18,65.2 ; JUSBC1.3 381.6,65.2 ; JUSBC1.3 380.18,66.86 ; 115.86,135.96 H7.1 ; H7.1 119.03,137.3 ; H7.1 117.2,135.47 ; H7.1 118.54,135.96 ; H7.1 118.54,138.64 ; H7.1 115.86,138.64 ; H7.1 117.2,139.13 ; H7.1 115.37,137.3 ; 6.06,79.74 H2.1 ; H2.1 5.57,78.4 ; H2.1 7.4,76.57 ; H2.1 7.4,80.23 ; H2.1 8.74,77.06 ; H2.1 6.06,77.06 ; H2.1 9.23,78.4 ; H2.1 8.74,79.74 ; JUSB3.10 16.75,73.22 ; JUSB3.10 16.75,74.88 ; JUSB3.10 14.09,74.88 ; JUSB3.10 15.42,73.22 ; JUSB3.10 14.09,74.05 ; JUSB3.10 14.09,73.22 ; JUSB3.10 16.75,74.05 ; JUSB3.10 15.42,74.88 ; H19.1 378.92,59.81 ; H19.1 377.5,59.3 ; H19.1 379.43,61.23 ; H19.1 376.08,59.81 ; H19.1 375.57,61.23 ; H19.1 376.08,62.65 ; H19.1 377.5,63.16 ; H19.1 378.92,62.65 ; HGPU1.1 253.76,132.43 ; HGPU1.1 251.33,130 ; HGPU1.1 251.99,128.23 ; HGPU1.1 255.53,128.23 ; HGPU1.1 253.76,127.57 ; HGPU1.1 251.99,131.77 ; HGPU1.1 255.53,131.77 ; HGPU1.1 256.19,130 ; 375.54,122.9 JCRT1.8 ; JCRT1.8 376.72,122.38 ; JCRT1.8 376.72,123.41 ; JCRT1.8 375.68,122.38 ; JCRT1.8 375.68,123.41 ; JCRT1.8 376.86,122.9 ; 378.27,82.87 JHDMI1.21 ; JHDMI1.21 378.27,83.85 ; JHDMI1.21 381.73,82.87 ; JHDMI1.21 381.73,83.85 ; JHDMI1.21 380,82.87 ; 14.09,61.25 JUSB3.11 ; JUSB3.11 16.75,60.42 ; JUSB3.11 16.75,61.25 ; JUSB3.11 14.09,62.08 ; JUSB3.11 15.42,60.42 ; JUSB3.11 16.75,62.08 ; JUSB3.11 14.09,60.42 ; JUSB3.11 15.42,62.08 ; JUSB3.12 6.17,76.18 ; JUSB3.12 4.99,75.35 ; JUSB3.12 7.35,76.18 ; JUSB3.12 4.99,76.18 ; JUSB3.12 7.35,75.35 ; 375.32,65.26 JUSBC1.1 ; JUSBC1.1 377.78,66.81 ; JUSBC1.1 377.78,65.26 ; JUSBC1.1 376.55,65.26 ; JUSBC1.1 377.78,66.03 ; JUSBC1.1 375.32,66.03 ; JUSBC1.1 375.32,66.81 ; H15.1 359.33,79.9 ; H15.1 356.16,81.24 ; H15.1 355.67,79.9 ; H15.1 358.84,78.56 ; H15.1 358.84,81.24 ; H15.1 357.5,78.07 ; H15.1 357.5,81.73 ; H15.1 356.16,78.56 ; 362.25,7.17 H17.1 ; H17.1 363.59,10.34 ; H17.1 364.08,9 ; H17.1 360.91,7.66 ; H17.1 360.42,9 ; H17.1 363.59,7.66 ; 368.38,48.37 JUSB1.7 ; JUSB1.7 368.38,50.03 ; JUSB1.7 367.55,49.2 ; JUSB1.7 369.02,48.57 ; JUSB1.7 367.75,49.84 ; JUSB1.7 369.02,49.84 ; JUSB1.7 367.75,48.57 ; 4.99,59.12 JUSB3.13 ; JUSB3.13 7.35,59.95 ; JUSB3.13 6.17,59.12 ; JUSB3.13 7.35,59.12 ; JUSB3.13 4.99,59.95 ; JLAN.12 11.73,97.73 ; JLAN.12 10.55,97.73 ; JLAN.12 11.73,98.4 ; JLAN.12 10.55,99.07 ; JLAN.12 9.37,98.4 ; JLAN.12 9.37,97.73 ; JLAN.12 9.37,99.07 ; JLAN.12 11.73,99.07 ; 358.57,118.53 H14.1 ; H14.1 360.7,114.87 ; H14.1 362.83,116.7 ; H14.1 360.7,118.53 ; H14.1 362.83,118.53 ; H14.1 362.83,114.87 ; H14.1 358.57,116.7 ; H14.1 358.57,114.87 ; JCRT1.10 376.86,118.32 ; JCRT1.10 375.68,117.8 ; JCRT1.10 375.68,118.83 ; JCRT1.10 376.72,118.83 ; JCRT1.10 375.54,118.32 ; JCRT1.10 376.72,117.8 ; 14.49,64.79 JUSB3.4 ; JUSB3.4 15.12,64.98 ; JUSB3.4 15.12,63.32 ; JUSB3.4 15.76,64.79 ; JUSB3.4 15.76,63.52 ; JUSB3.4 15.95,64.15 ; 371.34,88.64 JHDMI1.17 ; JHDMI1.17 371.34,89.56 ; JHDMI1.17 372.38,89.1 ; JHDMI1.17 372.26,89.56 ; JHDMI1.17 371.22,89.1 ; JHDMI1.17 372.26,88.64 ; 1.57,81.6 JLAN.10 ; JLAN.10 2.75,82.27 ; JLAN.10 2.75,80.93 ; JLAN.10 3.93,82.27 ; JLAN.10 1.57,82.27 ; JLAN.10 3.93,81.6 ; JLAN.10 1.57,80.93 ; JLAN.10 3.93,80.93 ; HGPU2.1 273.88,72.51 ; HGPU2.1 271.45,70.08 ; HGPU2.1 273.22,70.74 ; HGPU2.1 269.02,72.51 ; HGPU2.1 273.22,74.28 ; HGPU2.1 271.45,74.94 ; HGPU2.1 269.68,74.28 ; HGPU2.1 269.68,70.74 ; JHDMI1.11 372.26,92.56 ; JHDMI1.11 371.34,92.56 ; JHDMI1.11 372.26,91.64 ; JHDMI1.11 371.34,91.64 ; JHDMI1.11 372.38,92.1 ; JHDMI1.11 371.22,92.1 ; 374.65,57.73 JUSB1.13 ; JUSB1.13 375.83,57.73 ; JUSB1.13 377.01,56.9 ; JUSB1.13 374.65,56.9 ; JUSB1.13 377.01,57.73 ; JCRT1.16 376.3,132.66 ; JCRT1.16 378.1,132.66 ; JCRT1.16 374.5,132.66 ; JCRT1.16 378.1,131.8 ; JCRT1.16 374.5,131.8 ; JCRT1.16 376.3,130.94 ; JCRT1.16 378.1,130.94 ; JCRT1.16 374.5,130.94 ; JCRT1.6 376.72,126.96 ; JCRT1.6 375.68,126.96 ; JCRT1.6 376.2,128.14 ; JCRT1.6 376.72,127.99 ; JCRT1.6 375.68,127.99 ; JCRT1.6 375.54,127.48 ; JCRT1.6 376.86,127.48 ; 3.32,56.13 JREAD1.15 ; JREAD1.15 7.58,55.35 ; JREAD1.15 3.32,54.58 ; JREAD1.15 3.32,55.35 ; JREAD1.15 5.45,56.13 ; JREAD1.15 7.58,56.13 ; JREAD1.15 5.45,54.58 ; JREAD1.15 7.58,54.58 ; 371.34,95.56 JHDMI1.5 ; JHDMI1.5 372.26,94.64 ; JHDMI1.5 371.22,95.1 ; JHDMI1.5 371.34,94.64 ; JHDMI1.5 372.38,95.1 ; JHDMI1.5 372.26,95.56 ; 375.32,75.45 JUSBC1.4 ; JUSBC1.4 377.78,74.67 ; JUSBC1.4 377.78,75.45 ; JUSBC1.4 375.32,73.9 ; JUSBC1.4 375.32,74.67 ; JUSBC1.4 376.55,75.45 ; 376.2,116.51 JCRT1.5 ; JCRT1.5 375.68,117.69 ; JCRT1.5 375.68,116.65 ; JCRT1.5 376.72,117.69 ; JCRT1.5 375.54,117.17 ; JCRT1.5 376.72,116.65 ; JCRT1.5 376.86,117.17 ; 374.66,140.34 H16.1 ; H16.1 376,140.83 ; H16.1 377.34,137.66 ; H16.1 377.34,140.34 ; H16.1 376,137.17 ; H16.1 374.17,139 ; H16.1 374.66,137.66 ; H16.1 377.83,139 ; JLAN.11 2.75,99.07 ; JLAN.11 2.75,97.73 ; JLAN.11 3.93,99.07 ; JLAN.11 3.93,98.4 ; JLAN.11 3.93,97.73 ; JLAN.11 1.57,97.73 ; JLAN.11 1.57,98.4 ; JLAN.11 1.57,99.07 ; JCRT1.17 376.3,112.56 ; JCRT1.17 376.3,110.84 ; JCRT1.17 374.5,110.84 ; JCRT1.17 374.5,112.56 ; JCRT1.17 378.1,110.84 ; JCRT1.17 378.1,111.7 ; JCRT1.17 374.5,111.7 ; JCRT1.17 378.1,112.56 ; 366.58,41.97 JUSB1.10 ; JUSB1.10 367.91,42.8 ; JUSB1.10 367.91,43.63 ; JUSB1.10 366.58,43.63 ; JUSB1.10 367.91,41.97 ; 371.65,84.37 JHDMI1.23 ; JHDMI1.23 372.98,86.33 ; JHDMI1.23 370.32,84.37 ; JHDMI1.23 370.32,86.33 ; JHDMI1.23 372.98,85.35 ; JHDMI1.23 372.98,84.37 ; JHDMI1.23 370.32,85.35 ; JHDMI1.23 371.65,86.33 ; 366.25,53.33 JUSB1.4 ; JUSB1.4 366.25,52.06 ; JUSB1.4 367.52,52.06 ; JUSB1.4 366.88,51.87 ; JUSB1.4 366.88,53.53 ; JUSB1.4 366.05,52.7 ; JUSB1.11 367.91,54.77 ; JUSB1.11 366.58,56.43 ; JUSB1.11 367.91,56.43 ; JUSB1.11 366.58,54.77 ; JUSB1.11 367.91,55.6 ; H18.1 378.92,80.89 ; H18.1 375.57,79.47 ; H18.1 376.08,78.05 ; H18.1 378.92,78.05 ; H18.1 377.5,77.54 ; H18.1 377.5,81.4 ; H18.1 376.08,80.89 ; H18.1 379.43,79.47 ; JUSBC1.2 377.77,66.36 ; JUSBC1.2 376.33,67.26 ; JUSBC1.2 377.77,65.25 ; JUSBC1.2 376.33,65.25 ; JUSBC1.2 377.77,67.26 ; JUSBC1.2 377.05,65.25 ; JUSBC1.2 377.05,67.26 ; 374.65,41.5 JUSB1.12 ; JUSB1.12 375.83,40.67 ; JUSB1.12 377.01,40.67 ; JUSB1.12 374.65,40.67 ; JUSB1.12 377.01,41.5 ; JUSBC1.5 377.77,73.44 ; JUSBC1.5 376.33,75.45 ; JUSBC1.5 377.05,75.45 ; JUSBC1.5 377.77,74.35 ; JUSBC1.5 377.77,75.45 ; 366.05,31.6 JUSB2.4 ; JUSB2.4 366.88,32.43 ; JUSB2.4 366.88,30.77 ; JUSB2.4 366.25,30.97 ; JUSB2.4 367.52,30.97 ; JUSB2.4 366.25,32.24 ; JHDMI1.22 372.98,98.87 ; JHDMI1.22 370.32,99.85 ; JHDMI1.22 372.98,99.85 ; JHDMI1.22 370.32,98.87 ; JHDMI1.22 370.32,100.83 ; JHDMI1.22 371.65,100.83 ; JHDMI1.22 371.65,98.87 ; JHDMI1.22 372.98,100.83 ; 378.27,102.33 JHDMI1.20 ; JHDMI1.20 381.73,101.35 ; JHDMI1.20 381.73,102.33 ; JHDMI1.20 378.27,101.35 ; JHDMI1.20 380,102.33 ; 9.37,80.93 JLAN.9 ; JLAN.9 11.73,82.27 ; JLAN.9 11.73,81.6 ; JLAN.9 10.55,82.27 ; JLAN.9 9.37,81.6 ; JLAN.9 11.73,80.93 ; JLAN.9 9.37,82.27 ; JLAN.9 10.55,80.93 ; 369.79,97.06 JHDMI1.2 ; JHDMI1.2 370.25,97.18 ; JHDMI1.2 369.79,96.14 ; JHDMI1.2 370.83,96.6 ; JHDMI1.2 369.67,96.6 ; JHDMI1.2 370.71,97.06 ; JHDMI1.2 370.71,96.14 ; JUSB2.7 369.02,28.74 ; JUSB2.7 367.55,28.1 ; JUSB2.7 369.02,27.47 ; JUSB2.7 368.38,27.27 ; JUSB2.7 367.75,27.47 ; JUSB2.7 367.75,28.74 ; JUSB2.7 368.38,28.93 ; JCRT1.7 376.72,124.67 ; JCRT1.7 376.72,125.7 ; JCRT1.7 375.68,125.7 ; JCRT1.7 376.86,125.19 ; JCRT1.7 375.54,125.19 ; JCRT1.7 375.68,124.67 ; JUSB2.12 377.01,20.4 ; JUSB2.12 374.65,20.4 ; JUSB2.12 375.83,19.57 ; JUSB2.12 377.01,19.57 ; JUSB2.12 374.65,19.57 ; H1.1 7.4,105.13 ; H1.1 5.57,103.3 ; H1.1 6.06,104.64 ; H1.1 8.74,104.64 ; H1.1 7.4,101.47 ; H1.1 6.06,101.96 ; H1.1 8.74,101.96 ; H1.1 9.23,103.3 ; 311.32,40.47 H13.1 ; H13.1 313.4,42.55 ; H13.1 311.32,44.63 ; H13.1 312.84,41.03 ; H13.1 309.24,42.55 ; H13.1 309.8,44.07 ; H13.1 312.84,44.07 ; H13.1 309.8,41.03 ; 262.3,135.47 H11.1 ; H11.1 264.13,137.3 ; H11.1 260.96,135.96 ; H11.1 262.3,139.13 ; H11.1 263.64,135.96 ; H11.1 263.64,138.64 ; H11.1 260.47,137.3 ; H11.1 260.96,138.64 ; JUSB2.13 377.01,35.8 ; JUSB2.13 377.01,36.63 ; JUSB2.13 374.65,35.8 ; JUSB2.13 375.83,36.63 ; JUSB2.13 374.65,36.63 ; 365.25,21.7 JUSB2.10 ; JUSB2.10 367.91,21.7 ; JUSB2.10 366.58,20.87 ; JUSB2.10 365.25,20.87 ; JUSB2.10 365.25,22.53 ; JUSB2.10 367.91,22.53 ; JUSB2.10 367.91,20.87 ; JUSB2.10 366.58,22.53 ; 369.79,94.06 JHDMI1.8 ; JHDMI1.8 369.79,93.14 ; JHDMI1.8 370.83,93.6 ; JHDMI1.8 369.67,93.6 ; JHDMI1.8 370.71,94.06 ; JHDMI1.8 370.71,93.14 ; JUSB3.7 14.25,67.02 ; JUSB3.7 12.98,68.29 ; JUSB3.7 14.25,68.29 ; JUSB3.7 14.45,67.65 ; JUSB3.7 13.62,68.48 ; JUSB3.7 12.98,67.02 ; JUSB3.7 13.62,66.82
  GND3 w0.254: 5.45,28.28 JREAD1.14 ; JREAD1.14 3.32,29.83 ; JREAD1.14 7.58,28.28 ; JREAD1.14 3.32,28.28 ; JREAD1.14 7.58,29.05 ; JREAD1.14 3.32,29.05 ; JREAD1.14 7.58,29.83 ; JREAD1.14 5.45,29.83 ; 371.34,92.56 JHDMI1.11 ; JHDMI1.11 372.26,92.56 ; JHDMI1.11 372.38,92.1 ; JHDMI1.11 371.34,91.64 ; JHDMI1.11 372.26,91.64 ; JHDMI1.11 371.22,92.1 ; 374.65,57.73 JUSB1.13 ; JUSB1.13 374.65,56.9 ; JUSB1.13 377.01,56.9 ; JUSB1.13 377.01,57.73 ; JUSB1.13 375.83,57.73 ; 380,82.87 JHDMI1.21 ; JHDMI1.21 378.27,83.85 ; JHDMI1.21 381.73,82.87 ; JHDMI1.21 378.27,82.87 ; JHDMI1.21 381.73,83.85 ; JHDMI1.23 372.98,86.33 ; JHDMI1.23 371.65,86.33 ; JHDMI1.23 372.98,84.37 ; JHDMI1.23 372.98,85.35 ; JHDMI1.23 370.32,86.33 ; JHDMI1.23 370.32,85.35 ; JHDMI1.23 370.32,84.37 ; JHDMI1.23 371.65,84.37 ; 360.91,7.66 H17.1 ; H17.1 360.42,9 ; H17.1 362.25,7.17 ; H17.1 363.59,10.34 ; H17.1 363.59,7.66 ; H17.1 364.08,9 ; JCRT1.6 376.86,127.48 ; JCRT1.6 375.68,127.99 ; JCRT1.6 376.72,126.96 ; JCRT1.6 376.72,127.99 ; JCRT1.6 375.68,126.96 ; JCRT1.6 376.2,128.14 ; JCRT1.6 375.54,127.48 ; 131.04,114.32 HCPU1.1 ; HCPU1.1 130.38,116.09 ; HCPU1.1 131.04,117.86 ; HCPU1.1 135.24,116.09 ; HCPU1.1 132.81,113.66 ; HCPU1.1 134.58,114.32 ; HCPU1.1 134.58,117.86 ; HCPU1.1 132.81,118.52 ; JCRT1.7 376.72,124.67 ; JCRT1.7 376.86,125.19 ; JCRT1.7 375.68,124.67 ; JCRT1.7 376.72,125.7 ; JCRT1.7 375.68,125.7 ; JCRT1.7 375.54,125.19 ; H19.1 378.92,62.65 ; H19.1 378.92,59.81 ; H19.1 376.08,62.65 ; H19.1 379.43,61.23 ; H19.1 376.08,59.81 ; H19.1 375.57,61.23 ; H19.1 377.5,59.3 ; H19.1 377.5,63.16 ; JUSBC1.3 381.6,66.86 ; JUSBC1.3 381.6,65.2 ; JUSBC1.3 380.18,66.03 ; JUSBC1.3 380.18,65.2 ; JUSBC1.3 380.18,66.86 ; 370.32,100.83 JHDMI1.22 ; JHDMI1.22 372.98,100.83 ; JHDMI1.22 371.65,100.83 ; JHDMI1.22 370.32,98.87 ; JHDMI1.22 372.98,99.85 ; JHDMI1.22 371.65,98.87 ; JHDMI1.22 372.98,98.87 ; JHDMI1.22 370.32,99.85 ; JUSB1.11 367.91,55.6 ; JUSB1.11 367.91,54.77 ; JUSB1.11 365.25,54.77 ; JUSB1.11 365.25,56.43 ; JUSB1.11 365.25,55.6 ; JUSB1.11 366.58,54.77 ; JUSB1.11 367.91,56.43 ; JUSB1.11 366.58,56.43 ; H14.1 360.7,118.53 ; H14.1 362.83,114.87 ; H14.1 358.57,118.53 ; H14.1 362.83,116.7 ; H14.1 360.7,114.87 ; H14.1 362.83,118.53 ; H14.1 358.57,116.7 ; H14.1 358.57,114.87 ; 269.68,70.74 HGPU2.1 ; HGPU2.1 273.22,74.28 ; HGPU2.1 273.22,70.74 ; HGPU2.1 269.02,72.51 ; HGPU2.1 271.45,74.94 ; HGPU2.1 269.68,74.28 ; HGPU2.1 273.88,72.51 ; HGPU2.1 271.45,70.08 ; 365.25,35.33 JUSB2.11 ; JUSB2.11 367.91,33.67 ; JUSB2.11 366.58,33.67 ; JUSB2.11 367.91,35.33 ; JUSB2.11 365.25,34.5 ; JUSB2.11 365.25,33.67 ; JUSB2.11 366.58,35.33 ; JUSB2.11 367.91,34.5 ; 376.33,73.44 JUSBC1.5 ; JUSBC1.5 377.77,74.35 ; JUSBC1.5 377.77,73.44 ; JUSBC1.5 377.05,75.45 ; JUSBC1.5 376.33,75.45 ; JUSBC1.5 377.05,73.44 ; JUSBC1.5 377.77,75.45 ; 117.2,135.47 H7.1 ; H7.1 118.54,135.96 ; H7.1 115.37,137.3 ; H7.1 117.2,139.13 ; H7.1 115.86,138.64 ; H7.1 118.54,138.64 ; H7.1 115.86,135.96 ; H7.1 119.03,137.3 ; 2.75,97.73 JLAN.11 ; JLAN.11 3.93,97.73 ; JLAN.11 3.93,98.4 ; JLAN.11 2.75,99.07 ; JLAN.11 3.93,99.07 ; JLAN.11 1.57,99.07 ; JLAN.11 1.57,98.4 ; JLAN.11 1.57,97.73 ; JCRT1.5 376.86,117.17 ; JCRT1.5 375.68,116.65 ; JCRT1.5 376.72,116.65 ; JCRT1.5 376.2,116.51 ; JCRT1.5 375.54,117.17 ; JCRT1.5 376.72,117.69 ; JCRT1.5 375.68,117.69 ; 375.32,65.26 JUSBC1.1 ; JUSBC1.1 377.78,66.81 ; JUSBC1.1 375.32,66.81 ; JUSBC1.1 377.78,66.03 ; JUSBC1.1 377.78,65.26 ; JUSBC1.1 375.32,66.03 ; JUSBC1.1 376.55,65.26 ; 13.62,66.82 JUSB3.7 ; JUSB3.7 12.98,67.02 ; JUSB3.7 14.45,67.65 ; JUSB3.7 14.25,67.02 ; JUSB3.7 13.62,68.48 ; JUSB3.7 12.98,68.29 ; JUSB3.7 14.25,68.29 ; JUSB3.10 16.75,74.05 ; JUSB3.10 15.42,74.88 ; JUSB3.10 16.75,73.22 ; JUSB3.10 16.75,74.88 ; JUSB3.10 14.09,73.22 ; JUSB3.10 15.42,73.22 ; JUSB3.10 14.09,74.05 ; JUSB3.10 14.09,74.88 ; H16.1 377.34,140.34 ; H16.1 376,140.83 ; H16.1 377.83,139 ; H16.1 374.66,137.66 ; H16.1 374.66,140.34 ; H16.1 376,137.17 ; H16.1 374.17,139 ; H16.1 377.34,137.66 ; 368.38,48.37 JUSB1.7 ; JUSB1.7 367.75,48.57 ; JUSB1.7 369.02,48.57 ; JUSB1.7 367.55,49.2 ; JUSB1.7 367.75,49.84 ; JUSB1.7 369.02,49.84 ; JUSB1.7 368.38,50.03 ; 262.3,135.47 H11.1 ; H11.1 260.47,137.3 ; H11.1 264.13,137.3 ; H11.1 260.96,138.64 ; H11.1 260.96,135.96 ; H11.1 262.3,139.13 ; H11.1 263.64,135.96 ; H11.1 263.64,138.64 ; JUSB3.12 7.35,75.35 ; JUSB3.12 7.35,76.18 ; JUSB3.12 4.99,75.35 ; JUSB3.12 6.17,76.18 ; JUSB3.12 4.99,76.18 ; H5.1 75.5,59 ; H5.1 74.94,57.48 ; H5.1 71.9,57.48 ; H5.1 73.42,61.08 ; H5.1 73.42,56.92 ; H5.1 74.94,60.52 ; H5.1 71.34,59 ; H5.1 71.9,60.52 ; H1.1 8.74,104.64 ; H1.1 7.4,105.13 ; H1.1 8.74,101.96 ; H1.1 9.23,103.3 ; H1.1 7.4,101.47 ; H1.1 6.06,104.64 ; H1.1 6.06,101.96 ; H1.1 5.57,103.3 ; 22.67,29 H4.1 ; H4.1 24.5,27.17 ; H4.1 26.33,29 ; H4.1 23.16,30.34 ; H4.1 25.84,27.66 ; H4.1 24.5,30.83 ; H4.1 25.84,30.34 ; H4.1 23.16,27.66 ; JUSB2.13 377.01,36.63 ; JUSB2.13 377.01,35.8 ; JUSB2.13 374.65,36.63 ; JUSB2.13 375.83,36.63 ; JUSB2.13 374.65,35.8 ; 309.24,42.55 H13.1 ; H13.1 309.8,44.07 ; H13.1 311.32,44.63 ; H13.1 312.84,44.07 ; H13.1 309.8,41.03 ; H13.1 312.84,41.03 ; H13.1 313.4,42.55 ; H13.1 311.32,40.47 ; JHDMI1.2 370.83,96.6 ; JHDMI1.2 369.79,97.06 ; JHDMI1.2 369.79,96.14 ; JHDMI1.2 370.25,97.18 ; JHDMI1.2 370.71,97.06 ; JHDMI1.2 369.67,96.6 ; JHDMI1.2 370.71,96.14 ; 366.25,52.06 JUSB1.4 ; JUSB1.4 367.52,52.06 ; JUSB1.4 366.88,51.87 ; JUSB1.4 366.88,53.53 ; JUSB1.4 366.05,52.7 ; JUSB1.4 366.25,53.33 ; JUSB3.11 15.42,62.08 ; JUSB3.11 15.42,60.42 ; JUSB3.11 16.75,61.25 ; JUSB3.11 14.09,61.25 ; JUSB3.11 14.09,60.42 ; JUSB3.11 14.09,62.08 ; JUSB3.11 16.75,62.08 ; JUSB3.11 16.75,60.42 ; 374.5,131.8 JCRT1.16 ; JCRT1.16 374.5,132.66 ; JCRT1.16 374.5,130.94 ; JCRT1.16 378.1,130.94 ; JCRT1.16 376.3,132.66 ; JCRT1.16 376.3,130.94 ; JCRT1.16 378.1,132.66 ; JCRT1.16 378.1,131.8 ; 374.65,19.57 JUSB2.12 ; JUSB2.12 377.01,20.4 ; JUSB2.12 377.01,19.57 ; JUSB2.12 374.65,20.4 ; JUSB2.12 375.83,19.57 ; JUSBC1.2 377.77,67.26 ; JUSBC1.2 376.33,65.25 ; JUSBC1.2 377.77,65.25 ; JUSBC1.2 377.05,65.25 ; JUSBC1.2 377.05,67.26 ; JUSBC1.2 376.33,67.26 ; JUSBC1.2 377.77,66.36 ; H15.1 359.33,79.9 ; H15.1 355.67,79.9 ; H15.1 356.16,81.24 ; H15.1 358.84,78.56 ; H15.1 357.5,78.07 ; H15.1 356.16,78.56 ; H15.1 358.84,81.24 ; H15.1 357.5,81.73 ; H2.1 9.23,78.4 ; H2.1 7.4,80.23 ; H2.1 7.4,76.57 ; H2.1 8.74,77.06 ; H2.1 5.57,78.4 ; H2.1 8.74,79.74 ; H2.1 6.06,77.06 ; H2.1 6.06,79.74 ; JUSB1.12 377.01,41.5 ; JUSB1.12 374.65,41.5 ; JUSB1.12 377.01,40.67 ; JUSB1.12 375.83,40.67 ; JUSB1.12 374.65,40.67 ; 186.46,72.7 HCPU3.1 ; HCPU3.1 187.08,74.37 ; HCPU3.1 190.42,74.37 ; HCPU3.1 190.42,71.03 ; HCPU3.1 191.04,72.7 ; HCPU3.1 188.75,70.41 ; HCPU3.1 187.08,71.03 ; HCPU3.1 188.75,74.99 ; 366.88,30.77 JUSB2.4 ; JUSB2.4 366.05,31.6 ; JUSB2.4 366.88,32.43 ; JUSB2.4 366.25,32.24 ; JUSB2.4 366.25,30.97 ; JUSB2.4 367.52,30.97 ; 9.37,81.6 JLAN.9 ; JLAN.9 9.37,82.27 ; JLAN.9 11.73,80.93 ; JLAN.9 10.55,82.27 ; JLAN.9 11.73,81.6 ; JLAN.9 9.37,80.93 ; JLAN.9 11.73,82.27 ; JLAN.9 10.55,80.93 ; JCRT1.10 376.86,118.32 ; JCRT1.10 375.68,117.8 ; JCRT1.10 375.68,118.83 ; JCRT1.10 375.54,118.32 ; JCRT1.10 376.72,117.8 ; JCRT1.10 376.72,118.83 ; JUSB3.4 15.95,64.15 ; JUSB3.4 15.76,64.79 ; JUSB3.4 14.49,64.79 ; JUSB3.4 15.12,63.32 ; JUSB3.4 15.76,63.52 ; JUSB3.4 15.12,64.98 ; JUSB2.7 369.02,27.47 ; JUSB2.7 367.75,28.74 ; JUSB2.7 367.55,28.1 ; JUSB2.7 367.75,27.47 ; JUSB2.7 369.02,28.74 ; JUSB2.7 368.38,27.27 ; JUSB2.7 368.38,28.93 ; HCPU2.1 129.32,75.05 ; HCPU2.1 131.75,72.62 ; HCPU2.1 127.55,74.39 ; HCPU2.1 126.89,72.62 ; HCPU2.1 131.09,70.85 ; HCPU2.1 131.09,74.39 ; HCPU2.1 129.32,70.19 ; HCPU2.1 127.55,70.85 ; JLAN.12 11.73,98.4 ; JLAN.12 10.55,99.07 ; JLAN.12 9.37,97.73 ; JLAN.12 10.55,97.73 ; JLAN.12 11.73,97.73 ; JLAN.12 9.37,99.07 ; JLAN.12 11.73,99.07 ; JLAN.12 9.37,98.4 ; JHDMI1.17 372.38,89.1 ; JHDMI1.17 371.34,89.56 ; JHDMI1.17 371.34,88.64 ; JHDMI1.17 372.26,89.56 ; JHDMI1.17 372.26,88.64 ; JHDMI1.17 371.22,89.1 ; JUSB1.10 367.91,43.63 ; JUSB1.10 366.58,43.63 ; JUSB1.10 366.58,41.97 ; JUSB1.10 365.25,42.8 ; JUSB1.10 365.25,43.63 ; JUSB1.10 365.25,41.97 ; JUSB1.10 367.91,42.8 ; JUSB1.10 367.91,41.97 ; 3.32,56.13 JREAD1.15 ; JREAD1.15 7.58,54.58 ; JREAD1.15 5.45,56.13 ; JREAD1.15 3.32,54.58 ; JREAD1.15 7.58,56.13 ; JREAD1.15 7.58,55.35 ; JREAD1.15 5.45,54.58 ; JREAD1.15 3.32,55.35 ; JHDMI1.8 370.71,93.14 ; JHDMI1.8 370.83,93.6 ; JHDMI1.8 369.79,93.14 ; JHDMI1.8 369.67,93.6 ; JHDMI1.8 370.71,94.06 ; JHDMI1.8 369.79,94.06 ; JCRT1.8 376.72,122.38 ; JCRT1.8 376.86,122.9 ; JCRT1.8 375.68,122.38 ; JCRT1.8 375.54,122.9 ; JCRT1.8 375.68,123.41 ; JCRT1.8 376.72,123.41 ; H3.1 7.4,25.83 ; H3.1 7.4,22.17 ; H3.1 6.06,22.66 ; H3.1 5.57,24 ; H3.1 9.23,24 ; H3.1 8.74,25.34 ; H3.1 8.74,22.66 ; H3.1 6.06,25.34 ; JUSBC1.4 377.78,74.67 ; JUSBC1.4 375.32,74.67 ; JUSBC1.4 376.55,75.45 ; JUSBC1.4 377.78,75.45 ; JUSBC1.4 375.32,73.9 ; JUSBC1.4 375.32,75.45 ; 380.18,75.5 JUSBC1.6 ; JUSBC1.6 380.18,74.67 ; JUSBC1.6 381.6,75.5 ; JUSBC1.6 380.18,73.84 ; JUSBC1.6 381.6,73.84 ; JLAN.10 3.93,82.27 ; JLAN.10 1.57,80.93 ; JLAN.10 1.57,81.6 ; JLAN.10 1.57,82.27 ; JLAN.10 3.93,81.6 ; JLAN.10 2.75,80.93 ; JLAN.10 3.93,80.93 ; JLAN.10 2.75,82.27 ; 366.58,20.87 JUSB2.10 ; JUSB2.10 365.25,20.87 ; JUSB2.10 365.25,21.7 ; JUSB2.10 367.91,21.7 ; JUSB2.10 365.25,22.53 ; JUSB2.10 366.58,22.53 ; JUSB2.10 367.91,20.87 ; JUSB2.10 367.91,22.53 ; 378.27,102.33 JHDMI1.20 ; JHDMI1.20 380,102.33 ; JHDMI1.20 378.27,101.35 ; JHDMI1.20 381.73,101.35 ; JHDMI1.20 381.73,102.33 ; JCRT1.17 376.3,112.56 ; JCRT1.17 378.1,110.84 ; JCRT1.17 374.5,112.56 ; JCRT1.17 374.5,111.7 ; JCRT1.17 378.1,111.7 ; JCRT1.17 374.5,110.84 ; JCRT1.17 376.3,110.84 ; JCRT1.17 378.1,112.56 ; 371.34,94.64 JHDMI1.5 ; JHDMI1.5 372.38,95.1 ; JHDMI1.5 371.22,95.1 ; JHDMI1.5 371.34,95.56 ; JHDMI1.5 372.26,94.64 ; JHDMI1.5 372.26,95.56 ; 6.17,59.12 JUSB3.13 ; JUSB3.13 7.35,59.95 ; JUSB3.13 7.35,59.12 ; JUSB3.13 4.99,59.95 ; JUSB3.13 4.99,59.12 ; H18.1 379.43,79.47 ; H18.1 378.92,80.89 ; H18.1 376.08,78.05 ; H18.1 375.57,79.47 ; H18.1 377.5,77.54 ; H18.1 377.5,81.4 ; H18.1 376.08,80.89 ; H18.1 378.92,78.05 ; 251.33,130 HGPU1.1 ; HGPU1.1 255.53,131.77 ; HGPU1.1 253.76,127.57 ; HGPU1.1 253.76,132.43 ; HGPU1.1 256.19,130 ; HGPU1.1 251.99,128.23 ; HGPU1.1 255.53,128.23 ; HGPU1.1 251.99,131.77
  IN5 w0.15: v2(210.27,110.03) 210.27,110.17 210.5,110.4 210.55,110.4 ; 210.55,110.4 v2(210.85,110.1) 210.79,110.04 v2(210.79,109.51) ; 210.55,110.4 UG9.AU47 ; v2(221.37,112.2) 221.05,111.88 221.05,111.06 v2(220.79,110.8) 221.06,110.53 221.06,110.34 221.05,110.33 221.05,109.98 221.06,109.97 221.06,109.81 v2(221.24,109.63) ; UG9.AU47 v2(210.85,112.15) v2(210.25,112.15) UG9.AU47 ; v2(219.25,112.15) 219.25,112.1 218.95,111.8 218.95,111.23 218.65,110.93 v2(218.65,110.75)
  IN5 w0.25: v2(221.37,112.2) 220.87,112.69 v2(220.86,112.69) 220.86,113.06 v2(221.35,113.55) 221.35,113.95 v2(221.2,114.1)
  IN5 w0.3: v2(218.65,110.75) 219.13,110.27 v2(219.13,110) ; v2(219.13,110) 219.35,109.78 v2(219.35,109.45) 218.68,109.45 v2(218.65,109.42) ; v2(219.13,110) 219.93,110.8 ; 219.93,110.8 219.93,111.64 219.43,112.15 v2(219.25,112.15) ; 219.93,110.8 v2(220.79,110.8)
  GND4 w0.254: 374.65,20.4 JUSB2.12 ; JUSB2.12 377.01,19.57 ; JUSB2.12 374.65,19.57 ; JUSB2.12 375.83,19.57 ; JUSB2.12 377.01,20.4 ; JLAN.10 2.75,82.27 ; JLAN.10 2.75,80.93 ; JLAN.10 1.57,81.6 ; JLAN.10 1.57,82.27 ; JLAN.10 3.93,80.93 ; JLAN.10 1.57,80.93 ; JLAN.10 3.93,82.27 ; JLAN.10 3.93,81.6 ; 375.68,125.7 JCRT1.7 ; JCRT1.7 375.54,125.19 ; JCRT1.7 375.68,124.67 ; JCRT1.7 376.72,125.7 ; JCRT1.7 376.86,125.19 ; JCRT1.7 376.72,124.67 ; 6.17,59.12 JUSB3.13 ; JUSB3.13 7.35,59.12 ; JUSB3.13 4.99,59.95 ; JUSB3.13 7.35,59.95 ; JUSB3.13 4.99,59.12 ; JCRT1.5 376.72,117.69 ; JCRT1.5 375.68,117.69 ; JCRT1.5 375.54,117.17 ; JCRT1.5 376.86,117.17 ; JCRT1.5 376.72,116.65 ; JCRT1.5 376.2,116.51 ; JCRT1.5 375.68,116.65 ; JHDMI1.22 372.98,98.87 ; JHDMI1.22 371.65,100.83 ; JHDMI1.22 372.98,99.85 ; JHDMI1.22 371.65,98.87 ; JHDMI1.22 370.32,98.87 ; JHDMI1.22 370.32,99.85 ; JHDMI1.22 372.98,100.83 ; JHDMI1.22 370.32,100.83 ; JHDMI1.2 370.71,96.14 ; JHDMI1.2 370.71,97.06 ; JHDMI1.2 370.25,97.18 ; JHDMI1.2 370.83,96.6 ; JHDMI1.2 369.79,97.06 ; JHDMI1.2 369.79,96.14 ; JHDMI1.2 369.67,96.6 ; 188.21,110.5 HCPU4.1 ; HCPU4.1 192.17,108.83 ; HCPU4.1 188.83,108.83 ; HCPU4.1 190.5,108.21 ; HCPU4.1 188.83,112.17 ; HCPU4.1 192.17,112.17 ; HCPU4.1 192.79,110.5 ; HCPU4.1 190.5,112.79 ; 127.55,74.39 HCPU2.1 ; HCPU2.1 126.89,72.62 ; HCPU2.1 131.09,70.85 ; HCPU2.1 129.32,70.19 ; HCPU2.1 131.09,74.39 ; HCPU2.1 131.75,72.62 ; HCPU2.1 127.55,70.85 ; HCPU2.1 129.32,75.05 ; 15.42,60.42 JUSB3.11 ; JUSB3.11 15.42,62.08 ; JUSB3.11 16.75,62.08 ; JUSB3.11 16.75,61.25 ; JUSB3.11 14.09,60.42 ; JUSB3.11 14.09,61.25 ; JUSB3.11 16.75,60.42 ; JUSB3.11 14.09,62.08 ; JCRT1.16 378.1,132.66 ; JCRT1.16 374.5,131.8 ; JCRT1.16 378.1,130.94 ; JCRT1.16 374.5,130.94 ; JCRT1.16 376.3,132.66 ; JCRT1.16 378.1,131.8 ; JCRT1.16 374.5,132.66 ; JCRT1.16 376.3,130.94 ; JREAD1.15 7.58,56.13 ; JREAD1.15 7.58,55.35 ; JREAD1.15 3.32,55.35 ; JREAD1.15 5.45,56.13 ; JREAD1.15 3.32,56.13 ; JREAD1.15 3.32,54.58 ; JREAD1.15 5.45,54.58 ; JREAD1.15 7.58,54.58 ; JUSB2.10 366.58,22.53 ; JUSB2.10 365.25,21.7 ; JUSB2.10 367.91,20.87 ; JUSB2.10 365.25,22.53 ; JUSB2.10 365.25,20.87 ; JUSB2.10 366.58,20.87 ; JUSB2.10 367.91,21.7 ; JUSB2.10 367.91,22.53 ; JLAN.12 10.55,99.07 ; JLAN.12 9.37,98.4 ; JLAN.12 10.55,97.73 ; JLAN.12 9.37,99.07 ; JLAN.12 11.73,98.4 ; JLAN.12 11.73,97.73 ; JLAN.12 9.37,97.73 ; JLAN.12 11.73,99.07 ; JUSBC1.5 377.77,75.45 ; JUSBC1.5 377.05,73.44 ; JUSBC1.5 376.33,75.45 ; JUSBC1.5 376.33,73.44 ; JUSBC1.5 377.05,75.45 ; JUSBC1.5 377.77,73.44 ; JUSBC1.5 377.77,74.35 ; 115.37,137.3 H7.1 ; H7.1 117.2,139.13 ; H7.1 118.54,135.96 ; H7.1 117.2,135.47 ; H7.1 115.86,138.64 ; H7.1 119.03,137.3 ; H7.1 115.86,135.96 ; H7.1 118.54,138.64 ; 371.22,92.1 JHDMI1.11 ; JHDMI1.11 371.34,92.56 ; JHDMI1.11 372.26,91.64 ; JHDMI1.11 372.26,92.56 ; JHDMI1.11 371.34,91.64 ; JHDMI1.11 372.38,92.1 ; JUSB3.4 15.95,64.15 ; JUSB3.4 14.49,64.79 ; JUSB3.4 15.76,63.52 ; JUSB3.4 15.12,63.32 ; JUSB3.4 15.76,64.79 ; JUSB3.4 15.12,64.98 ; 260.47,137.3 H11.1 ; H11.1 262.3,139.13 ; H11.1 263.64,138.64 ; H11.1 260.96,135.96 ; H11.1 264.13,137.3 ; H11.1 260.96,138.64 ; H11.1 263.64,135.96 ; H11.1 262.3,135.47 ; 370.32,84.37 JHDMI1.23 ; JHDMI1.23 371.65,86.33 ; JHDMI1.23 370.32,85.35 ; JHDMI1.23 370.32,86.33 ; JHDMI1.23 372.98,85.35 ; JHDMI1.23 372.98,86.33 ; JHDMI1.23 372.98,84.37 ; JHDMI1.23 371.65,84.37 ; 186.46,72.7 HCPU3.1 ; HCPU3.1 187.08,74.37 ; HCPU3.1 187.08,71.03 ; HCPU3.1 190.42,71.03 ; HCPU3.1 188.75,74.99 ; HCPU3.1 191.04,72.7 ; HCPU3.1 190.42,74.37 ; HCPU3.1 188.75,70.41 ; H4.1 24.5,30.83 ; H4.1 22.67,29 ; H4.1 23.16,30.34 ; H4.1 26.33,29 ; H4.1 25.84,30.34 ; H4.1 25.84,27.66 ; H4.1 23.16,27.66 ; H4.1 24.5,27.17 ; JUSB2.11 366.58,35.33 ; JUSB2.11 367.91,35.33 ; JUSB2.11 367.91,33.67 ; JUSB2.11 367.91,34.5 ; JUSB2.11 365.25,34.5 ; JUSB2.11 365.25,33.67 ; JUSB2.11 365.25,35.33 ; JUSB2.11 366.58,33.67 ; 368.38,27.27 JUSB2.7 ; JUSB2.7 367.75,27.47 ; JUSB2.7 367.75,28.74 ; JUSB2.7 368.38,28.93 ; JUSB2.7 367.55,28.1 ; JUSB2.7 369.02,28.74 ; JUSB2.7 369.02,27.47 ; HCPU1.1 132.81,118.52 ; HCPU1.1 134.58,114.32 ; HCPU1.1 134.58,117.86 ; HCPU1.1 130.38,116.09 ; HCPU1.1 135.24,116.09 ; HCPU1.1 131.04,117.86 ; HCPU1.1 132.81,113.66 ; HCPU1.1 131.04,114.32 ; 5.57,78.4 H2.1 ; H2.1 8.74,79.74 ; H2.1 6.06,77.06 ; H2.1 7.4,76.57 ; H2.1 8.74,77.06 ; H2.1 7.4,80.23 ; H2.1 6.06,79.74 ; H2.1 9.23,78.4 ; JUSB1.10 366.58,43.63 ; JUSB1.10 367.91,42.8 ; JUSB1.10 366.58,41.97 ; JUSB1.10 367.91,41.97 ; JUSB1.10 365.25,43.63 ; JUSB1.10 365.25,42.8 ; JUSB1.10 367.91,43.63 ; JUSB1.10 365.25,41.97 ; 7.4,101.47 H1.1 ; H1.1 6.06,104.64 ; H1.1 5.57,103.3 ; H1.1 8.74,104.64 ; H1.1 7.4,105.13 ; H1.1 9.23,103.3 ; H1.1 8.74,101.96 ; H1.1 6.06,101.96 ; 12.98,67.02 JUSB3.7 ; JUSB3.7 12.98,68.29 ; JUSB3.7 14.45,67.65 ; JUSB3.7 14.25,68.29 ; JUSB3.7 14.25,67.02 ; JUSB3.7 13.62,66.82 ; JUSB3.7 13.62,68.48 ; JCRT1.8 376.72,123.41 ; JCRT1.8 375.68,122.38 ; JCRT1.8 376.72,122.38 ; JCRT1.8 375.54,122.9 ; JCRT1.8 376.86,122.9 ; JCRT1.8 375.68,123.41 ; 375.32,75.45 JUSBC1.4 ; JUSBC1.4 375.32,74.67 ; JUSBC1.4 376.55,75.45 ; JUSBC1.4 377.78,74.67 ; JUSBC1.4 377.78,75.45 ; JUSBC1.4 375.32,73.9 ; JUSB3.12 7.35,75.35 ; JUSB3.12 7.35,76.18 ; JUSB3.12 4.99,75.35 ; JUSB3.12 6.17,76.18 ; JUSB3.12 4.99,76.18 ; 374.65,56.9 JUSB1.13 ; JUSB1.13 377.01,57.73 ; JUSB1.13 377.01,56.9 ; JUSB1.13 374.65,57.73 ; JUSB1.13 375.83,57.73 ; 358.57,116.7 H14.1 ; H14.1 358.57,114.87 ; H14.1 362.83,114.87 ; H14.1 362.83,118.53 ; H14.1 360.7,118.53 ; H14.1 362.83,116.7 ; H14.1 358.57,118.53 ; H14.1 360.7,114.87 ; JREAD1.14 7.58,28.28 ; JREAD1.14 7.58,29.83 ; JREAD1.14 3.32,29.05 ; JREAD1.14 3.32,29.83 ; JREAD1.14 5.45,28.28 ; JREAD1.14 7.58,29.05 ; JREAD1.14 3.32,28.28 ; JREAD1.14 5.45,29.83 ; 374.5,111.7 JCRT1.17 ; JCRT1.17 376.3,110.84 ; JCRT1.17 374.5,112.56 ; JCRT1.17 378.1,111.7 ; JCRT1.17 378.1,112.56 ; JCRT1.17 376.3,112.56 ; JCRT1.17 378.1,110.84 ; JCRT1.17 374.5,110.84 ; 309.8,41.03 H13.1 ; H13.1 311.32,40.47 ; H13.1 313.4,42.55 ; H13.1 312.84,44.07 ; H13.1 312.84,41.03 ; H13.1 309.8,44.07 ; H13.1 311.32,44.63 ; H13.1 309.24,42.55 ; H19.1 379.43,61.23 ; H19.1 377.5,59.3 ; H19.1 377.5,63.16 ; H19.1 378.92,62.65 ; H19.1 376.08,62.65 ; H19.1 378.92,59.81 ; H19.1 375.57,61.23 ; H19.1 376.08,59.81 ; HGPU2.1 273.88,72.51 ; HGPU2.1 269.68,70.74 ; HGPU2.1 273.22,70.74 ; HGPU2.1 271.45,70.08 ; HGPU2.1 269.02,72.51 ; HGPU2.1 273.22,74.28 ; HGPU2.1 271.45,74.94 ; HGPU2.1 269.68,74.28 ; H15.1 358.84,78.56 ; H15.1 357.5,78.07 ; H15.1 358.84,81.24 ; H15.1 357.5,81.73 ; H15.1 356.16,81.24 ; H15.1 359.33,79.9 ; H15.1 356.16,78.56 ; H15.1 355.67,79.9 ; 380.18,73.84 JUSBC1.6 ; JUSBC1.6 380.18,74.67 ; JUSBC1.6 381.6,75.5 ; JUSBC1.6 381.6,73.84 ; JUSBC1.6 380.18,75.5 ; HGPU1.1 253.76,132.43 ; HGPU1.1 251.33,130 ; HGPU1.1 255.53,128.23 ; HGPU1.1 256.19,130 ; HGPU1.1 251.99,131.77 ; HGPU1.1 253.76,127.57 ; HGPU1.1 251.99,128.23 ; HGPU1.1 255.53,131.77 ; JCRT1.10 376.72,117.8 ; JCRT1.10 375.54,118.32 ; JCRT1.10 376.72,118.83 ; JCRT1.10 375.68,117.8 ; JCRT1.10 375.68,118.83 ; JCRT1.10 376.86,118.32 ; 375.83,40.67 JUSB1.12 ; JUSB1.12 374.65,41.5 ; JUSB1.12 374.65,40.67 ; JUSB1.12 377.01,41.5 ; JUSB1.12 377.01,40.67 ; 375.54,127.48 JCRT1.6 ; JCRT1.6 375.68,127.99 ; JCRT1.6 376.2,128.14 ; JCRT1.6 376.72,126.96 ; JCRT1.6 376.72,127.99 ; JCRT1.6 375.68,126.96 ; JCRT1.6 376.86,127.48 ; H16.1 377.83,139 ; H16.1 377.34,137.66 ; H16.1 377.34,140.34 ; H16.1 374.17,139 ; H16.1 374.66,140.34 ; H16.1 376,137.17 ; H16.1 374.66,137.66 ; H16.1 376,140.83 ; JUSB1.11 367.91,56.43 ; JUSB1.11 365.25,56.43 ; JUSB1.11 366.58,54.77 ; JUSB1.11 366.58,56.43 ; JUSB1.11 365.25,54.77 ; JUSB1.11 365.25,55.6 ; JUSB1.11 367.91,55.6 ; JUSB1.11 367.91,54.77 ; 71.9,60.52 H5.1 ; H5.1 74.94,57.48 ; H5.1 71.34,59 ; H5.1 74.94,60.52 ; H5.1 73.42,61.08 ; H5.1 75.5,59 ; H5.1 71.9,57.48 ; H5.1 73.42,56.92 ; 14.09,73.22 JUSB3.10 ; JUSB3.10 15.42,73.22 ; JUSB3.10 14.09,74.88 ; JUSB3.10 16.75,74.05 ; JUSB3.10 16.75,73.22 ; JUSB3.10 15.42,74.88 ; JUSB3.10 16.75,74.88 ; JUSB3.10 14.09,74.05 ; 376.08,80.89 H18.1 ; H18.1 378.92,80.89 ; H18.1 378.92,78.05 ; H18.1 375.57,79.47 ; H18.1 377.5,81.4 ; H18.1 379.43,79.47 ; H18.1 377.5,77.54 ; H18.1 376.08,78.05 ; JHDMI1.17 372.26,88.64 ; JHDMI1.17 371.22,89.1 ; JHDMI1.17 372.38,89.1 ; JHDMI1.17 372.26,89.56 ; JHDMI1.17 371.34,89.56 ; JHDMI1.17 371.34,88.64 ; 367.75,49.84 JUSB1.7 ; JUSB1.7 369.02,48.57 ; JUSB1.7 369.02,49.84 ; JUSB1.7 367.75,48.57 ; JUSB1.7 368.38,48.37 ; JUSB1.7 368.38,50.03 ; JUSB1.7 367.55,49.2 ; 378.27,102.33 JHDMI1.20 ; JHDMI1.20 380,102.33 ; JHDMI1.20 378.27,101.35 ; JHDMI1.20 381.73,101.35 ; JHDMI1.20 381.73,102.33 ; 380.18,66.03 JUSBC1.3 ; JUSBC1.3 380.18,65.2 ; JUSBC1.3 381.6,66.86 ; JUSBC1.3 381.6,65.2 ; JUSBC1.3 380.18,66.86 ; 360.42,9 H17.1 ; H17.1 360.91,7.66 ; H17.1 363.59,7.66 ; H17.1 362.25,7.17 ; H17.1 363.59,10.34 ; H17.1 364.08,9 ; JLAN.11 3.93,99.07 ; JLAN.11 2.75,99.07 ; JLAN.11 3.93,97.73 ; JLAN.11 1.57,99.07 ; JLAN.11 1.57,98.4 ; JLAN.11 2.75,97.73 ; JLAN.11 1.57,97.73 ; JLAN.11 3.93,98.4 ; 6.06,25.34 H3.1 ; H3.1 8.74,25.34 ; H3.1 7.4,25.83 ; H3.1 7.4,22.17 ; H3.1 9.23,24 ; H3.1 6.06,22.66 ; H3.1 5.57,24 ; H3.1 8.74,22.66 ; JUSB2.4 367.52,30.97 ; JUSB2.4 366.25,30.97 ; JUSB2.4 366.25,32.24 ; JUSB2.4 366.88,30.77 ; JUSB2.4 366.88,32.43 ; JUSB2.4 366.05,31.6 ; JUSBC1.2 377.77,65.25 ; JUSBC1.2 377.77,66.36 ; JUSBC1.2 376.33,65.25 ; JUSBC1.2 377.05,67.26 ; JUSBC1.2 377.77,67.26 ; JUSBC1.2 376.33,67.26 ; JUSBC1.2 377.05,65.25 ; 376.55,65.26 JUSBC1.1 ; JUSBC1.1 377.78,65.26 ; JUSBC1.1 375.32,66.03 ; JUSBC1.1 377.78,66.03 ; JUSBC1.1 377.78,66.81 ; JUSBC1.1 375.32,65.26 ; JUSBC1.1 375.32,66.81 ; 380,82.87 JHDMI1.21 ; JHDMI1.21 381.73,82.87 ; JHDMI1.21 378.27,83.85 ; JHDMI1.21 378.27,82.87 ; JHDMI1.21 381.73,83.85 ; 366.25,52.06 JUSB1.4 ; JUSB1.4 367.52,52.06 ; JUSB1.4 366.25,53.33 ; JUSB1.4 366.88,53.53 ; JUSB1.4 366.05,52.7 ; JUSB1.4 366.88,51.87 ; JLAN.9 11.73,80.93 ; JLAN.9 11.73,82.27 ; JLAN.9 9.37,80.93 ; JLAN.9 11.73,81.6 ; JLAN.9 10.55,82.27 ; JLAN.9 9.37,82.27 ; JLAN.9 10.55,80.93 ; JLAN.9 9.37,81.6 ; 371.34,94.64 JHDMI1.5 ; JHDMI1.5 371.34,95.56 ; JHDMI1.5 372.26,94.64 ; JHDMI1.5 372.38,95.1 ; JHDMI1.5 371.22,95.1 ; JHDMI1.5 372.26,95.56 ; 369.79,94.06 JHDMI1.8 ; JHDMI1.8 369.67,93.6 ; JHDMI1.8 370.71,94.06 ; JHDMI1.8 369.79,93.14 ; JHDMI1.8 370.83,93.6 ; JHDMI1.8 370.71,93.14 ; JUSB2.13 377.01,36.63 ; JUSB2.13 375.83,36.63 ; JUSB2.13 374.65,36.63 ; JUSB2.13 374.65,35.8 ; JUSB2.13 377.01,35.8
  BOTTOM w0.089: UG3.C3 UG3.C4 ; UG9.P51 226.65,114.85 226.97,115.17 226.97,115.53 226.86,115.64 226.86,116.62 225.95,117.53 v2(225.95,117.63) ; UG5.C4 UG5.C3
  BOTTOM w0.1: v2(229.58,117.79) 230.2,117.17 v2(230.2,116.95)
  BOTTOM w0.102: v2(351.01,59.94) 351.13,59.82 UT1.A20 UT1.B20 ; UG9.W10 v2(223.15,86.65) ; v2(352.08,59.93) 352.05,59.9 UT1.A18 UT1.B18 ; v2(353.04,59.85) 352.97,59.79 UT1.A16 UT1.B16 ; v2(354.38,59.85) 353.89,59.37 UT1.A14 UT1.B14
  BOTTOM w0.127: UG9.H40 230.2,106.95 v2(230.05,107.1) ; UG9.H40 v2(231.15,107.25) ; UG9.H40 231.15,106.65 v2(231.18,106.65) ; UG9.AH43 v2(216.85,108.35) ; v4(21.83,39.17) v2(21.83,38.39) ; v2(231.71,98.75) 231.51,98.55 UG9.H28 ; v4(16.22,55.9) 15.22,54.9 v2(15.22,54.76) ; UG9.W43 v2(223.15,108.35) ; v2(359.81,86.45) v4(359.03,86.45) ; UG9.BC25 v2(207.05,96.45) ; UG9.F31 232.95,100.65 v2(233.1,100.8) UG9.D31 233.75,100.65 ; v2(81.28,43.45) v4(81.28,44.11) ; v4(15.44,39.46) v2(14.57,39.46) ; v4(363.26,83.1) v2(363.26,83.85) ; v2(230.55,96.15) UG9.H25 v2(231.15,96.75) ; UG9.AH10 v2(216.85,86.65) ; UG9.AL10 v2(214.75,86.65) ; 216.85,109.67 216.85,109.67 UG9.AH45 ; v2(230.4,100.9) 230.15,100.65 UG9.K31 v2(228.75,100.65) ; v2(126.81,107.2) 126.91,107.2 127.75,108.05 v4(127.75,108.27) ; v2(232.69,102.59) 232.81,102.59 v2(233.25,103.03) ; v2(25.66,35.96) 27.18,35.96 v4(27.26,36.03) ; UG9.BC31 v2(207.05,100.65) ; UG6.R11 UG6.R12 ; UG9.K40 v2(228.75,106.95) ; UG9.AL43 v2(214.75,108.35) ; UG9.BC19 v2(207.05,92.25) ; UG9.AY51 208.45,115.32 v2(208.3,115.47) ; v4(279.64,75.44) 279.02,75.44 v2(278.87,75.59) ; UG9.K19 v2(228.75,92.25) ; v4(348.21,5.36) v2(347.38,5.36) ; UG9.BC28 v2(207.05,98.55)
  BOTTOM w0.13: v2(220.79,110.8) 221.05,111.06 UG9.AB47
  BOTTOM w0.14: v2(372.02,69.69) 372.47,69.24 372.76,69.24 DT2.2
  BOTTOM w0.15: v2(201.3,84) 201.45,83.85 UG9.BJ7 ; v2(212.95,112.15) 212.65,112.45 UG9.AP49 ; v2(232.61,118.89) 232.65,118.85 v2(232.65,118.17) 232.46,117.98 232.46,116.21 v2(232.25,116) ; UG9.BC13 207.04,88.05 v2(207.11,87.98) ; v2(233.95,105.15) 234.1,105.15 v2(234.56,104.69) ; v2(230.39,98.73) 230.39,98.69 230.25,98.55 UG9.K28 v2(228.75,98.55) ; v2(230,90.35) 229.65,90.35 UG9.K16 v2(228.75,90.15) ; v2(207.05,102.73) 207.03,102.73 207.01,102.75 UG9.BC34 ; UG9.AB10 v2(221.05,86.65) ; UG9.BC16 v2(207.05,90.15) ; v2(210.85,112.15) UG9.AU47 ; UG9.AU47 UG9.AU45 ; UG9.AU47 v2(210.25,112.15) 210.55,112.45 UG9.AU49 ; v2(232.6,108.74) 232.91,109.05 UG9.D43 ; UG9.BC37 v2(207.05,104.85) ; UG9.AP47 212.65,111.17 ; v2(228.75,94.35) UG9.K22 ; UG9.K34 v2(228.75,102.75) ; UG9.AB43 v2(221.05,108.35) ; v2(232.65,112.25) UG9.E48 v2(232.65,112.85) ; v2(218.65,112.15) UG9.AE47 v2(219.25,112.15) ; v2(225.25,108.35) UG9.T43 UG9.T45 ; v2(227.58,110.97) 227.58,110.97 227.6,110.97 227.6,110.7 UG9.N45 v2(227.05,110.75) ; UG9.D16 233.99,90.49 234.39,90.49 v2(234.62,90.25) ; v2(224.92,110.81) 225.25,111.14 UG9.T47 ; v2(212.65,86.65) UG9.AP10 ; UG9.F44 232.6,110.1 232.6,110.82 v2(232.6,110.82) ; v2(233.95,113.55) UG9.D49 v2(233.95,112.95) ; v2(218.61,84.9) 218.95,85.24 UG9.AE10 v2(218.95,86.65) ; UG9.AE43 v2(218.95,108.35) ; v2(212.76,109.67) 212.65,109.78 UG9.AP45 ; UG9.BC22 v2(207.05,94.35) ; v2(228.75,96.45) UG9.K25 ; v2(231.93,100.36) 231.83,100.36 231.53,100.65 UG9.H31 ; UG9.N43 v2(227.35,108.35) ; v2(227.35,86.65) UG9.N10 ; UG9.K37 v2(228.75,104.85) ; v2(225.25,86.65) UG9.T10 ; v2(212.65,108.35) UG9.AP43 ; v2(210.55,86.65) UG9.AU10 ; v2(233.25,98.72) 232.78,98.25 v2(232.55,98.25) UG9.F28 232.23,98.57 232.14,98.57 232.13,98.58 231.89,98.58 v2(231.71,98.75) ; 216.85,109.67 v2(217.15,109.38) ; v2(216.55,110.75) 217,111.2 v2(217,111.42) ; UG9.K13 v2(228.75,88.05)
  BOTTOM w0.152: UH2.AH45 274.73,38.96 274.64,39.05 v2(274.64,39.05) ; v2(274.73,41.32) 275.08,41.32 UH2.AC45 ; UH2.AC1 297.16,41.22 297.43,41.49 297.92,41.49 v2(297.98,41.56) ; 284.76,51.07 v2(284.86,50.97) 284.76,50.97 284.76,51.07 ; 284.76,51.07 UH2.B25 UH2.A25 ; v2(280.7,29.85) 280.87,29.85 UH2.BE32 ; UH2.BE14 290.41,30.3 v2(290.41,29.34) ; UH1.G26 176.36,96.68 176.07,96.97 176.07,97.92 UH1.G28 ; UH2.A18 288.27,52.44 v2(288.38,52.56) ; UH2.AM45 275.12,36.74 v2(275.12,37.11) ; UT4.K9 362.87,72.28 362.37,71.78 v2(362.31,71.78) ; UH2.A32 281.8,52.4 v2(281.8,52.45) ; UT1.B2 UT1.B1 360.05,58.79 360.2,58.95 360.2,59.1 360.05,59.25
  BOTTOM w0.165: UG2.H2 201.03,135.15 200.28,135.15 UG2.H1
  BOTTOM w0.178: UT1.P1 UT1.P2 ; UT1.AC2 UT1.AC1 360.04,49.13 v2(360.39,49.48) 360.28,49.59 UT1.AB1 UT1.AB2 ; v2(349.1,50.83) 349.24,50.97 UT1.W23 UT1.W22 ; 349.94,59.59 350.21,59.31 UT1.A22 350.18,59.22 350.18,58.83 UT1.B22 ; UT1.AB12 UT1.AC12 354.81,48.92 354.83,48.91 354.83,48.87 354.99,48.71 v2(354.99,48.42) ; UT1.T1 UT1.T2 359.24,52.35 v2(359.02,52.57) ; v2(349.1,51.78) 349.21,51.89 UT1.U23 UT1.U22 ; v2(351.91,48.46) 351.91,48.72 352.05,48.85 352.05,49.08 352.05,49.08 UT1.AC18 UT1.AB18 ; UT1.C23 UT1.C22 ; v2(349.03,55.66) 349.12,55.57 UT1.J23 UT1.J22 ; UT1.H2 UT1.H1 359.9,56.03 360.4,55.53 v2(360.4,55.4) 360.12,55.11 UT1.K1 UT1.K2 ; v2(349.32,49.84) 349.31,49.84 349.31,49.88 349.49,50.05 UT1.AA23 UT1.AA22 ; v2(349.41,48.75) 349.92,48.75 350.21,49.05 UT1.AC22 UT1.AB22 ; UT1.M2 UT1.M1 ; v2(356.15,48.35) 356.15,48.48 355.73,48.89 UT1.AC10 UT1.AB10 ; v2(350.75,48.35) 351.13,48.74 UT1.AC20 UT1.AB20 ; v2(349.23,54.64) 349.24,54.65 UT1.L23 UT1.L22 ; v2(354.08,48.48) 353.94,48.48 353.89,48.52 UT1.AC14 UT1.AB14 ; UT1.G22 UT1.G23 348.86,56.49 v2(348.72,56.63) ; v2(349.25,52.73) 349.34,52.82 349.75,52.82 UT1.R23 UT1.R22 ; UT1.B6 UT1.A6 357.57,59.36 357.06,59.88 v2(356.7,59.88) 356.65,59.83 UT1.A8 UT1.B8 ; UT1.AB16 UT1.AC16 352.97,48.52 352.89,48.43 v2(352.85,48.43) ; v2(355.89,59.78) 355.73,59.62 UT1.A10 UT1.B10 ; UT1.B12 UT1.A12 354.81,59.55 v2(355.07,59.8) ; UT1.E22 UT1.E23 349.56,57.41 349.42,57.56 348.91,57.56 v2(348.46,58) ; UT1.AB6 UT1.AC6 v2(357.57,48.45) ; UT1.N23 UT1.N22 ; UT4.A6 361.44,67.63 361.82,67.25 361.87,67.25 v2(362.05,67.07) ; UT1.AC8 UT1.AB8
  BOTTOM w0.2: UG9.B16 234.72,90.15 v2(234.62,90.25) ; UG9.K22 v2(229.75,94.65) ; UG9.AP45 212.45,110.65 v2(212.45,110.92) 212.65,111.11 212.65,111.17
  BOTTOM w0.203: v2(167.09,86.32) 166.99,86.32 UH1.Y14 ; v2(167.09,86.32) 167.13,86.28 167.13,85.82 167.58,85.38 UH1.W12 ; v2(167.09,86.32) 166.77,86 UH1.Y13 ; UT1.AB6 357.56,49.59 357.25,49.91 357.13,49.91 357.12,49.92 356.98,49.92 UT1.AB8 356.65,49.75 UT1.Y9 355.73,49.91 UT1.AB10 ; v2(176.07,95.53) 175.71,95.89 UH1.H25 UH1.J25 ; UH2.BE9 292.83,29.36 v2(293.21,28.98) ; UH1.BE3 UH1.BE4 UH1.BE5 147.38,81.11 v2(147.45,81.11) ; UH1.BE3 v2(146.56,79.17) ; UH1.BE3 UH1.BE2 UH1.BE1 147.05,77.67 v2(146.61,77.23) ; UH1.C27 178.95,97.46 178.67,97.18 v2(178.67,97.08) 178.67,97.03 178.35,96.71 UH1.D26 179,96.03 UH1.C25 ; UH1.A6 180.16,81.73 179.72,81.28 179.5,81.28 179.19,80.98 179.05,80.98 UH1.C5 178.51,80.44 178.23,80.44 v2(178.18,80.39) ; v2(179.32,82.9) 179.65,83.22 UH1.B9 UH1.A9 ; v2(179.32,82.9) 179,82.57 UH1.C8 179,82.37 UH1.D6 ; v2(179.32,82.9) 179,83.22 UH1.C9 178.95,83.34 178.4,83.34 ; UH1.AV37 152.57,104.16 v2(152.89,104.49) 152.56,104.81 UH1.AV38 ; UH1.BM18 142.27,90.08 v2(141.95,89.76) 141.62,90.08 UH1.BN18 141.47,90 141.12,90 UH1.BP18 140.84,90.02 140.45,90.02 UH1.BR18 140.17,90 139.82,90 UH1.BT18 139.49,89.97 139.05,89.97 v2(138.91,90.11) ; UH1.F36 176.77,103.51 UH1.H35 175.98,102.86 UH1.J36 ; UH1.F36 176.91,103.52 177.29,103.91 177.29,104.52 177.4,104.63 UH1.E38 177.4,105.38 177.52,105.5 v2(177.52,105.87) ; UH1.F36 177.04,103.51 UH1.E35 177.69,102.19 UH1.E34 ; UH2.BE40 277.53,29.69 277.46,29.62 v2(277.46,29.45) ; UH1.G5 176.4,80.83 176.4,81.39 UH1.G6 176.41,81.49 176.41,81.97 v2(176.4,81.98) UH1.G8 ; UH1.G5 176.28,80.79 175.96,80.46 175.87,80.46 UH1.J4 ; UH1.G5 176.88,80.79 UH1.F5 ; 174.71,79.23 v2(174.31,79.23) ; 174.71,79.23 UH1.K2 174.78,78.84 v2(175.13,78.49) 175.09,78.49 174.79,78.19 UH1.K1 ; 174.71,79.23 UH1.K3 UH1.K4 ; UH1.A18 v2(180.93,90.38) ; UH1.BM35 142.39,102.86 UH1.BL35 ; 299.82,49.07 299.67,49.22 299.39,49.22 298.81,49.8 298.81,50.62 298.81,50.99 298.7,51.11 ; v2(176.7,93.94) 176.4,94.24 UH1.G23 176.72,94.64 ; UH1.T12 UH1.T11 ; UH1.T12 UH1.T13 ; UH1.T12 169.58,85.35 v2(169.86,85.06) 170.03,85.06 UH1.R12 170.58,85.61 170.98,85.61 UH1.P12 171.45,85.57 171.93,85.57 UH1.N12 ; UH1.T12 169.24,85.52 168.66,85.52 UH1.V12 ; UH1.T11 169.6,84.7 v2(169.87,84.42) 169.78,84.42 UH1.T10 ; UH1.T11 UH1.T10 ; UH2.B6 294.44,51.09 294.43,51.08 ; v2(176.73,90.77) 177.05,91.09 UH1.F19 177.05,91.24 v2(176.72,91.56) 176.72,91.63 UH1.G20 ; v2(283.23,29.29) 283.23,29.71 283.71,30.18 UH2.BE28 ; UH1.BR38 140.11,104.96 v2(140.11,105.47) ; v2(179.32,89.2) 179,89.52 UH1.C17 179,89.73 UH1.D18 ; UH1.N11 172.27,84.7 v2(172.61,85.03) ; UH1.N11 UH1.N12 ; UH1.N11 UH1.N10 ; UH1.F4 UH1.G4 176.3,80.14 175.97,79.8 175.92,79.8 175.59,80.14 UH1.J4 ; UH1.F4 UH1.E4 177.93,80.14 v2(178.18,80.39) ; UH1.F4 177.04,79.83 177.14,79.72 UH1.F3 177.07,79.49 176.74,79.16 176.81,79.16 UH1.F2 ; UG9.F40 232.48,107.18 v2(232.72,107.18) ; UH1.AR13 155.1,86.32 v2(155.23,86.32) 154.91,86.65 UH1.AR14 154.65,86.65 v2(154.32,86.32) ; UH1.BG38 v2(145.8,105.14) ; 169.75,83.79 v2(169.88,83.79) ; 169.75,83.79 169.41,83.45 ; 169.75,83.79 169.67,83.79 UH1.T10 ; UH1.N12 172.29,85.35 v2(172.61,85.03) ; UH1.K38 174.54,105.17 v2(175.31,105.93) ; v2(180.6,98.61) 180.6,98.55 UH1.A28 ; v2(287.07,31.48) 287.21,31.63 UH2.BB21 ; UH1.BE6 147.46,81.85 UH1.BD7 UH1.BD8 v2(147.92,83.15) UH1.BD9 v2(147.92,83.79) UH1.BD10 v2(147.92,84.42) UH1.BD11 147.93,85.07 147.93,85.05 ; UH1.BE6 UH1.BF6 UH1.BG6 UH1.BH6 ; UH1.BE6 v2(147.45,81.11) ; UH1.BN14 UH1.BP14 140.97,87.07 v2(140.64,87.39) 140.32,87.07 UH1.BR14 140.2,87.12 139.79,87.12 UH1.BT14 ; UH1.BJ31 143.77,100.26 v2(143.44,99.93) 143.84,99.54 UH1.BJ30 143.97,99.43 UH1.BK29 143.35,98.81 UH1.BL29 UH1.BM29 ; v2(156.15,83.15) 155.94,83.15 UH1.AP9 ; v2(156.15,83.15) v2(156.15,83.79) ; v2(156.15,83.15) 155.74,82.75 UH1.AP8 156.13,82.31 156.13,81.58 UH1.AN6 156.22,81.39 UH1.AN5 ; UH1.AD8 163.95,82.78 163.95,83.37 UH1.AD9 ; UH1.AD8 163.82,82.74 163.47,83.03 v2(163.42,83.02) ; UH1.AD8 UH1.AD7 ; v2(156.15,84.42) 156.15,84.42 v2(156.15,83.79) ; v2(156.15,84.42) 156.15,85.06 v2(156.15,85.06) 156.05,85.06 UH1.AP11 155.97,84.42 v2(156.15,84.42) ; 176.72,94.64 UH1.F23 177.05,94.25 v2(177.37,93.92) ; 176.72,94.64 176.72,94.78 UH1.G24 ; UH1.K5 174.75,80.75 174.75,80.17 UH1.K4 ; UH1.BA8 UH1.BA7 150.21,82.08 UH1.BB6 ; UH1.BA8 v2(150.66,83.15) ; UH1.BA8 UH1.BA9 ; v2(144.76,96.04) 144.38,95.66 UH1.BJ25 UH1.BK25 ; 260.03,93.98 260.77,93.98 v2(260.8,93.95) ; 260.03,93.98 UG6.N14 ; 260.03,93.98 260.03,94.72 v2(260,94.75) ; v2(161.6,85.02) 161.5,85.02 UH1.AG11 ; UH1.AY33 150.99,101.56 v2(151.32,101.88) 150.99,102.21 UH1.AY34 ; UH1.AE34 UH1.AE33 v2(163.13,101.23) ; v2(180.87,84.04) 180.83,84.08 UH1.A10 ; UH1.BM5 142.09,80.71 UH1.BN4 ; UH1.BM5 142.17,80.71 v2(142.4,80.26) 142.23,79.92 UH1.BM3 UH1.BM2 UH1.BN2 141.66,78.76 141.87,78.54 v2(142.13,78.54) ; UH1.BM5 142.07,80.81 UH1.BM6 142.15,81.44 UH1.BL6 ; UH1.BR29 140.36,98.85 140.93,98.85 UH1.BP29 141.07,98.91 141.52,98.91 UH1.BN29 UH1.BM29 ; UH2.AU1 297.15,34.38 297.46,34.07 297.51,34.07 v2(297.53,34.09) ; UH1.BK18 UH1.BJ18 144.66,90.15 v2(144.81,89.99) ; v2(172.61,85.03) 172.93,85.35 UH1.M12 UH1.M13 UH1.M14 ; UH1.AU33 153.35,101.56 v2(153.68,101.23) ; UT4.L1 358.47,73.26 v2(357.84,73.26) ; UH1.BK22 UH1.BJ22 144.73,93.3 v2(144.78,93.35) ; UH1.BF34 146.26,102.21 v2(146.59,101.88) 146.27,101.56 UH1.BF33 ; UH1.A22 v2(180.93,93.53) ; 149.11,81 149.09,81.15 UH1.BC6 UH1.BD6 v2(147.45,81.11) ; 149.11,81 v2(149.12,81) ; 149.11,81 149.22,81.11 149.24,81.11 UH1.BB6 ; v2(139.08,103.5) UH1.BT36 140.21,103.5 UH1.BR36 ; UH1.L33 173.83,101.56 v2(174.15,101.88) 173.82,102.21 UH1.L34 ; UH1.J22 UH1.H22 175.73,93.49 176.36,93.49 UH1.G22 176.72,93.2 v2(176.72,93.14) 176.72,93.07 UH1.F21 177.37,92.42 v2(177.37,92.35) ; UH1.AJ4 UH1.AJ5 UH1.AJ6 UH1.AH6 UH1.AG6 ; UH1.AJ4 UH1.AJ3 159.51,79.49 v2(159.18,79.16) 159.27,79.16 159.59,78.84 UH1.AJ2 159.67,78.8 159.67,78.23 UH1.AJ1 v2(159.62,77.7) ; UH1.AJ4 159.42,79.94 158.94,79.94 UH1.AK4 158.6,80 158.13,80 UH1.AL4 ; v2(164.38,83.77) 164.3,83.77 UH1.AD9 ; v2(178.18,80.39) 178.26,80.31 178.26,79.85 178.48,79.64 UH1.D3 178.57,79.52 v2(179.04,79.52) ; v2(180.58,97.06) 180.3,96.78 UH1.A26 ; UH1.AM5 UH1.AM4 157.14,80.1 157.14,79.52 UH1.AM3 UH1.AM2 UH1.AM1 157.11,77.71 v2(157.17,77.66) ; UH2.AH1 297.44,38.95 v2(297.45,38.94) ; UH1.E9 177.7,83.22 v2(177.37,82.9) ; v2(166.72,79.19) UH1.W3 ; UH1.W3 167.2,79.46 167.2,78.87 UH1.W2 UH1.W1 167.17,77.7 v2(166.72,77.26) ; UH1.W3 UH1.W4 UH1.W5 167.82,81.44 UH1.V6 UH1.U6 168.84,81.53 UH1.T7 UH1.T8 UH1.T9 169.41,83.45 ; UH1.T10 169.41,83.45 ; UH1.D20 179,91.3 UH1.C19 179,91.1 v2(178.67,90.77) ; UH1.AD9 UH1.AD10 ; UH1.AD10 164.3,84.42 v2(164.38,84.42) v2(164.38,85.06) 164.28,85.06 UH1.AD11 163.92,84.7 163.92,84.05 UH1.AD10 ; UH1.N10 172.27,84.05 v2(172.61,84.38) ; UH1.N10 172.13,84.03 172.13,83.42 UH1.N9 172.46,83.7 v2(172.6,83.7) 172.63,83.67 172.63,83.23 UH1.N8 UH1.N7 172.2,82.05 UH1.N6 ; UH1.T33 v2(170.21,101.88) 169.88,102.21 UH1.T34 ; UH1.AL34 157.94,102.21 v2(157.62,101.88) 157.94,101.56 UH1.AL33 ; UH1.AC38 v2(164.7,105.14) ; UH1.AG6 161.18,81.56 UH1.AG7 UH1.AG8 ; UH1.AG6 v2(161.67,81.8) ; 152.48,81.76 152.48,81.74 152.91,82.1 UH1.AU7 ; 152.48,81.76 152.9,81.5 UH1.AU6 152.27,80.79 UH1.AW5 UH1.AW4 UH1.AW3 ; 152.48,81.76 v2(152.48,81.78) ; UH1.AG10 161.55,84.42 v2(161.64,84.42) ; UH1.AU11 153.39,84.44 153.39,84.4 v2(153.42,84.39) ; UH1.AU11 UH1.AU12 ; UH1.AU11 UH1.AU10 ; UH1.F11 177.05,84.78 v2(176.75,84.48) ; UG12.11 216.33,73.62 216.26,73.69 216.26,73.71 v2(216.27,73.71) ; UH1.F9 177.05,83.22 v2(177.37,82.9) ; UH2.BE18 288.12,30.28 288.12,30.05 v2(288.07,29.99) ; UH1.K4 UH1.J4 ; UH1.AM38 157.29,104.81 v2(157.62,104.49) 157.29,104.16 UH1.AM37 ; v2(157.98,86.96) 158.12,86.96 UH1.AL14 ; UH1.BJ29 144.33,98.68 v2(144.65,98.36) ; v2(171.73,81.79) 171.38,81.44 UH1.P6 ; UH2.P45 275.17,46.21 275.49,46.53 275.89,46.53 275.93,46.57 276.48,46.57 ; v2(177.37,82.9) 177.05,82.57 UH1.F8 UH1.G8 ; UH1.G8 176.34,82.45 176.04,82.45 UH1.J7 175.52,81.92 174.92,81.92 UH1.K7 v2(175.23,82.39) 174.87,82.75 UH1.K8 174.87,82.8 174.87,83.34 UH1.K9 174.89,83.47 174.89,83.97 UH1.K10 ; UH1.N1 UH1.N2 UH1.N3 UH1.N4 UH1.N5 UH1.N6 ; v2(179.04,79.52) 179.09,79.57 UH1.B3 179.73,79.44 UH1.A3 UH1.A4 ; v2(179.04,79.52) 179.04,78.99 UH1.C2 ; UH1.AP10 155.95,83.79 v2(156.15,83.79) ; UG9.B40 234.65,106.95 v2(234.5,106.8) ; UH1.M6 UH1.N6 ; UH1.BR34 UH1.BP34 UH1.BN34 ; UH1.Y10 UH1.Y11 166.85,84.7 v2(167.13,84.42) 167.04,84.42 UH1.Y10 ; UH1.Y10 UH1.Y9 UH1.Y8 ; UH1.BN21 141.62,92.58 v2(141.95,92.9) 141.95,92.84 UH1.BM21 142.6,92.84 v2(142.6,92.9) ; UH1.BN21 141.56,92.45 141.03,92.45 UH1.BP21 ; UH1.BN21 UH1.BN20 141.77,91.57 141.77,91.09 UH1.BN19 ; UH1.BA9 UH1.BA10 v2(150.67,84.42) UH1.BA11 v2(150.66,85.06) ; UH1.BA9 v2(150.66,83.79) ; UT1.C22 UT1.B22 ; UH1.Y38 v2(167.06,104.49) UH1.Y37 ; UH1.AU7 UH1.AU8 UH1.AU9 ; UH1.AU7 153.61,81.44 UH1.AT6 ; v2(141.94,100) 141.94,100.07 UH1.BN31 140.97,101.04 UH1.BP33 ; v2(167.87,101.87) 167.52,102.21 UH1.W34 ; UH1.BH9 145.13,83.81 v2(145.14,83.81) ; UH1.BH9 UH1.BH10 v2(145.18,84.42) UH1.BH11 ; UH1.BH9 UH1.BH8 ; v2(147.92,86.97) 148.24,86.65 UH1.BC14 UH1.BC13 ; UH1.BM12 141.95,85.1 v2(141.95,85.03) UH1.BM11 142.27,84.57 141.94,84.24 v2(141.94,84.23) ; UH1.BL38 143.12,104.85 v2(142.78,105.19) 142.41,104.82 UH1.BM38 ; UH1.T3 UH1.T4 UH1.T5 ; UH1.T3 169.55,79.49 v2(169.24,79.18) ; UH1.T3 UH1.T2 UH1.T1 169.68,77.6 169.41,77.32 169.33,77.32 169.33,77.28 v2(169.22,77.28) ; UH1.BH6 144.21,81.11 v2(144.09,81.11) ; UH1.BH6 UH1.BH7 UH1.BH8 ; UH1.D16 179,88.15 UH1.C15 179,87.95 v2(179.32,87.62) ; v2(151.64,78.51) 151.96,78.19 UH1.AW1 152.11,78.21 152.11,78.81 UH1.AW2 152.12,78.87 152.12,79.45 UH1.AW3 ; UH1.A12 v2(180.93,85.65) ; UH1.BM7 142.2,82.35 142.2,82.99 UH1.BM8 142.18,83.16 142.18,83.76 UH1.BM9 142.27,83.9 v2(141.94,84.23) ; UH1.BM7 UH1.BL6 ; UH1.BM7 UH1.BN7 UH1.BP7 UH1.BR7 ; UH1.AR37 154.92,104.16 v2(155.25,103.84) ; UH1.Y8 167.04,83.12 v2(167.13,83.12) ; UH1.Y8 UH1.Y7 166.49,82.1 165.83,81.44 UH1.AB6 UH1.AC6 UH1.AC5 UH1.AC4 164.51,80.14 v2(164.21,79.84) 164.56,79.49 UH1.AC3 UH1.AC2 UH1.AC1 ; v2(138.47,81.05) 138.52,81 UH1.BT5 ; UT1.E4 358.95,57.44 359.05,57.54 359.05,58.24 358.96,58.33 358.86,58.43 358.4,58.43 UT1.D5 ; UH1.C31 178.66,100.95 v2(178.66,100.99) 178.66,101.09 UH1.D33 177.94,100.99 177.33,100.99 177.05,100.71 UH1.F31 ; UH1.AW3 151.96,79.49 v2(151.64,79.16) ; UH2.BE37 279.14,29.94 v2(279.1,29.91) ; UH1.A30 180.3,99.79 v2(180.65,99.44) ; UH1.BN9 141.62,83.91 141.94,84.23 v2(141.94,84.23) ; v2(173.38,99.95) 173.41,99.95 173.76,99.6 UH1.L30 UH1.L29 ; UH1.A14 v2(180.85,87.23) ; UH1.A24 180.9,95.1 v2(180.95,95.15) ; UH1.AU10 v2(153.41,83.79) ; UH1.AU10 UH1.AU9 ; UH1.BM23 142.27,94.15 v2(141.95,94.48) 141.62,94.8 UH1.BN24 141.57,94.93 141.02,94.93 UH1.BP24 140.94,94.9 140.35,94.9 UH1.BR24 UH1.BT24 ; v2(274.68,43.63) 274.92,43.63 275.04,43.51 UH2.V45 ; UH1.BM29 UH1.BM28 142.27,97.94 142.6,97.62 v2(142.6,97.6) 142.58,97.6 142.27,97.29 UH1.BM27 ; UH1.AB33 v2(165.49,101.88) UH1.AB34 ; UH1.AL9 158.5,83.4 v2(158.89,83.79) v2(158.89,83.15) 158.49,82.75 UH1.AL8 UH1.AL7 ; UH1.BL6 UH1.BK6 143.76,81.44 v2(144.09,81.11) ; UH1.A20 180.83,91.95 v2(180.93,92.05) ; UH1.BH3 144.13,79.15 v2(144.1,79.15) ; UH1.BH3 144.57,79.45 144.57,78.87 UH1.BH2 144.28,78.58 UH1.BH1 144.28,77.81 v2(144.45,77.64) ; UH1.BH3 UH1.BH4 UH1.BH5 144.41,80.79 v2(144.09,81.11) ; UH1.BD38 147.84,104.81 v2(148.17,104.49) 147.85,104.16 UH1.BD37 ; UH1.BB3 149.59,79.46 149.59,78.86 UH1.BB2 149.58,78.82 149.58,78.2 UH1.BB1 ; UH1.BT9 139.66,83.86 139.22,83.86 v2(138.98,84.1) ; UH2.A4 UH2.A3 ; UH1.BN12 141.57,85.38 141.02,85.38 UH1.BP12 UH1.BR12 UH1.BT12 139.62,85.42 v2(139.23,85.82) ; v2(225.73,140.36) v2(226.51,140.36) ; UH1.BT32 139.31,101.47 v2(139.17,101.47) ; UH1.U38 v2(169.43,104.49) UH1.U37 ; v2(174.5,90.34) 174.53,90.38 UH1.J18 UH1.H18 175.78,90.29 176.31,90.29 UH1.G18 176.72,90.05 v2(176.72,89.99) 177.05,89.66 UH1.F17 177.37,89.27 v2(177.37,89.2) ; JKB1.1 108.58,32.06 108.41,32.24 v2(108.18,32.24) ; UH1.D10 178.47,83.96 178.47,83.41 178.4,83.34 ; 143.26,86.55 143.57,86.86 UH1.BK14 143.57,87 143.21,87.37 v2(143.21,87.4) 143.21,87.42 UH1.BK15 ; 143.26,86.55 143.57,86.24 UH1.BK13 ; 143.26,86.55 UH1.BL13 ; UH1.K11 174.9,84.7 v2(175.23,84.37) ; UH1.AF4 UH1.AF3 162.11,79.37 v2(161.69,79.14) 161.73,79.11 161.74,79.09 162.11,78.83 UH1.AF2 UH1.AF1 v2(162.14,77.64) ; v2(176.07,85.26) 176.4,85.59 UH1.G12 177.05,86.3 UH1.F13 ; v2(176.07,85.26) 175.75,85.59 UH1.H12 ; v2(176.07,85.26) 176.07,85.19 UH1.H11 ; UH1.BB6 UH1.BA6 ; UH1.BB6 149.59,81.41 149.59,80.81 UH1.BB5 149.59,80.76 149.59,80.16 UH1.BB4 ; UH1.AU9 v2(153.47,83.09) ; 178.4,83.34 UH1.D9 ; v2(138.81,92.51) 138.88,92.43 139.59,92.43 UH1.BT21 139.75,92.43 140.24,92.43 UH1.BR21 ; UH1.AP33 155.72,101.56 v2(156.04,101.88) 155.71,102.21 UH1.AP34 ; v2(179.3,86.07) 179,86.37 UH1.C13 179,86.58 UH1.D14 ; v2(145.8,103.84) 145.48,104.16 UH1.BG37 ; UT1.N22 350.72,53.73 UT1.N20 ; UH1.G16 176.72,88.48 v2(176.72,88.41) UH1.F15 176.94,87.88 v2(176.71,87.6) 176.71,87.54 UH1.G14 ; UH1.AC37 v2(164.7,103.84) ; UH1.AE6 163.31,81.1 v2(163.39,81.1) 163.48,81.1 UH1.AD6 ; UH1.AJ38 UH1.AJ37 159.51,104.16 v2(159.19,103.84) ; UH1.AH33 160.44,101.56 v2(160.76,101.88) 160.44,102.21 UH1.AH34 ; UH1.BM25 142.6,95.99 v2(142.6,96.05) 142.6,96.12 UH1.BM26 ; v2(223.85,116.75) 223.71,116.61 223.71,116.15 223.85,116.01 UG9.V52 ; UH1.BH8 v2(145.18,83.07) ; v2(148.95,102.53) 148.63,102.21 UH1.BC34 ; UT1.M1 360.05,54.37 360.07,54.37 360.46,54.77 v2(360.47,54.77) ; UH1.BJ32 143.76,100.91 v2(143.44,101.23) ; v2(155.25,105.14) 154.93,104.81 UH1.AR38 ; v2(148.95,101.23) 148.62,101.56 UH1.BC33 ; UH1.W33 v2(167.85,101.23) ; 171.79,104.49 v2(171.76,104.49) ; 171.79,104.49 UH1.P37 ; 171.79,104.49 UH1.P38 ; v2(274.55,32.32) 274.72,32.32 UH2.AY45 ; UH1.AR1 UH1.AR2 UH1.AR3 UH1.AR4 v2(154.15,80.42) UH1.AR5 ; UH1.AU34 153.36,102.21 v2(153.68,102.53) ; v2(286.4,29.09) 286.4,30.03 286.02,30.41 UH2.BE23 ; UH1.BH14 144.86,86.65 145.19,86.32 v2(145.19,86.33) 145.19,86.34 145.5,86.65 UH1.BG14 UH1.BG13 ; v2(274.66,34.3) 274.75,34.39 UH2.AU45 ; 349.94,59.59 349.42,59.59 v2(349.35,59.53) ; UH1.D22 179,92.88 UH1.C21 179,92.67 v2(179.32,92.35) ; UH1.BA38 150.13,104.74 150.2,104.67 150.2,104.3 150.13,104.23 UH1.BA37 150.46,103.84 v2(150.53,103.84) ; v2(169.87,87) 169.51,86.65 ; UH1.A16 v2(180.91,88.8)
  BOTTOM w0.229: UT4.A1 358.3,67.14 v2(357.98,67.14)
  BOTTOM w0.25: v2(212.95,112.15) UG9.AP47 ; UG9.F17 232.55,90.55 v2(232.55,90.5) 232.55,90.45 UG9.F16 ; v2(233.27,89.96) 233.46,89.96 UG9.D16 ; v2(208.85,115.65) 208.48,115.65 v2(208.3,115.47) ; v2(236.24,97.2) 236.19,97.15 UG9.A26 ; v2(221.24,109.63) 221.24,109.24 UG9.AB43 ; v2(212.76,109.67) 212.79,109.64 212.79,109.19 UG9.AP43 ; v2(227.51,109.45) 227.51,109.26 227.35,109.1 UG9.N43 ; UG9.BH5 v2(203.17,82.77) ; UG9.BD35 v2(205.95,103.15) ; UG9.BD32 v2(205.95,101.05) ; v2(216.94,114.02) 216.78,113.86 216.78,113.32 UG9.AH49 216.97,113.13 v2(216.97,112.68) ; UG9.BE33 v2(205.25,102.35) ; UG9.A32 236.15,101.35 v2(236.2,101.3) ; UG9.BH2 v2(202.55,80.05) ; UG1.A12 220.45,142.46 220.44,142.46 220.19,142.71 v2(220.15,142.71) ; v2(230.2,115.95) v2(230.2,116.95) ; v2(212.5,113.66) 212.5,113.4 UG9.AP49
  BOTTOM w0.254: v2(9.06,46.38) 9.19,46.51 UI3.10 ; v2(226.53,129.98) 226.13,130.38 UG1.T5 ; UG3.M5 v2(256.43,112.37) UG3.L5 ; UG6.E1 v2(252.8,104.35) ; UG5.K13 v2(255.2,84.71) UG5.K14 255.58,85.11 v2(255.19,85.5) ; UG2.U1 v2(199.86,142.78) ; UG3.R4 v2(253.23,111.57) UG3.R3 v2(254.03,110.77) v2(254.83,110.77) 254.83,110.77 UG3.N3 ; v2(262.43,116.17) 262.43,116.17 UG3.D10 262.83,117.17 v2(262.83,117.17) 262.83,117.17 UG3.C11 ; v2(211.17,130.77) 210.77,131.18 UG2.C14 v2(210.26,130.78) ; v2(203.06,131.6) 203.06,131.58 UG2.C4 ; v2(147.93,85.01) 147.93,85.05 147.63,85.35 UH1.BD12 147.34,85.47 146.67,85.47 UH1.BF12 ; JXDP1.32 203.37,69.5 203.77,69.9 204.14,69.9 v2(204.15,69.9) 204.31,69.9 204.86,69.35 204.86,67.8 JXDP1.26 ; PU5202.4 117.53,128.41 117.41,128.3 v2(117.15,128.3) ; JEDP1.36 v2(94.42,58.75) ; v2(201.46,131.6) 201.46,131.58 UG2.C3 ; v2(257.25,104.6) 257.2,104.55 UG6.K1 UG6.K2 ; UG2.H1 199.81,135.18 v2(199.61,134.98) ; v2(236.13,129.18) 236.53,129.58 UG4.A3 ; UG6.D10 v2(252,96.35) UG6.C11 v2(251.2,95.55) UG6.C12 v2(252,94.75) v2(252.8,94.75) ; UR1.24 13.38,29.15 13.2,29.33 13.09,29.33 v2(12.74,29.68) ; UG3.T10 v2(252.43,117.17) ; UG1.D10 222.67,139.98 v2(222.68,139.98) ; UG4.R1 234.93,140.78 v2(234.53,141.18) ; UG4.R1 v2(235.33,140.38) ; UG4.R1 235.33,141.18 v2(235.33,141.18) v2(236.13,141.18) 236.53,140.78 UG4.R3 236.53,140.78 v2(236.93,141.18) 237.33,140.78 UG4.R4 ; UG5.R4 251.2,76.71 v2(251.2,76.71) UG5.R3 251.6,76.31 v2(252,75.91) v2(252.8,75.91) UG5.N3 ; UG2.C1 200.26,131.18 v2(199.86,130.78) ; v2(155.23,85.63) 155.41,85.63 UH1.AP12 ; v2(211.06,141.18) 210.66,140.78 UG2.R14 210.66,140.78 v2(210.27,141.17) ; v2(219.33,141.98) v2(219.33,141.18) UG1.C14 v2(218.53,140.38) ; v2(219.33,141.98) UG1.A14 ; v2(219.33,141.98) v2(218.53,141.98) ; UG4.P10 v2(241.73,139.58) ; v2(165.98,125.23) 166.09,125.12 PU5203.10 ; v2(289.15,15.71) 288.93,15.94 UTPM1.16 ; v2(257.23,118.77) UG3.K13 257.54,119.26 257.54,119.88 UG3.K14 ; v2(259.37,120.61) 259.23,120.47 UG3.H14 v2(258.83,119.57) UG3.H13 ; v2(255.63,117.17) UG3.M10 256.11,116.69 256.75,116.69 UG3.L10 v2(256.43,117.17) ; UTPM1.23 291.93,17.13 292.55,17.74 v2(292.77,17.74) ; UG1.E14 v2(219.33,139.58) v2(220.13,139.58) 220.52,139.18 UG1.E12 ; UH1.BB4 149.62,80.08 149.62,79.54 UH1.BB3 ; JNGFF1.25 344.21,41.3 344.03,41.11 v2(343.7,41.11) ; UG6.A1 v2(249.6,104.35) ; UG6.R11 261.2,95.95 v2(261.6,96.35) 261.6,96.35 UG6.T10 ; v2(176.07,95.53) 176.08,95.52 176.68,95.52 UH1.F25 ; v2(262.82,113.18) v2(262.82,112.36) 263.21,111.97 UG3.C4 263.63,112.37 v2(263.63,112.37) 264.03,112.77 UG3.B5 264.03,112.77 v2(264.43,113.17) ; UG2.A12 v2(209.46,129.18) ; v2(253.6,83.91) UG5.N12 v2(252.8,83.91) v2(252,83.91) UG5.R12 v2(251.2,83.11) UG5.R11 v2(252,82.31) UG5.P10 ; v2(227.33,139.58) 227.72,139.18 UG1.E3 227.73,139.2 v2(228.13,139.6) 228.15,139.57 228.91,139.57 v2(228.94,139.6) 228.94,139.57 UG1.E1 v2(229.73,139.58) ; UG4.K2 UG4.K1 234.33,136.78 v2(234.28,136.83) ; v2(218.42,136.85) 218.85,136.85 UG1.H14 UG1.H13 ; JNGFF1.55 344.08,48.8 343.7,49.18 v2(343.7,50.19) ; v2(238.53,141.98) 238.13,141.58 UG4.T5 ; UH1.C37 179,104.19 179.5,104.19 UH1.B37 180.15,104.09 UH1.A37 v2(180.3,104.85) ; v2(263.2,75.11) 262.8,74.71 UG5.A1 ; UG1.U14 v2(218.53,129.18) ; UH1.AC6 164.65,81.6 164.34,81.91 ; UG2.B5 203.46,130.38 v2(203.06,129.98) ; UH1.D28 178.72,98.62 179.31,98.62 v2(179.31,98.62) 179.31,98.72 UH1.C29 179,99.11 178.67,99.44 ; v2(203.86,141.98) 203.46,141.58 UG2.T5 203.46,141.58 v2(203.06,141.18) 202.66,140.78 UG2.R4 v2(202.26,141.18) 201.86,140.78 UG2.R3 v2(201.46,141.18) ; UG4.R14 245.33,140.78 v2(244.93,141.18) ; 178.67,99.44 178.35,99.76 UH1.D30 ; 178.67,99.44 v2(178.67,99.41) ; UG4.N12 v2(244.13,139.58) v2(244.13,140.38) 243.73,140.78 UG4.R12 ; UG5.D10 260.39,81.91 v2(260,82.3) ; UG5.D10 260.4,81.36 v2(260.4,81.36) ; UG5.D10 260.4,81.91 v2(260.8,82.31) 261.2,82.71 UG5.C11 ; UH1.F27 176.75,97.17 176.75,97.11 176.71,97.07 ; v2(250.41,77.5) 250.41,77.52 UG5.T5 ; UG4.T10 242.13,141.58 v2(241.73,141.98) ; UG4.T10 242.13,141.58 v2(242.53,141.98) ; UG4.T10 242.53,141.18 v2(242.53,141.18) 242.93,140.78 UG4.R11 ; v2(251.63,109.17) 252.03,109.57 UG3.U1 ; v2(260,104.35) 259.6,103.95 UG6.N1 ; UG5.L5 254.4,77.51 v2(254.4,77.51) UG5.M5 ; UG9.H19 v2(231.15,92.55) ; JEDP1.11 v2(94.27,46.25) ; v2(373.42,67.31) 373.32,67.21 372.89,67.21 DT3.2 ; v2(259.2,84.71) 259.2,84.71 UG5.E14 v2(260,84.71) ; UG9.E51 v2(233.25,114.95) ; UG2.R12 v2(209.46,140.38) v2(209.46,139.58) ; UG2.C3 201.86,131.18 v2(202.26,130.78) 202.66,131.18 UG2.C4 ; UG2.C3 202.26,131.58 ; v2(244.93,130.78) UG4.C14 v2(245.93,131.18) ; v2(260.8,78.31) v2(260.8,77.49) 261.19,77.11 UG5.C4 261.2,77.11 v2(261.6,77.51) 261.6,77.51 UG5.B5 262,77.91 v2(262.4,78.31) ; JXDP1.25 204.87,63.34 205.18,63.65 v2(205.18,64.16) ; v2(262.4,84.71) 262.4,84.71 UG5.A14 262.8,85.11 v2(262.4,85.51) ; UG1.G5 226.12,137.58 v2(225.73,137.98) UG1.F5 v2(226.53,138.78) ; UH1.H32 175.76,100.55 v2(175.73,100.55) 175.69,100.55 UH1.J32 175.39,100.97 175.39,101.5 UH1.J33 ; v2(176.74,83.7) 176.74,83.6 UH1.F9 ; v2(176.74,83.7) 176.4,84.04 UH1.G10 ; v2(176.74,83.7) 176.4,83.35 UH1.G9 ; v2(218.53,130.78) UG1.R14 219.33,131.58 v2(219.33,132.38) UG1.N14 ; v2(168.12,127.81) 168.5,127.42 PU5203.3 ; US1.14 9.03,39.24 9.06,39.27 v2(9.06,39.33) ; v2(94.43,52.8) 94.47,52.75 JEDP1.24 ; UH1.A34 v2(180.77,103.12) 180.69,103.12 180.35,103.46 UH1.A36 ; v2(151.3,129.06) 151.15,128.91 PU5101.4 ; UG3.N14 v2(254.83,120.37) ; UG1.U3 227.73,129.58 v2(228.13,129.18) ; UG9.BF4 204.36,81.64 v2(204.36,81.15) 204.36,80.93 204.36,80.92 204.36,80.56 204.25,80.44 UG9.BF2 ; v2(179.3,94.71) 179.3,94.57 179.05,94.32 UH1.C23 178.88,94.43 178.88,94.47 178.47,94.88 178.47,94.98 UH1.D24 ; UG5.C11 261.6,83.11 v2(261.6,83.11) 261.6,83.11 UG5.C12 ; UG5.C11 261.2,82.71 v2(261.6,82.31) 262,81.91 UG5.B10 262.4,81.51 v2(262.4,81.51) ; v2(217,111.42) 217,111.7 UG9.AH47 ; v2(238.53,138.78) UG4.M5 238.47,138.04 v2(238.59,138.04) UG4.L5 237.74,137.97 v2(237.74,137.99) ; v2(256.9,94.75) 256.9,94.64 UG6.K13 UG6.K14 257.2,93.52 v2(257.92,92.8) ; UG2.H2 201.06,135.18 v2(201.46,135.58) ; v2(236.13,139.58) 236.53,139.18 UG4.N3 v2(236.93,139.58) ; v2(229.73,132.38) 229.33,132.78 UG1.N1 ; v2(164.34,81.84) 164.34,81.91 ; 164.34,81.91 164.15,82.1 UH1.AD7 ; v2(257.24,74.14) 257.24,74.22 257.2,74.26 UG5.H1 UG5.H2 ; UG3.P10 v2(254.03,117.17) UG3.R11 v2(253.23,117.97) UG3.R12 v2(254.03,118.77) v2(254.83,118.77) UG3.N12 v2(255.63,118.77) ; UG9.J17 230,90.7 v2(230,90.35) ; v2(181.65,115.85) 177.2,115.85 176.83,116.23 PU6102.23 ; UG9.BL5 v2(200.45,82.15) ; v2(251.2,74.31) 251.2,74.31 UG5.R1 v2(251.2,75.11) ; v2(219.1,114.1) 218.95,114.25 UG9.AE51 ; UG5.N1 253.2,74.71 v2(252.8,74.31) ; v2(362.75,62.26) 362.56,62.45 362.05,62.45 361.61,62 361.61,60.54 360.32,59.25 UT1.A1 ; UG2.T10 207.46,141.58 v2(207.06,141.98) ; UG2.T10 207.83,141.95 v2(207.84,141.95) ; UG2.T10 v2(207.86,141.18) 208.26,140.78 UG2.R11 207.84,140.37 v2(207.84,140.36) 207.84,140.36 UG2.P10 ; v2(251.2,104.35) UG6.C1 v2(251.2,103.55) ; v2(258.39,86.13) 258.3,86.13 257.67,85.5 v2(257.6,85.5) ; UH1.BA12 150.09,85.47 149.41,85.47 UH1.BB12 149.17,85.47 148.5,85.47 UH1.BC12 UH1.BC13 ; UG1.C4 226.92,140.78 v2(226.53,141.18) 226.13,141.58 UG1.B5 226.12,141.58 v2(225.73,141.98) ; UG1.C4 226.51,140.37 v2(226.51,140.36) ; UG1.C4 v2(227.33,141.18) ; v2(261.23,117.17) 261.23,117.17 UG3.F10 260.83,116.62 v2(260.43,116.22) 260.03,116.62 UG3.G10 ; v2(94.27,48.03) 94.56,47.75 JEDP1.14 ; UG9.AW52 v2(208.85,115.65) ; JXDP1.20 206.37,66.68 206.82,66.23 v2(207.76,66.23) 207.87,66.34 JXDP1.14 ; v2(222.53,141.98) 222.13,141.58 UG1.B10 v2(221.73,141.18) 221.33,140.78 UG1.C11 221.32,140.78 v2(220.93,141.18) ; UH1.BT35 139.07,102.68 v2(139.06,102.7) ; UG4.E3 v2(236.13,133.18) ; v2(212.5,113.66) 212.5,114.11 v2(212.6,114.21) 212.65,114.26 UG9.AP51 ; UG5.U14 v2(249.6,85.51) ; 345.9,66.06 346.52,66.06 346.72,66.26 v2(347.45,66.26) ; UI3.21 v2(9.19,52.29) ; v2(263.2,74.31) 262.8,74.71 UG5.A1 ; UTH1.6 98.64,68.78 v2(98.97,69.12) ; UG9.AU51 210.55,114.1 v2(210.63,114.03) ; v2(231.95,83.55) UG9.F7 ; UG9.F31 231.96,100.36 v2(231.93,100.36) ; UH1.BT26 UH1.BR26 140.32,96.52 v2(140.65,96.85) 140.97,96.54 UH1.BP26 ; v2(94.21,60.42) 94.38,60.25 JEDP1.39 ; v2(199.86,139.58) UG2.N1 v2(200.66,138.78) ; UG1.R12 v2(220.93,130.78) UG1.R11 v2(221.73,130.78) UG1.T10 ; UG2.H13 v2(210.26,134.78) UG2.H14 210.89,135.18 211.06,135.01 v2(211.06,134.9) ; UG6.T10 262,96.75 v2(262.4,96.35) ; UG6.T10 262,96.75 v2(262.4,97.15) ; JEDP1.8 94.32,44.75 v2(94.23,44.84) ; v2(229.73,141.18) 229.33,140.78 UG1.C1 ; v2(263.2,93.15) UG6.U14 v2(262.4,93.95) ; UG2.A1 200.04,129.36 v2(199.82,129.36) ; 242.13,134.38 242.02,134.27 242.02,133.69 UG4.F10 242.13,133.58 v2(242.53,133.18) ; 242.13,134.38 UG4.G10 ; 242.13,134.38 v2(242.53,133.98) ; UG9.D37 233.95,105.15 v2(233.95,105.15) ; UH1.BH12 144.72,85.35 145.01,85.06 v2(145.18,85.06) 145.46,85.35 UH1.BG12 ; UG3.A3 264.83,111.17 v2(265.23,111.57) ; v2(159.93,129.06) 159.93,129 159.82,128.89 PU5103.4 ; v2(263.2,83.91) 263.2,83.91 UG5.A12 ; v2(228.13,132.38) 227.73,132.78 UG1.N3 ; v2(263.63,109.17) UG3.C1 263.63,109.97 v2(263.63,110.77) UG3.C3 ; v2(141.29,99.98) 141.29,99.91 141.6,99.6 UH1.BN30 ; 202.26,131.58 v2(202.26,131.6) ; 202.26,131.58 UG2.C4 ; v2(138.28,86.2) 138.21,86.27 UC1.3 ; v2(205.95,96.85) UG9.BD26 ; v2(232.6,106.62) 232.55,106.62 232.25,106.92 UG9.F40 ; v2(211.06,139.58) UG2.N14 210.66,139.18 v2(210.26,139.58) v2(209.46,139.58) ; UG5.A1 v2(262.4,75.11) v2(261.6,75.11) ; UG9.H16 231.1,90.4 v2(231.25,90.4) ; UH1.AY14 150.99,86.65 v2(150.66,86.97) ; UH2.AK42 276.27,37.73 v2(276.18,37.81) ; UH1.BJ15 UH1.BK15 ; UG1.M10 v2(221.73,133.98) UG1.L10 ; UG3.C11 263.63,117.17 v2(263.63,117.17) 264.03,116.77 UG3.B10 264.03,116.77 v2(264.43,116.37) ; UG3.C11 263.63,117.97 v2(263.63,117.97) 263.23,118.37 UG3.C12 263.23,118.37 v2(262.83,118.77) v2(262.03,118.77) UG3.E12 261.63,118.37 v2(261.23,118.77) v2(261.23,119.57) 261.63,119.97 UG3.E14 ; v2(200.89,128.99) 201.27,128.99 201.86,129.58 UG2.A3 ; v2(251.2,92.95) 251.6,93.35 UG6.C14 v2(251.2,93.95) ; v2(245.98,136.9) 245.86,136.78 UG4.K14 UG4.K13 244.45,136.78 v2(244.13,136.46) ; v2(261.6,94.75) 261.2,95.15 UG6.R12 ; UT4.K10 UT4.K9 ; v2(263.63,119.57) 263.23,119.97 UG3.C14 263.23,119.97 v2(262.83,120.37) ; v2(261.6,75.11) v2(261.6,75.91) UG5.C3 260.8,75.91 v2(260.8,75.91) ; v2(261.6,75.11) 261.2,74.71 UG5.C1 261.2,74.71 v2(261.6,74.31) ; v2(260.8,93.95) UG6.R14 v2(261.6,93.15) ; UG4.G5 237.73,133.98 ; 237.73,133.98 UG4.F5 ; 237.73,133.98 v2(237.73,133.97) ; UG9.A29 v2(236.2,99.25) ; UG5.E3 259.6,76.31 v2(260,76.71) ; UG3.N1 255.23,109.57 v2(254.83,109.17) ; UTPM1.32 292.43,12.44 v2(292.2,12.66) ; UH1.AY12 UH1.AW12 152.18,85.35 v2(152.48,85.65) ; UG1.A12 v2(220.93,141.98) v2(220.93,141.18) ; v2(264.43,118.77) 264.83,118.37 UG3.A12 264.83,118.37 v2(265.23,117.97) ; v2(245.73,139.58) UG4.N14 v2(244.93,138.78) ; v2(207.86,133.18) UG2.F10 207.86,133.98 v2(207.86,133.98) UG2.G10 ; UG1.L5 226.13,134.38 v2(226.53,133.98) UG1.M5 ; v2(206.73,115.88) 206.63,115.98 205.92,115.98 v2(205.74,115.8) 205.65,115.71 UG9.BD52 ; v2(206.57,59.43) 206.57,59.59 206.5,59.65 206.5,60.26 206.37,60.4 JXDP1.19 ; v2(199.61,136.83) 199.66,136.78 UG2.K1 UG2.K2 ; v2(162.55,86.96) 162.4,86.96 UH1.AF14 UH1.AF13 UH1.AF12 ; v2(228.93,142.78) 229.32,142.38 UG1.A1 ; UG9.BC51 206.35,114.85 v2(206.59,115.09) ; UG4.H13 244.53,135.18 v2(244.93,134.78) UG4.H14 245.78,135.18 v2(245.93,135.03) ; v2(262.41,100.37) 262.38,100.37 262,100.75 UG6.T5 262,100.75 v2(261.6,101.15) UG6.R4 261.2,101.55 v2(261.6,101.95) UG6.R3 261.2,102.35 v2(261.6,102.75) ; UT1.P2 359.29,53.27 359.07,53.05 359.07,52.62 v2(359.02,52.57) ; UG1.C3 227.72,140.78 v2(227.33,141.18) ; v2(234.53,139.58) 234.93,139.18 UG4.N1 ; v2(230.53,103.07) 230.42,102.96 230.04,102.96 229.95,103.05 v2(229.75,103.05) ; UG2.M10 v2(207.86,138.78) 207.84,138.79 v2(207.84,139.6) 207.84,139.6 UG2.P10 ; UG2.M10 207.46,138.38 v2(207.06,138.78) ; UG2.M10 v2(207.06,137.98) 207.46,137.58 UG2.L10 ; v2(260.8,85.51) 261.2,85.11 UG5.C14 260.8,84.71 v2(260.8,84.71) v2(260,84.71) ; UG9.W43 v2(223.45,109.35) ; UG9.N51 227.35,114.17 v2(227.38,114.14) ; v2(229.88,136.88) 229.78,136.78 UG1.H1 UG1.H2 ; v2(224.96,85.5) 225.25,85.79 UG9.T10 ; v2(234.5,106.8) 234.46,106.8 234.17,107.09 233.79,107.09 UG9.D40 ; UG2.E14 v2(210.26,132.38) v2(209.46,132.38) UG2.E12 ; v2(201.3,84) 201.15,83.85 UG9.BL7 ; v2(220.13,129.22) 220.49,129.58 UG1.U12 ; UG9.H22 v2(230.55,94.65) ; v2(249.6,102.75) UG6.A3 v2(250.4,102.75) ; JDEG1.10 320.75,6.52 320.56,6.33 v2(320.22,6.33) ; 158.89,84.44 v2(158.89,83.79) ; 158.89,84.44 158.82,84.44 UH1.AL10 ; 158.89,84.44 v2(158.91,84.45) ; UG2.B10 v2(207.86,129.98) ; v2(236.13,130.78) UG4.C3 v2(236.93,131.58) UG4.C4 v2(237.73,131.58) ; v2(264.43,120.37) 264.83,119.97 UG3.A14 ; UH1.T14 169.58,86.65 v2(169.9,86.32) 169.58,86 UH1.T13 ; v2(178.79,105.44) 178.79,105.37 178.23,104.81 UH1.D38 ; v2(245.93,132.78) UG4.E14 v2(244.93,132.38) v2(244.13,132.38) 243.73,132.78 UG4.E12 ; UG3.U3 v2(251.63,110.77) ; v2(94.18,47.43) 94.36,47.25 JEDP1.13 ; UG5.U1 249.99,74.71 v2(249.6,74.31) ; v2(254.4,96.35) UG6.G10 254.71,96.84 254.08,96.84 UG6.F10 v2(253.6,96.35) ; UG6.U1 262.8,103.95 v2(263.2,104.35) ; v2(252,102.75) UG6.C3 v2(252,101.95) UG6.C4 ; v2(94.34,43.68) 94.41,43.75 JEDP1.6 ; v2(249.6,92.95) 250,93.35 UG6.A14 ; v2(199.86,141.18) UG2.R1 v2(200.65,140.39) ; v2(263.2,102.75) 262.8,102.35 UG6.U3 ; UG3.A1 v2(265.23,109.17) ; v2(175.93,128.17) 175.49,128.17 175.3,128.36 PU6100.23 ; v2(253.23,120.37) UG3.R14 v2(253.23,119.57) ; v2(210.67,69.94) 210.54,70.07 210.01,70.07 209.37,69.43 JXDP1.8 ; v2(348.46,58) 347.94,58.52 347.5,58.52 ; UG4.A12 243.73,129.58 v2(244.13,129.18) ; UZ9.5 187.67,106.85 188.51,106.01 v2(188.51,105.95) ; UG6.A12 v2(249.6,94.75) ; v2(242.53,129.98) 242.13,130.38 UG4.B10 ; 203.46,138.38 203.86,137.98 v2(203.96,137.98) 203.56,137.58 UG2.L5 ; 203.46,138.38 UG2.M5 ; 203.46,138.38 v2(203.86,138.78) 203.86,139.58 v2(203.86,139.58) v2(203.06,139.58) v2(202.26,139.58) 201.86,139.18 UG2.N3 v2(201.46,139.58) ; UG1.R4 226.93,131.18 v2(227.33,130.78) UG1.R3 ; JXDP1.13 207.87,59.7 v2(208.11,59.46) 208.76,59.46 209.37,60.07 JXDP1.7 ; v2(204.42,59.14) 204.42,59.4 203.37,60.45 JXDP1.31 ; v2(229.84,92.52) 229.84,92.64 UG9.J20 ; UG9.F19 232.5,92 v2(232.64,92) ; JEDP1.27 v2(94.42,54.25) ; UG9.AH43 216.85,109.08 v2(217.15,109.38) ; JEDP1.30 v2(94.34,55.75) ; UG6.H13 255.59,94.35 v2(255.2,93.95) UG6.H14 255.45,93.4 v2(255.45,92.95) ; UG9.B19 234.65,92.25 v2(234.5,92.1) 234.17,92.43 233.87,92.43 233.69,92.25 UG9.D19 ; UH1.BT4 139.12,80.2 v2(139.03,80.11) ; 176.71,97.07 176.7,97.07 176.7,96.98 UH1.G26 ; 176.71,97.07 v2(176.74,97.04) ; v2(261.6,104.35) 261.2,103.95 UG6.R1 261.2,103.95 v2(260.8,103.55) ; UG5.A12 263.2,83.11 v2(263.2,83.11) ; UG5.A12 262.4,83.11 v2(262.4,83.11) ; UG5.G5 258,78.03 v2(258.4,78.43) 258.4,78.31 UG5.F5 258.8,77.91 v2(259.2,77.51) ; UG6.B5 v2(250.4,101.15) ; UH1.BT3 139.33,79.48 v2(139.1,79.25) ; UG9.K40 229.6,107.1 v2(230.05,107.1) ; v2(209.46,139.58) UG2.N12 ; UG4.C1 v2(235.33,131.58) ; UG2.F5 v2(203.06,133.98) 203.46,134.38 UG2.G5 ; UG6.L5 258,100.75 v2(258.4,101.15) 258.8,100.75 UG6.M5 v2(259.2,100.35) 260.09,100.35 v2(260.09,100.35) 260,100.45 v2(260,101.95) UG6.N3 259.6,102.35 v2(260,102.75) ; PU5103.23 156.79,125.99 v2(156.76,125.95) ; UG4.L10 242.13,137.58 v2(241.73,137.98) UG4.M10 v2(242.53,138.78) ; v2(234.3,86.05) 233.75,86.05 UG9.D10 ; UG6.P10 260.4,96.75 v2(260,97.15) ; UG3.H2 UG3.H1 259.23,109.12 v2(259.33,109.02) ; v2(227.33,141.18) 227.33,141.98 UG1.A3 227.72,142.38 v2(227.33,142.78) ; UG6.E12 v2(252.8,94.75) ; v2(252.8,94.75) v2(252.8,93.95) UG6.E14 253.2,93.38 v2(252.8,92.98) ; v2(255.4,104.6) 255.4,104.38 255.6,104.18 UG6.H1 255.51,103.86 255.51,103.24 UG6.H2 v2(256,102.75) ; UG6.E3 v2(253.6,102.75) ; UG1.U1 v2(228.93,129.98) 228.93,130.77 v2(228.93,130.77) 229.33,131.17 UG1.R1 ; UG2.A14 211.09,129.58 v2(211.14,129.63) ; v2(261.23,112.37) UG3.F5 260.43,113.17 v2(260.43,113.24) 260.03,112.84 UG3.G5 ; v2(164.65,77.65) UH1.AC1 ; v2(371.8,67.33) 371.82,67.31 371.82,67.03 372.21,66.64 373.19,66.64 DT9.2 ; UH1.AH12 160.41,85.35 v2(160.71,85.65) ; UG1.K13 v2(219.33,134.78) UG1.K14 v2(218.53,134.78) ; UG3.E1 v2(262.03,109.17) ; v2(263.2,94.75) 262.8,95.15 UG6.U12 ; UG3.U14 v2(251.63,120.37) ; RT45.2 359.08,61.74 RT42.2 357.91,61.74 RT40.2 ; v2(234.53,142.78) 234.93,142.38 UG4.U1 235.33,142.78 v2(235.33,142.78) v2(236.13,142.78) 236.53,142.38 UG4.U3 ; UG6.G5 v2(254.4,101.15) UG6.F5 ; UG9.AE43 218.95,109.12 v2(218.65,109.42) ; v2(251.2,85.51) UG5.R14 v2(251.2,84.71) ; UG9.BB49 v2(206.75,112.95) ; v2(255.45,74.16) 255.6,74.31 UG5.K1 255.51,74.8 255.51,75.42 UG5.K2 v2(256,75.91) ; v2(249.6,96.35) v2(250.4,96.35) UG6.B10 ; v2(228.13,135.58) 228.53,135.18 UG1.K2 228.59,135.11 229.26,135.11 UG1.K1 229.73,135.18 v2(229.88,135.03) ; UH1.BM13 UH1.BL13 ; UG5.L10 v2(254.4,82.31) UG5.M10 v2(253.6,82.31) ; UG9.AL43 v2(215.15,109.45) UG9.AK44 ; v2(175.62,137.06) 175.3,137.06 174.85,137.52 PU6101.23 ; JXDP1.59 196.37,63.14 196.91,63.68 198.47,63.68 198.81,64.02 ; v2(143.45,102.57) 143.15,102.86 UH1.BL35 ; UG5.E12 259.6,83.51 v2(260,83.91) v2(260,84.71) ; JEDP1.33 94.39,57.25 v2(94.34,57.31) ; UG2.C12 v2(208.66,130.78) UG2.C11 v2(207.86,131.58) UG2.D10 ; UG5.U3 v2(249.6,75.91) ; UG6.L10 258,96.75 v2(258.4,97.15) 258.8,96.75 UG6.M10 v2(259.2,96.35) ; v2(230.39,98.73) 230.67,98.73 UG9.H28 ; UG2.U3 v2(201.46,142.78) ; v2(176.71,99.44) 176.71,99.37 UH1.F29 ; v2(216.94,114.02) 216.85,114.1 UG9.AH51 ; v2(156.15,85.06) 156.44,85.35 UH1.AN12 156.73,85.47 157.4,85.47 UH1.AM12 UH1.AL12 ; UG3.U12 v2(251.63,118.77) ; v2(94.27,44.26) 94.37,44.26 94.37,44.25 JEDP1.7 ; v2(245.73,142.78) 245.33,142.38 UG4.U14 ; JNGFF1.7 346.53,34.8 347.47,33.85 v2(347.47,33.23) ; v2(234.5,94.2) 234.19,94.51 233.81,94.51 UG9.D22 ; UG1.C12 220.53,140.78 v2(220.93,141.18) ; UG2.E1 200.26,132.78 v2(199.86,132.38) ; v2(148.12,125.69) 148.12,125.73 148.38,125.98 PU5101.23 ; v2(230.2,115.95) 230.15,115.9 UG9.J52 ; v2(201.74,100.53) 201.62,100.65 UG9.BL31 ; v2(262.03,111.57) 261.63,111.17 UG3.E3 v2(262.03,110.77) ; UG2.P10 207.46,139.98 v2(207.06,140.38) ; UG2.E3 v2(201.46,133.18) ; v2(244.13,141.98) 243.73,142.38 UG4.U12 243.73,142.38 v2(244.13,142.78) ; UG9.B7 v2(234.64,83.56) ; UH1.K10 175.14,84.37 v2(175.23,84.37) 175.38,84.37 UH1.J10 ; UG9.E8 v2(232.77,84.11) ; UG1.P10 v2(221.73,132.38) ; v2(211.31,137.03) 211.06,136.78 UG2.K14 UG2.K13 ; UG1.N12 v2(220.13,133.18) ; JEDP1.40 94.7,60.75 v2(94.46,60.99) ; DT8.2 v2(373.29,64.11) ; UTPM1.9 v2(287.21,12.44) ; v2(211.92,116.47) 211.95,116.44 UG9.AR52 ; v2(253.23,109.17) 253.63,109.57 UG3.R1 253.63,109.57 v2(253.23,109.97) ; v2(209.46,141.98) UG2.U12 v2(209.46,142.78) ; v2(258.03,110.77) 257.63,110.37 UG3.K2 257.54,110.28 257.54,109.66 UG3.K1 257.63,109.17 v2(257.48,109.02) ; UG6.N12 v2(260,94.75) ; UG9.BL43 v2(201.2,109.05) ; JNGFF1.31 346.08,42.8 v2(346.18,42.89) ; UG4.B5 238.13,130.38 v2(237.73,129.98) ; v2(214.62,114.18) 214.75,114.31 UG9.AL51 ; UG5.U12 v2(249.6,83.91) ; UG5.A3 262.8,76.31 v2(263.2,76.71) ; UG4.E1 v2(234.53,132.38) ; UG1.G10 222.28,137.58 v2(222.68,137.98) 222.53,137.98 UG1.F10 222.12,138.38 v2(221.73,138.78) ; UG5.N14 v2(252.8,85.51) ; UH1.BP34 UH1.BP33 ; v2(211.06,142.78) 210.66,142.38 UG2.U14 ; UH1.D12 178.66,85.34 v2(178.66,85.25) 179,84.91 UH1.C11 ; UG4.A1 v2(235.33,129.98) ; PU5102.23 v2(139.42,125.79) ; UG4.C12 v2(243.33,130.78) 242.93,131.18 UG4.C11 v2(242.53,131.58) 242.13,131.98 UG4.D10 ; v2(233.23,83.61) UG9.D7 ; UG9.F10 v2(232.55,85.65) ; UG5.T10 v2(250.4,82.31) ; v2(236.13,135.58) UG4.H2 UG4.H1 234.53,135.18 v2(234.38,135.03) ; UG9.B10 v2(235.35,85.65) ; v2(216.55,110.75) UG9.AH45 ; v2(372.66,76.23) 372.76,76.13 DT13.2 ; UG3.T5 v2(252.43,112.37) ; UG4.A14 v2(245.93,129.58) ; 232.25,93.69 v2(231.74,94.2) 232.1,94.2 UG9.F22 232.52,94.08 v2(232.68,94.08) UG9.F21 232.25,93.69
  BOTTOM w0.279: JXDP1.38 201.87,69.79 v2(201.75,69.9) ; JXDP1.2 210.87,69.74 v2(210.67,69.94) ; JXDP1.50 198.87,66.41 v2(198.67,66.21) ; JXDP1.49 198.89,62.08 v2(198.89,64.1) 198.81,64.02
  BOTTOM w0.3: UG9.AU49 210.42,113.39 210.42,113.82 v2(210.63,114.03) ; UG9.B48 v2(235.35,112.85) ; v2(220.79,110.8) 220.79,110.71 UG9.AB45 ; UG9.C1 234.66,79.34 v2(234.68,79.34) ; v2(233.25,80.05) UG9.E2 ; UG9.N49 227.14,113.46 227.14,113.9 v2(227.38,114.14) ; UG9.H31 230.6,100.9 v2(230.4,100.9) ; v2(234.5,94.2) 234.65,94.35 UG9.B22 ; UG9.B1 235.5,79.2 v2(235.65,79.2) ; UG9.B2 v2(235.42,79.98) ; UG9.D46 233.79,111.29 234.21,111.29 v2(234.5,111) 234.65,111.15 UG9.B46 ; v2(224.92,110.81) 224.92,110.78 UG9.T45 ; UG9.AD44 v2(219.35,109.45) ; v2(234.56,104.69) 234.72,104.85 UG9.B37 ; UG9.D43 233.73,109.13 234.28,109.13 v2(234.5,108.9) 234.65,109.05 UG9.B43 ; v2(219.1,114.1) 218.83,113.83 218.83,113.37 UG9.AE49 ; UG9.N47 227.53,112.03 v2(227.53,112.25) ; v2(211.25,115.83) UG9.AT52 UG9.AT51 ; UG9.A3 v2(236.32,81.05) ; v2(236.3,79.8) UG9.A2
  BOTTOM w0.305: v2(192.15,44.81) 191.83,44.48 JDIMM2.51 ; PU5201.23 120.04,116.59 v2(120.04,116.59) ; v2(244.91,27.24) 245.43,27.24 245.6,27.41 JHDD1.7 ; v2(144.26,85.02) 143.89,85.39 UH1.BJ12 ; v2(272.11,18.63) 272.97,17.78 JNGFF2.33 ; v2(356.17,68.14) 356.13,68.14 355.78,68.49 RT62.2 RT83.1 ; UH1.AD12 164.09,85.35 v2(164.38,85.06) ; v2(250.84,28.79) 250.56,29.07 248.82,29.07 248.6,28.85 ; UG5.G10 258.55,81.36 v2(258.8,81.36) 258.8,81.36 UG5.F10 258.8,81.91 v2(259.2,82.31) ; JNGFF1.49 343.93,47.3 343.7,47.53 343.7,48.36 v2(343.76,48.42) ; JXDP1.37 201.87,63.35 v2(200.36,64.86) ; JNGFF1.61 345.67,50.3 v2(345.96,50) ; JNGFF2.9 274.73,23.78 275.07,23.43 v2(275.07,22.55) 274.8,22.28 JNGFF2.15 ; JNGFF2.39 274.63,16.28 274.94,15.97 v2(274.94,15.71) 274.94,15.02 274.69,14.78 JNGFF2.45 ; 171.76,101.9 172.07,102.21 UH1.N34 ; 171.76,101.9 v2(171.77,101.89) ; 171.76,101.9 171.84,101.9 UH1.N33 ; RT46.2 v2(356.59,62.31) ; JNGFF1.67 343.72,51.8 v2(343.29,51.37) ; v2(257.6,85.5) 257.52,85.5 257.2,85.17 UG5.H14 UG5.H13 v2(256.8,83.91) ; JNGFF1.37 344.03,44.3 343.81,44.08 342.6,44.08 342.05,43.53 v2(342.05,43.3) ; JPW.6 215.15,26.81 214.86,26.52 v2(214.86,23.69) ; v2(226.01,115.79) 225.95,115.73 UG9.R52 ; PU5201.4 117.08,119.68 117.01,119.6 v2(116.94,119.6) ; PU5202.23 v2(120.19,125.33) ; JNGFF2.3 274.59,25.28 v2(275.09,25.78) JNGFF2.1 ; v2(294.98,4.43) 294.98,4.48 295.76,5.26 JESPI1.9 ; JNGFF2.21 274.62,20.78 274.93,20.46 v2(274.93,20.09) 274.93,19.62 274.59,19.28 JNGFF2.27 ; UH1.AA12 165.7,85.35 165.31,85.75 v2(165.31,85.7) 165.2,85.7 164.86,85.35 UH1.AC12 ; v2(359.13,62.31) RT45.2 ; v2(342.91,45.6) 343.25,45.94 343.97,45.94 344.11,45.8 JNGFF1.43 ; UG9.M52 v2(228.05,115.8) ; 248.6,28.85 248.38,29.07 247.42,29.07 247.1,28.75 JHDD1.4 ; 248.6,28.85 JHDD1.1 ; v2(339.64,36.77) 339.09,36.77 338.31,37.55 JNGFF1.18 ; JNGFF2.51 273.08,13.28 272.5,12.7 272.5,12.04 v2(272.57,11.98) 272.61,11.98 272.81,11.78 JNGFF2.57 ; PU5102.4 142.55,128.89 v2(142.6,128.93) ; JNGFF1.1 345.93,33.3 v2(346.02,33.21) ; v2(213.65,23.71) JPW.9 ; v2(260,93.15) UG6.N14
  BOTTOM w0.33: v2(168.19,130.9) 168.01,130.72 167.62,130.72 167.22,130.33 PC6108.2
  BOTTOM w0.356: RT24.2 358.56,45.02 v2(358.56,44.41) ; RT34.2 362.92,52.16 v2(362.99,52.24) ; v2(363.11,44.92) CT45.2 ; CG527.2 117.53,87.48 v2(117.72,87.48) ; v2(202.03,76.93) 201.94,76.93 201.59,76.57 CG526.2 ; v2(364.99,96.98) 365.28,97.27 CT117.2 ; v2(362.76,55.72) RT36.2 ; v2(201.75,69.9) 201.75,70.13 201.97,70.35 RG165.1 ; 222.9,44.43 222.57,44.76 v2(222.31,44.76) ; v2(198.92,69.94) 197.8,69.94 CG483.2 ; CG79.2 CG78.2 214.63,134.38 213.6,134.38 ; DT1.2 366.5,73.29 CT113.2 366.88,74.11 v2(366.88,74.32) ; RT71.2 RT72.2 v2(352.27,74.01) ; CT102.2 355.01,73.07 354.51,73.07 353.89,72.44 353.89,72.3 353.71,72.13 353.67,72.13 353.58,72.04 v2(353.54,72.04) 353.23,72.04 353.14,72.13 353.07,72.13 352.9,72.3 352.9,72.37 352.81,72.46 RT73.2 ; CTH1.2 92.9,65.43 v2(92.44,65.43) ; RT38.2 363.02,49.6 v2(363.18,49.76) 363.48,50.05 RT11.2 ; v2(197.23,91.68) 197.61,91.68 RG518.2 ; v2(363.77,76.42) RT68.2 RT69.2 ; v2(197.89,89.41) 197.78,89.53 RG26.2
  BOTTOM w0.381: v2(211.06,134.9) 211.31,134.64 212.12,134.64 212.39,134.38 RG112.2 213.6,134.38 ; v2(364.28,53.69) 364.05,53.69 363.67,54.07 RT47.2 ; v2(352.36,66.82) 352.26,66.92 RT113.2 ; v2(20.8,47.08) 21.12,47.08 21.71,46.49 CL36.2 ; v2(360.21,46.26) 360.07,46.26 RT18.2 ; CZ86.2 181.84,104.18 v2(180.77,103.12) ; v2(289.73,20.6) 289.73,21.1 CC4.1 ; CT112.2 364.24,75.25 364.16,75.17 364.16,75.17 363.97,74.99 363.97,74.98 363.86,74.87 v2(363.86,74.7) ; CTPM3.2 285.56,12.19 CTPM4.2 ; JDEG1.11 v2(326.25,5.25) ; UG31.3 113.96,86.47 CG482.2 113.96,85.45 v2(114.26,85.14) ; v2(364.18,56.65) 363.4,57.43 362.66,57.43 RT17.2 ; v2(218.53,134.78) 218.04,134.78 217.56,134.3 CG79.2 ; RG123.2 CG114.2 CG113.2 ; v2(373.17,70.96) 372.97,71.15 DT10.3 ; JDEG1.12 v2(319.75,5.07) ; CG75.1 196.89,85.7 197.17,85.98 197.18,85.98 v2(197.33,86.13) ; JLED.1 204.65,23.78 v2(204.61,23.74) ; PC213.2 v2(109.39,79.47) ; v2(211.45,23.7) JPW.12 ; RT4.2 363.89,54.7 v2(364.28,54.32) ; v2(263.2,104.35) 263.2,106.16 CG167.2
  BOTTOM w0.4: v2(260,75.11) 259.6,74.71 UG5.E1 v2(260,74.31)
  BOTTOM w0.406: QC5.4 255.96,23.62 255.72,23.87 255.54,23.87 255.54,23.87 252.21,23.87 v2(251.91,23.56) ; UG29.3 203.1,70.92 203.44,71.26 203.44,71.45 203.46,71.47 v2(203.46,71.59) ; JESPI1.11 300.41,4.43 v2(300.16,4.68) ; v2(294.98,4.43) JESPI1.12 ; v2(201.38,73.5) 201.52,73.5 201.57,73.55 UG10.3
  BOTTOM w0.432: v2(242.29,73.24) 242.62,72.92 QG513.4 ; QG513.1 240.84,74.53 v2(240.29,75.09)
  BOTTOM w0.457: RL30.2 27.06,40.22 v2(27.22,40.07) ; CG80.2 232,139.58 v2(229.73,139.58) ; CG117.2 254.07,121.73 254.83,120.97 v2(254.83,120.37) ; v2(294.56,54.17) 294.58,54.17 ; v2(245.73,139.58) 245.98,139.83 CG132.2 ; v2(218.53,130.78) 218.29,130.54 CG81.2 ; UG11.3 225.53,71.68 CG61.2 ; CG149.2 257.3,87.68 v4(257.69,87.29) 257.69,86.83 v2(258.39,86.13) ; v2(173.57,76.08) 173.42,75.92 173.42,73.43 RH149.1 ; CG97.2 213.17,131.88 212.06,130.77 v2(211.17,130.77) ; v2(229.73,142.78) 230.2,142.3 CG82.2 ; CT103.2 353.1,67.72 v2(352.86,67.48) ; CG133.2 245.89,142.94 v2(245.73,142.78) ; v2(251.44,28.79) 251.44,26.18 250.4,25.14 JHDD1.13 ; v2(287.54,61.85) 287.59,61.9 287.59,62.54 EC5205.2 ; v2(160.21,130.52) 160.21,131.63 PR6054.1 ; v2(211.14,129.63) 211.82,128.96 CG98.2
  BOTTOM w0.508: v2(183.3,81.55) UG13.4 ; PC5230.1 166.14,129.05 v2(165.81,129.38) ; PC5001.2 132.17,144.22 131.89,144.5 v2(131.89,144.76) ; v2(135.74,92.15) 135.74,92.15 135.8,92.2 RH188.2 RH57.1 ; RG562.2 199.15,76.18 RG92.1 198.48,76.76 v2(198.52,76.8) ; v2(191.65,84.8) 188.89,84.8 188.32,84.23 CG66.2 ; v2(169.36,138.6) 169.44,138.52 PR6111.1 ; RE151.1 300.55,15.1 v2(300.46,15.01) 300.29,15.19 CE79.2 ; v2(131.71,142.48) 131.71,141.92 PC5004.1 131.88,140.84 PR5010.1 ; v2(197.33,83.01) 197.32,83.01 CG76.1 ; YH2.2 v2(305.2,49.64) ; v2(305.2,49.64) 305.2,48.9 304.86,48.56 303.31,48.56 302.98,48.23 CH177.2 CH178.2 300.19,48.42 299.78,48.42 299.76,48.43 299.3,48.43 v2(299.12,48.61) ; v2(305.2,49.64) v2(305.2,51.31) 305.2,52.66 304.49,53.37 302.15,53.37 v2(301.77,52.99) ; PC2.2 v2(50.56,63.68) ; v2(163.17,131.22) 162.93,131.22 162.43,130.71 PC5132.2 162.42,130.64 PC5131.2 ; CI4.2 v2(5.94,44.53) ; v2(18.87,47.11) 20.78,47.11 v2(20.8,47.08) ; v2(18.87,47.11) 18.29,47.11 17.69,46.51 17.69,42.64 18.14,42.19 v2(20.58,42.19) ; v2(18.87,47.11) YL2.4 ; RV551.2 v2(87.33,50.76) ; v2(364.54,92.8) 364.78,92.56 CV598.2 ; PH5000.1 122.29,123.35 v2(121.96,123.35) ; v2(170.09,120.17) 171.01,119.26 PC6128.2 ; v2(362.33,21.49) CI12.2 CI13.2 ; DI10.1 360.15,42.64 v2(360.72,43.21) ; CS14.2 245.33,31.62 245,31.96 242.23,31.96 241.34,32.84 v2(241.34,33.37) ; PC4003.2 v2(120.07,105.61) ; PR10V5.2 v2(123.54,90.9) ; v2(251.63,120.37) 251.51,120.49 CG404.2 ; JKB1.31 110.06,28.68 109.13,29.61 v2(109.13,31.46) ; v2(287.72,16.98) 287.72,16.56 287.52,16.36 CTPM7.2 ; RH113.2 v2(301.3,35.3) ; PR107.2 252.06,35 251.3,34.25 v2(251.3,32.74) ; CE9.2 v2(157.39,30.57) ; RV536.2 v2(87.33,49.81) ; JRTC.2 262.75,20.42 262.99,20.67 v2(264.45,20.67) ; v2(208.83,75.59) 209.6,74.82 CG232.2 210.06,74.8 211.03,73.83 CG508.2 ; CE65.2 300.65,12.02 v2(301.32,12.69) ; v2(84.42,29.58) 83.91,29.07 JKB1.32 ; v2(167.74,131.35) 167.25,131.35 PC6109.2 ; CI23.2 v2(14.58,37.68) ; CG316.2 247.09,134.96 v2(247.08,134.98) ; v2(139.84,138.73) 139.89,138.78 PC5016.2 ; CH45.2 294.84,26.42 295.53,25.74 v2(295.53,25.62) ; CV579.2 v2(88.75,42.88) ; v2(301,52.99) CH47.2 ; v2(301,52.99) 301,53.72 300.21,54.52 297.76,54.52 297.76,54.51 294.93,54.51 294.58,54.17 ; v2(301,52.99) v2(301.77,52.99) ; PC5038.2 135.6,132.16 135.57,132.13 PC5040.1 135.57,130.94 PC5037.1 134.67,130.93 PC5039.2 134.02,130.89 v2(133.97,130.84) ; v2(363.77,77.19) CT104.2 ; v2(265.98,76.74) PR18V04.2 ; CE10.2 v2(154.8,29.89) ; 347.76,44.1 348.95,44.1 v2(349.14,44.29) ; v2(251.28,23.57) 251.28,24.63 251.79,25.13 QC5.1 ; v2(132.58,88.26) 132.59,88.25 CH197.2 ; v2(373.17,74.89) 372.97,74.7 CT106.2 ; v2(291.69,8.79) 291.71,8.78 CTPM1.2 ; PR6105.1 170.52,128.3 v2(170.87,127.96) ; v2(161.9,141.82) 161.39,141.32 PC6106.2 ; D5225.1 219.28,30.47 v2(218.92,30.11) ; JRTC.4 264.44,23.63 v2(263.86,23.63) ; CS15.2 245.73,32.65 244.97,32.65 v2(244.32,33.3) ; v2(224.8,70.32) CG61.2 ; v2(265.91,79.32) 265.99,79.4 PR18V05.2 ; v2(172.56,106.46) 172.57,106.48 PC5589.2 ; v2(195.49,76.36) 195.56,76.36 196.14,75.77 RG98.2 196.77,75.77 197.24,76.24 RG93.1 ; RA16.2 341.42,9.36 v2(341.68,9.1) ; CG231.2 207.68,74.95 207.62,74.89 v2(207.24,74.89) ; PC5588.2 v2(172.57,109.39) 172.63,109.45 PC5567.2 172.64,110.34 PC5568.2 ; CG514.1 CG515.1 211.35,70.26 v2(211.53,70.08) ; PR4011.1 v2(129.71,103.74) ; 345.9,66.06 345.68,65.84 v2(345.68,63.99) 345.68,62.02 v2(345.61,61.94) 346.18,61.37 CT37.2 346.23,59.79 347.5,58.52 ; JPW.11 v2(219.35,23.68) ; RH562.2 v2(268.96,49.37) ; CG149.2 RG134.2 CG148.2 ; UL2.2 23.58,52.3 v2(23.17,52.72) ; PC5.2 56.67,35.41 v2(57.21,34.86) 57.57,35.22 PC6.2 ; v2(264.43,120.37) 265.52,121.46 CG115.2 ; DA4.1 v2(365.82,18.91) ; v2(19.95,58.27) 19.85,58.37 DI11.1 ; v2(15.32,46.95) RI11.1 ; v2(288.46,65.85) 288.46,65.09 JCAM1.8 ; v2(251.2,92.95) 251.2,92.47 251.89,91.78 CG169.2 CG324.2 ; CE2.2 v2(130.47,28.6) ; v2(146.29,137.14) 146.26,137.1 PC5022.2 145.58,137.12 PC5023.2 ; PC710.1 34.76,38.7 v2(34.54,38.47) ; v2(192.42,33.3) 191.85,32.73 RE4.1 191.52,31.66 QE5.3 ; v2(349.35,59.53) 348.92,59.96 CT38.2 348.92,62.44 YT1.4 348.55,63.04 v2(349.67,64.16) 349.67,66.13 v2(349.42,66.39) 349.29,66.26 v2(347.45,66.26) 346.85,65.66 YT1.2 ; JRTC.3 261.86,22.76 v2(262.95,23.85) ; v2(29.29,49.62) 28.82,49.62 CL22.2 ; PC5214.2 v2(114.36,131.42) ; JTP.9 139.45,22.98 v2(138.98,22.51) ; v2(10.77,43.14) 11.09,43.14 11.6,43.65 RI23.1 ; v2(116.9,115.47) 117.31,115.47 PC5110.2 ; PC5114.1 142.6,129.24 v2(142.6,128.93) ; v2(265.85,77.63) PC18V09.2 ; CE1.2 v2(118.47,22) ; CG64.2 215.74,75.83 CG65.2 215.74,76.42 v2(215.82,76.51) ; JBL1.5 v2(195.95,23.66) ; v2(116.92,114.76) 117.41,114.26 PC5111.2 ; RG123.2 256.9,124.1 v2(256.52,123.72) ; v2(298.83,31.02) 298.94,30.91 299.87,30.91 299.87,30.91 CH209.2 ; 299.82,49.07 300.29,49.07 300.65,49.43 CH48.2 ; PC4001.2 PC4000.2 v2(120.05,104.67) ; DE4.2 156.44,23.92 CE105.2 155.5,23.84 CE80.2 154.74,23.85 v2(154.6,23.71) ; CG152.2 260.31,87.49 260.3,87.48 260.3,87.3 v2(260.78,86.83) ; v2(95.16,62.77) 94.68,63.25 JEDP1.41 ; v2(298.24,60.51) 296.01,58.28 JCAM1.7 ; v2(366.88,74.32) 366.88,74.9 DT11.1 ; CZ96.2 182.68,113.07 v2(182.44,113.07) 181.78,113.07 181.27,112.56 CZ28.2 ; CV922.2 v2(89.76,42.8) ; v2(24.85,51.01) CL34.2 CL20.2 ; PC25V05.2 v2(165.62,27.71) ; CG79.2 215.62,133.76 CG389.2 ; C5235.2 224.75,27.18 D5223.1 224.69,25.54 224.36,25.21 v2(224.36,23.84) ; v2(14.99,50.51) RI54.1 ; v2(201.46,142.78) 201.9,143.22 CG406.2 ; v2(245.98,136.9) 246.34,137.26 RG120.2 ; v2(135.76,100.13) 135.92,99.98 CH211.2 ; v2(160.54,108.33) 160.48,108.27 RH33.2 RH29.2 ; CG364.2 CG134.2 247.27,128.23 v2(245.93,129.58) ; PR10V3.2 v2(114.34,93.56) ; RE67.1 306.05,20.53 305.54,20.02 CE66.2 305.09,20.02 305.09,19.27 v2(304.97,19.14) ; RE114.1 311.37,11.09 v2(311.06,11.39) ; v2(132.18,101.82) 132.18,102.05 132.55,102.42 PR4010.1 ; v2(356.66,65.92) 356.57,66 CT99.2 ; v2(284.57,11.2) 284.57,11.64 285.03,12.09 CTPM3.2 ; PC4004.2 v2(120.06,106.52) ; v2(263.04,91.57) CG168.2 ; v2(133.29,28.45) 132.82,28.92 UE4.2 ; v2(295.83,12.73) 295.83,12.03 CTPM2.2 ; v2(136.48,88.69) 136.49,88.71 RH186.2 ; CV600.1 367.2,90.52 v2(367.89,89.82) ; CE63.1 311.75,23.47 312.27,23.99 v2(312.27,24.29) ; RI57.1 v2(12.49,43.53) ; PR6000.2 151.83,136.87 v2(151.56,136.6) ; PC25V01.2 PC25V02.2 175.78,28.51 v2(175.78,27.59) ; PC25V06.2 v2(171.82,23.78) ; v2(223.06,72.78) RG65.1 ; PC5209.2 v2(125.07,117.38) ; PC4012.2 v2(126.1,100.54) ; RG23.1 196.51,109.2 v2(195.97,109.2) 195.02,109.2 PR6030.2 ; JCAM1.1 296.14,61 296.69,61.56 297.41,61.56 v2(297.78,61.19) ; v2(260.48,127.72) 259.58,126.82 QG3.3 ; RH58.1 RH61.1 136.05,95.75 v2(135.84,95.96) ; v2(302.68,19.14) 302.43,19.4 RE22.2 ; v2(366.66,96.72) CV601.1 ; RG88.1 191.11,82.94 v2(191.66,82.39) ; RTPM7.2 295.94,15.41 v2(296.43,14.92) ; v2(85.93,47.82) 85.93,47.11 85.93,47.11 DI3.1 ; v2(356.16,67.42) 355.68,67.42 CT98.2 ; RI25.1 v2(10.71,55.02) ; v2(315.76,7.58) 314.87,7.58 314.22,8.23 CE64.1 314.21,8.42 CE68.2 ; v2(183.87,113.06) 184.32,112.61 CZ88.2 184.75,112.37 185.19,112.82 CZ97.2 ; PR6056.1 152.69,140.71 v2(152.11,140.13) ; CE6.2 194.92,32.43 v2(194.92,33.3) ; RG89.1 v2(193.02,79.15) ; JEDP1.42 v2(95.28,38.75) ; PC5020.2 v2(143.8,135.45) ; v2(313.51,21.22) 313.83,20.89 CE77.2 ; QV2.3 v2(81.51,33.18) ; PC5585.2 PC5569.2 168.87,109.65 v2(168.72,109.5) RH41.2 ; PR6063.1 157.53,132.12 v2(157.27,131.85) ; v2(214.68,71.97) 214.03,71.97 CG289.2 ; v2(249.6,85.51) 248.84,86.26 CG151.2 ; v2(137.87,136.77) 137.8,136.85 PC5035.2 ; QG4.3 261.48,88.54 v2(262.56,88.54) ; v2(202.22,33.4) 201.96,33.14 CE5.2 202.82,31.75 CD69.2 ; v2(261.6,104.35) 261.6,105.19 260.84,105.94 CG421.2 ; PC25V04.2 164.42,27.72 v2(164.42,27.71) ; D5226.1 214.45,31.88 213.69,32.64 v2(213.69,33.33) ; CTPM5.2 v2(284.63,13.6) ; v2(21.4,49.48) 21.55,49.33 CL19.2 ; CH215.2 v2(284.24,21.86) ; v2(304.09,9.22) 303.81,8.94 CE67.2 ; CC27.2 v2(267.01,15) ; v2(308.14,6.06) 307.75,6.45 CE71.2 ; RH558.2 v2(268.96,50.32) ; v2(16.46,34.37) CR10.2 16.46,32.22 CR9.2 ; PC4007.2 133.87,93.21 PC4009.2 133.9,92.61 v2(134.29,92.22) ; PR5210.1 135.44,138.27 v2(135.91,138.73) 135.93,138.76 PC5014.2 ; v2(327.19,40.35) 327.19,40.85 RP43.1 ; PC5108.2 PC5109.2 154.26,130.51 v2(154.88,131.13) ; CH179.2 298.71,47.79 298.55,47.64 v2(298.55,47.6) ; v2(354.05,69.75) 353.86,69.94 CT101.2 CT88.2 354.85,70.55 355.65,70.55 RT75.2 ; v2(301.77,52.99) 302.31,52.44 YH2.4 ; PC1.2 v2(48.18,63.68) ; v2(20.58,42.19) 21.43,42.19 21.74,42.51 21.74,43.66 CL37.2 22.16,43.8 v2(22.52,44.16) ; v2(20.58,42.19) YL2.2 ; PC5566.2 175.02,110.34 PC5586.2 175.03,110.12 v2(174.41,109.5) ; v2(33.25,45.05) 33.4,44.9 PR719.2 ; v2(10.55,29.75) CR8.1 ; CD38.2 CD40.2 284.94,7.46 v2(285.39,7) ; PC25V00.2 v2(175.05,33.11) ; v2(21.18,48.12) 21.41,48.35 RL31.1 CL24.2 ; CH46.2 v2(291.75,27.27) ; v2(372.02,119.64) 371.93,119.73 CVGA22.2 ; v2(265.91,78.51) PR18V07.1 ; PC10V5.2 v2(121.83,96.68) ; JHDD1.14 241.44,24.55 v2(242.38,23.61) ; CG320.2 v2(218.56,75.78) ; US2.2 v2(352.47,36.92) ; CG420.2 251.32,86.89 251.13,86.7 251.13,85.58 v2(251.2,85.51) ; v2(304.14,27.84) 305.09,26.89 CE73.2 ; RH60.1 v2(133.33,99.95) ; v2(13.5,24.86) CR4.2 ; v2(3.85,49.37) RI56.1 ; JNGFF2.68 272.38,26.88 v2(272.26,26.76) ; CL39.2 v2(25.01,56.43) ; YG1.2 v2(195.33,81.82) ; PC5024.2 129.15,138.2 PC5008.2 127.63,138.18 127.51,138.3 127.45,138.3 v2(127.42,138.33) ; v2(139.84,140.7) 139.66,140.52 PC5003.2 ; CH50.1 299.01,26.86 v2(298.59,27.28) ; RH148.1 173.56,71.53 RH150.1 173.56,72.41 RH149.1 ; JEDP1.44 91.15,46.65 90.66,47.14 89.75,47.14 v2(89.64,47.02) ; JBL1.6 v2(188.55,23.8) ; v2(263.64,88.99) 263.29,88.65 CG150.2 ; PC214.2 v2(113.14,72.68) ; PR4009.2 v2(129.69,101.06) ; CG388.2 217.14,127.79 v2(218.53,129.18) ; PC4.2 v2(55.41,56.62) ; PC5219.2 v2(114.39,130.53) ; v2(292.52,20.5) CTPM6.2 ; PR4005.2 126.43,106.54 PC4011.2 126.42,106.82 v2(126.81,107.2) ; v2(16.16,23.32) CR7.1 ; DT15.1 v2(370.1,75.94) ; PC10V7.2 v2(123.52,91.79) ; CS13.2 CS12.2 241.79,31.31 240.64,32.46 v2(240.64,33.3) ; RV537.2 v2(87.33,48.86) ; v2(359.07,90.33) 359.56,90.82 UT5.4 ; PC3.2 v2(55.39,57.57) ; v2(214.99,76.04) 214.42,76.04 CG290.2 ; EC5206.2 285.53,60.26 v2(285.89,59.9) 286.09,59.69 287.59,59.69 DA1.1 ; v2(15,51.4) RI55.1 ; v2(220.26,73.18) 220.26,72.55 219.94,72.23 CG288.2 219.94,71.97 221.22,70.68 CG386.2 ; CE84.1 299.59,21.03 CE69.2 300.56,20.93 CE12.2 300.71,21.06 v2(300.71,21.62) ; v2(15,48.73) RI46.1 ; v2(344.23,53.86) 344.07,53.7 JNGFF1.69 ; CG390.2 216.75,140.37 v2(217.56,140.37) ; CE4.2 194.1,31.7 v2(194.1,33.3) ; v2(346.42,22.03) 346.41,22.04 RA14.2 ; RH166.1 136.47,97.81 v2(135.79,97.81) ; CLRP1.2 294.1,22.77 v2(293.54,23.33) ; UH8.4 304.01,44.33 303.37,43.68 303.37,42.43 v2(303.25,42.32) ; CL32.2 CL35.2 24.65,40 v2(24.68,39.97) ; v2(133.85,145.12) 133.89,145.09 133.89,144.82 134.2,144.5 PC5000.2 ; v2(23.98,39.97) 23.7,40.25 CL42.2 ; v2(206.81,23.67) 206.85,23.71 JLED.5 ; JLED.6 199.45,23.7 v2(199.41,23.67) ; CA9.2 v2(337.03,17.24) ; PR6119.1 v2(172.3,115.43) ; RH185.2 v2(135.77,90.36) ; RH567.1 271.11,34.56 v2(271.06,34.51) 270.79,34.24 RH550.2 ; v2(164.92,128.96) PC5130.2 164.92,127.39 PC5133.2 ; PR109.2 v2(255.06,36.79) ; CA4.2 v2(334.75,7.71) ; v2(3.85,50.32) RI47.1 ; v2(92.37,57.27) 91.8,56.7 JEDP1.43 ; v2(156.56,131.51) PR6059.1 PR6058.1 ; YG1.4 v2(193.63,86.13) ; v2(139.84,136.77) 139.84,137.86 PC5021.1 ; v2(345.82,31.82) 345.44,32.2 JNGFF1.68 ; CI24.2 349.34,34.64 348.93,34.23 v2(348.93,33.23) ; PC712.2 35.71,39.65 v2(35.6,39.54) ; CA12.2 344.46,22.04 v2(344.45,22.03) ; RG87.1 v2(193.65,75.66) ; RI45.2 v2(14.64,38.57) ; RH187.2 v2(135.77,91.31) ; v2(10.55,30.76) RI3.2 ; RI49.2 v2(14.57,39.46) ; v2(3.89,46.51) RI48.1 ; v2(363.51,88.29) 363.77,88.55 UV17.2 ; RH59.2 135.71,93.98 135.67,94.01 v2(135.66,94.01) ; v2(3.85,53.18) RI58.1 ; PC5002.2 137.66,140.92 v2(137.87,140.7) ; v2(365.85,82.15) CV599.1 ; PR25V01.2 v2(174.16,33.11) ; v2(211.06,139.58) 211.64,139.58 212.81,138.41 QG2.3 214.57,138.49 214.57,139.13 CG99.2 ; RL27.1 v2(21.49,55.72) ; JTP.5 v2(145.45,30.61) ; DI8.1 v2(358.56,33.47) ; JTP.10 v2(152.45,23.79) ; v2(262.83,120.37) 262.66,120.54 CG116.2 ; v2(364.36,89.88) 364.83,90.35 CV597.2 ; RE35.2 CE91.2 v2(303.63,12.79) ; v2(286.86,20.42) RH77.2 ; v2(10.33,32.39) RI51.1 ; CI3.2 v2(11.6,55.02)
  vias: v2(0.43,99.36) v2(0.44,97.64) v2(0.43,81.25) v2(0.43,55.51) v2(0.43,53.78) v2(0.43,52.05) v2(0.43,50.33) v2(0.43,48.6) v2(0.43,46.87) v2(0.43,45.15) v2(0.43,43.42) v2(0.43,41.69) v2(0.43,39.96) v2(0.43,38.24) v2(0.43,36.51) v2(0.43,34.78) v2(0.43,33.06) v2(0.43,31.33) v2(0.43,29.6) v2(0.45,27.87) v2(1.06,57.12) v2(1.74,82.38) v2(1.8,100.42) v2(1.98,80.48) v2(1.97,27.06) v2(2.43,25.39) v2(2.43,23.67) v2(2.43,21.94) v2(2.78,57.23) v2(3.28,20.43) v2(3.5,100.73) v2(3.57,79.56) v2(3.72,82.38) v2(3.65,77.96) v2(3.66,75.68) v2(3.65,58.73) v2(3.89,97.6) v2(4,60.42) v2(4.11,105.83) v2(4.73,74.88) v2(5.01,20.43) v2(5.14,81.7) v2(5.34,98.55) v2(5.39,103.3) v2(5.39,78.4) v2(5.39,24) v2(5.81,106.12) v2(6.4,105.04) v2(6.4,76.66) v2(6.4,25.74) v2(6.4,22.26) v2(7.04,98.8) v2(7.21,43.78) v2(7.34,58.26) v2(7.45,60.42) v2(7.93,82.38) v2(8.16,75.18) v2(8.29,97.6) v2(8.4,105.04) v2(8.4,76.66) v2(8.4,25.74) v2(8.4,22.26) v2(8.61,50.19) v2(8.61,48.54) v2(8.68,36.97) v2(9.06,106.12) v2(9.18,43.78) v2(9.28,37.57) v2(9.28,36.38) v2(9.41,103.3) v2(9.41,78.4) v2(9.44,49.37) v2(9.41,24) v2(9.66,82.38) v2(9.89,75.18) v2(9.9,60.12) v2(9.88,36.97) v2(10.19,20.43) v2(10.26,50.19) v2(10.26,48.54) v2(10.99,106.12) v2(11.58,82.39) v2(11.58,75.54) v2(11.59,59.75) v2(11.91,20.43) v2(12.04,56.48) v2(12.55,102.64) v2(12.65,105.65) v2(13,74.56) v2(13,62.32) v2(13,60.59) v2(13.64,20.43) v2(13.91,104.46) v2(14.01,100.99) v2(14.01,36.29) v2(14.5,34.53) v2(14.89,28.81) v2(14.89,27) v2(15.16,103.28) v2(15.36,20.61) v2(15.79,27.9) v2(16.41,102.09) v2(16.69,28.81) v2(16.69,27) v2(16.9,21.4) v2(17.67,100.9) v2(18.03,22.7) v2(18.92,99.71) v2(19.09,24.07) v2(19.75,98.2) v2(19.92,96.48) v2(20.15,94.77) v2(20.44,93.06) v2(20.49,25.07) v2(20.81,91.38) v2(21.24,89.7) v2(21.74,88.05) v2(22.13,25.63) v2(22.3,86.41) v2(22.49,29) v2(22.92,84.8) v2(23.5,30.74) v2(23.5,27.26) v2(23.85,25.7) v2(24.36,81.66) v2(25.17,80.14) v2(25.21,45.34) v2(25.21,44.22) v2(25.5,30.74) v2(25.5,27.26) v2(25.52,25.26) v2(26.33,46.45) v2(26.33,45.34) v2(26.33,44.22) v2(26.51,29) v2(26.63,79.22) v2(27,24.36) v2(27.45,46.45) v2(27.45,45.34) v2(27.45,44.22) v2(28.15,23.08) v2(28.36,79.22) v2(29.18,21.69) v2(30.08,79.22) v2(30.89,21.43) v2(31.15,31.27) v2(31.5,42.57) v2(31.8,79.03) v2(32.49,45.52) v2(32.62,21.43) v2(32.83,77.65) v2(33.47,39.54) v2(33.47,37.41) v2(33.92,76.31) v2(34.34,21.43) v2(35.07,75.01) v2(35.51,55.8) v2(35.5,55.13) v2(35.52,54.49) v2(35.52,53.73) v2(35.52,52.97) v2(35.6,37.41) v2(36.07,21.43) v2(36.27,73.77) v2(36.34,55.8) v2(36.32,55.13) v2(36.35,54.49) v2(36.35,53.73) v2(36.35,52.97) v2(36.27,36.79) v2(36.89,36.79) v2(37.19,29.9) v2(37.19,29.2) v2(37.53,72.59) v2(37.8,21.43) v2(38.01,29.9) v2(38.01,29.2) v2(38.83,71.46) v2(38.84,29.9) v2(38.84,29.2) v2(39.53,21.43) v2(39.66,29.9) v2(39.66,29.2) v2(40.19,70.39) v2(40.43,29.9) v2(40.43,29.2) v2(41.19,29.9) v2(41.19,29.2) v2(41.25,21.43) v2(41.59,69.38) v2(41.95,29.9) v2(41.95,29.2) v2(42.65,29.9) v2(42.65,29.2) v2(43.04,68.44) v2(42.98,21.43) v2(43.77,41.38) v2(43.77,40.73) v2(43.77,40.1) v2(43.77,39.46) v2(43.77,38.83) v2(44.35,41.28) v2(44.39,40.69) v2(44.53,67.56) v2(44.71,21.43) v2(46.05,66.75) v2(46.43,21.43) v2(47.61,66) v2(48.16,21.43) v2(48.95,34.93) v2(49.2,65.33) v2(49.58,34.93) v2(49.89,21.43) v2(50.25,34.92) v2(50.82,64.73) v2(50.89,34.92) v2(51.5,34.92) v2(51.62,21.43) v2(52.13,34.92) v2(52.46,64.2) v2(53.34,21.43) v2(54.13,63.74) v2(55.07,21.43) v2(55.81,63.36) v2(56.8,21.43) v2(57.51,63.05) v2(58.52,21.43) v2(59.03,54.57) v2(59.22,62.81) v2(59.79,54.57) v2(60.25,21.43) v2(60.55,54.57) v2(60.94,62.66) v2(61.25,54.57) v2(61.98,21.43) v2(62.41,61.75) v2(62.95,35.4) v2(63.71,21.43) v2(63.89,60.86) v2(64.99,31.82) v2(65.43,21.43) v2(65.61,60.95) v2(65.62,31.82) v2(66.26,31.82) v2(66.99,61.99) v2(67.03,42.83) v2(67.03,42.19) v2(67.16,21.43) v2(67.73,42.83) v2(67.73,42.19) v2(67.73,41.49) v2(67.73,40.86) v2(68.05,29.52) v2(68.47,62.87) v2(68.49,42.83) v2(68.49,42.19) v2(68.49,41.49) v2(68.49,40.86) v2(68.56,40.22) v2(68.89,21.43) v2(69.19,42.19) v2(69.19,41.49) v2(69.19,40.86) v2(69.19,40.22) v2(69.89,42.19) v2(69.89,41.49) v2(69.89,40.86) v2(69.89,40.22) v2(70.18,63.13) v2(70.59,42.19) v2(70.59,41.49) v2(70.59,40.86) v2(70.59,40.22) v2(70.62,21.43) v2(71.29,42.83) v2(71.29,42.19) v2(71.29,41.49) v2(71.29,40.86) v2(71.29,40.22) v2(71.48,45.94) v2(71.48,45.24) v2(71.48,44.54) v2(71.88,63.46) v2(72.34,21.43) v2(73.56,63.86) v2(74.07,21.43) v2(75.21,64.34) v2(75.8,21.43) v2(76.85,64.89) v2(77.52,21.43) v2(77.57,25.62) v2(78.46,65.52) v2(79.25,21.43) v2(79.35,25.62) v2(80.04,66.21) v2(80.66,42.82) v2(80.98,21.43) v2(81.28,42.82) v2(81.28,42.2) v2(81.59,66.98) v2(81.9,42.82) v2(82.71,21.43) v2(83.11,67.81) v2(84.34,61.28) v2(84.43,21.43) v2(84.58,68.71) v2(84.75,52.61) v2(86.02,69.67) v2(86.16,21.43) v2(86.41,59.92) v2(86.59,57.81) v2(86.95,61.15) v2(87.22,54.83) v2(87.41,70.69) v2(87.89,21.43) v2(88.75,71.78) v2(89.61,21.43) v2(90.04,72.93) v2(91.28,74.13) v2(91.34,21.43) v2(92.47,75.38) v2(93.07,21.43) v2(93.6,76.69) v2(94.8,21.43) v2(95.08,77.58) v2(96.52,21.43) v2(96.8,77.58) v2(98.25,21.43) v2(98.53,77.58) v2(99.98,21.43) v2(100.26,77.58) v2(101.7,21.43) v2(101.96,77.87) v2(102.17,55.25) v2(102.81,55.25) v2(102.81,54.61) v2(103.07,36.57) v2(103.44,55.25) v2(103.44,54.61) v2(103.43,21.43) v2(103.51,78.65) v2(103.68,41.67) v2(103.71,40.45) v2(103.76,39) v2(103.76,37.68) v2(104.05,36.35) v2(104.76,79.84) v2(104.83,41.58) v2(104.94,39.78) v2(105.16,21.43) v2(105.6,81.34) v2(105.7,71.26) v2(105.69,70.67) v2(105.69,70.08) v2(105.98,84.76) v2(105.97,83.03) v2(106.47,63.78) v2(106.6,86.37) v2(106.89,21.43) v2(107,44.83) v2(107,44.19) v2(107.04,33.3) v2(107.1,63.78) v2(107.1,41.3) v2(107.11,40.03) v2(107.1,38.64) v2(107.1,37.36) v2(107.1,36.06) v2(107.44,72.24) v2(107.44,71.54) v2(107.74,63.78) v2(108.04,72.23) v2(108.04,71.53) v2(108.3,86.69) v2(108.26,40.73) v2(108.29,39.56) v2(108.31,33.3) v2(108.37,63.78) v2(108.36,38.36) v2(108.62,72.23) v2(108.62,71.53) v2(108.61,21.43) v2(109.26,72.23) v2(109.26,71.53) v2(109.35,33.3) v2(110.03,86.7) v2(110.34,21.43) v2(110.85,36.67) v2(110.94,38.48) v2(111.04,70.2) v2(111.04,69.6) v2(110.97,67.18) v2(110.96,40.97) v2(110.96,39.7) v2(111.65,87.3) v2(111.59,67.81) v2(111.59,66.56) v2(112.07,21.43) v2(112.22,67.18) v2(112.78,88.6) v2(112.82,45.84) v2(112.82,33.34) v2(113.13,136.93) v2(113.13,135.2) v2(113.13,133.47) v2(113.13,131.75) v2(113.13,130.02) v2(113.13,128.29) v2(113.13,126.56) v2(113.13,124.84) v2(113.13,123.11) v2(113.13,121.38) v2(113.13,119.66) v2(113.13,117.93) v2(113.13,116.2) v2(113.13,114.47) v2(113.13,112.75) v2(113.13,111.02) v2(113.13,109.29) v2(113.13,107.57) v2(113.13,105.84) v2(113.13,104.11) v2(113.13,102.38) v2(113.13,100.66) v2(113.13,98.93) v2(113.13,97.2) v2(113.13,95.48) v2(113.13,93.75) v2(113.13,92.02) v2(113.13,90.29) v2(113.64,36.64) v2(113.69,138.56) v2(113.67,37.95) v2(113.71,20.9) v2(113.81,40.51) v2(113.83,39.32) v2(114.87,124.3) v2(114.87,123.66) v2(115.05,96.1) v2(115.05,95.52) v2(115.05,94.94) v2(115.05,94.35) v2(115.19,137.3) v2(115.37,20.43) v2(115.6,40.89) v2(115.62,39) v2(116.2,139.04) v2(116.2,135.56) v2(116.93,41.52) v2(116.93,36.44) v2(117.1,20.43) v2(117.83,40.86) v2(117.83,39.59) v2(117.83,38.32) v2(117.9,37.05) v2(118.1,140.77) v2(118.2,139.04) v2(118.2,135.56) v2(118.58,95.77) v2(118.58,93.77) v2(118.58,33.3) v2(118.83,20.43) v2(119.11,119.37) v2(119.11,118.4) v2(119.21,137.3) v2(119.17,94.77) v2(119.26,128.11) v2(119.26,127.14) v2(119.58,33.3) v2(119.75,95.77) v2(119.75,93.77) v2(119.94,84.78) v2(119.94,84.15) v2(119.95,85.38) v2(120.25,121.85) v2(120.25,120.98) v2(120.25,120.12) v2(120.25,119.26) v2(120.31,100.04) v2(120.31,99.41) v2(120.4,130.58) v2(120.4,129.72) v2(120.4,128.86) v2(120.4,127.99) v2(120.36,41.25) v2(120.36,39.94) v2(120.38,39.32) v2(120.36,37.85) v2(120.45,36.46) v2(120.55,84.48) v2(120.54,83.86) v2(120.56,85.11) v2(120.56,20.43) v2(121.03,121.85) v2(121.03,120.98) v2(121.03,120.12) v2(121.03,119.26) v2(121.18,130.58) v2(121.18,129.72) v2(121.18,128.86) v2(121.18,127.99) v2(121.55,140.77) v2(121.81,121.85) v2(121.81,120.98) v2(121.81,120.12) v2(121.81,119.26) v2(121.9,124.62) v2(121.9,123.98) v2(121.96,130.58) v2(121.96,129.72) v2(121.96,128.86) v2(121.96,127.99) v2(122.28,20.43) v2(122.47,47.43) v2(122.47,40.59) v2(122.68,38.85) v2(122.68,36.91) v2(123.28,140.77) v2(123.91,38.39) v2(123.99,37.09) v2(123.99,21.5) v2(124,20.6) v2(124.37,92.23) v2(124.37,44.24) v2(124.55,108.35) v2(124.61,107.75) v2(124.55,102.79) v2(124.56,100.42) v2(124.56,99.84) v2(124.68,107.17) v2(124.75,90.87) v2(125.01,140.77) v2(124.96,92.23) v2(125,23.24) v2(125.21,108.04) v2(125.21,107.46) v2(125.34,90.87) v2(125.54,92.23) v2(125.52,41.68) v2(125.79,108.04) v2(125.92,90.87) v2(125.91,36.59) v2(126.59,94.69) v2(126.59,94.11) v2(126.59,93.53) v2(126.72,140.96) v2(126.72,72.62) v2(127,23.24) v2(127.44,145.99) v2(127.43,144.27) v2(127.43,142.54) v2(127.86,36.59) v2(127.86,35.98) v2(128.02,74.87) v2(128.02,70.37) v2(128.01,21.5) v2(128.09,39.81) v2(128.08,38.51) v2(128.18,100.29) v2(128.18,99.66) v2(129.1,146.47) v2(129.31,40.15) v2(129.31,38.98) v2(129.32,37.8) v2(129.44,20.43) v2(130.21,116.09) v2(130.62,74.87) v2(130.62,70.37) v2(130.83,146.47) v2(131.17,20.43) v2(131.29,37.33) v2(131.51,118.34) v2(131.51,113.84) v2(131.92,72.62) v2(132.55,146.47) v2(132.89,20.43) v2(133.44,132.98) v2(133.44,132.4) v2(133.64,36.68) v2(133.77,40.63) v2(133.76,39.46) v2(133.77,38.3) v2(134.02,132.98) v2(134.02,132.4) v2(134.1,129.07) v2(134.1,128.49) v2(134.1,127.9) v2(134.11,118.34) v2(134.11,113.84) v2(134.28,146.47) v2(134.41,111.31) v2(134.41,110.68) v2(134.41,110.1) v2(134.62,20.43) v2(135.41,116.09) v2(135.81,39.74) v2(135.81,38.41) v2(135.79,37.22) v2(135.91,140.7) v2(135.91,136.77) v2(136.01,146.47) v2(136.35,20.43) v2(136.5,83.46) v2(137.61,82.78) v2(137.64,40.69) v2(137.63,38.76) v2(137.64,36.82) v2(137.74,146.47) v2(137.71,84.23) v2(137.71,77.85) v2(137.87,138.73) v2(137.88,21.23) v2(139.3,74.76) v2(139.46,146.47) v2(139.6,21.43) v2(140.4,76.17) v2(140.49,39.44) v2(140.49,38.13) v2(140.49,36.9) v2(141.19,146.47) v2(141.28,126.73) v2(141.32,21.43) v2(141.9,145.01) v2(142.13,125.58) v2(142.13,124.8) v2(142.13,124.02) v2(142.24,126.73) v2(142.22,74.98) v2(142.53,145.01) v2(142.92,146.47) v2(142.95,39.07) v2(142.99,125.58) v2(142.99,124.8) v2(142.99,124.02) v2(143.01,37.88) v2(143.05,21.43) v2(143.17,145.01) v2(143.41,76.27) v2(143.8,145.01) v2(143.86,125.58) v2(143.86,124.8) v2(143.86,124.02) v2(144.65,146.47) v2(144.74,130.94) v2(144.72,125.58) v2(144.72,124.8) v2(144.72,124.02) v2(144.78,21.43) v2(145.35,130.94) v2(145.63,112.84) v2(145.62,40.24) v2(145.64,38.93) v2(145.57,37.66) v2(145.84,131.6) v2(145.76,75.72) v2(145.96,131.03) v2(145.96,88.65) v2(146.32,123.98) v2(146.32,123.35) v2(146.32,122.71) v2(146.32,122.08) v2(146.32,121.44) v2(146.32,120.74) v2(146.27,112.84) v2(146.35,74.56) v2(146.37,146.47) v2(146.5,21.43) v2(146.61,99.93) v2(146.66,131.03) v2(146.91,123.98) v2(146.91,123.35) v2(146.91,122.71) v2(146.91,122.08) v2(146.91,121.44) v2(146.91,120.74) v2(146.9,112.84) v2(147.38,99.94) v2(147.55,123.98) v2(147.55,123.35) v2(147.55,122.71) v2(147.55,122.08) v2(147.55,121.44) v2(147.55,120.74) v2(147.74,75.85) v2(148.1,146.47) v2(148.23,21.43) v2(148.38,40) v2(148.38,39.39) v2(148.37,38.77) v2(148.37,37.56) v2(148.6,141.2) v2(148.65,130.23) v2(148.95,99.94) v2(149.26,141.2) v2(149.72,99.96) v2(149.83,146.47) v2(149.92,141.2) v2(149.87,126.92) v2(149.96,21.43) v2(150.58,141.2) v2(150.57,40.38) v2(150.57,38.63) v2(150.59,36.82) v2(150.58,33.43) v2(150.72,125.78) v2(150.72,124.99) v2(150.72,124.21) v2(150.84,126.92) v2(151.29,99.94) v2(151.55,146.47) v2(151.59,125.78) v2(151.59,124.99) v2(151.59,124.21) v2(151.55,76.09) v2(151.73,40.72) v2(151.73,39.46) v2(151.71,38.24) v2(151.69,21.43) v2(151.93,33.37) v2(152.1,99.94) v2(152.45,125.78) v2(152.45,124.99) v2(152.45,124.21) v2(152.95,74.45) v2(153.28,146.47) v2(153.32,125.78) v2(153.32,124.99) v2(153.32,124.21) v2(153.3,39.73) v2(153.43,95.02) v2(153.41,21.43) v2(153.46,93.65) v2(153.7,99.94) v2(153.77,33.26) v2(154.34,120.55) v2(154.45,99.96) v2(154.62,38.66) v2(154.6,36.6) v2(154.71,123.98) v2(154.86,20.49) v2(155.01,146.47) v2(154.98,120.55) v2(154.98,95.79) v2(155.35,123.98) v2(155.59,123.35) v2(155.59,122.65) v2(155.59,121.95) v2(155.59,121.25) v2(155.59,120.55) v2(155.81,33.34) v2(155.98,123.98) v2(156.04,99.94) v2(156.19,123.35) v2(156.19,122.65) v2(156.19,121.95) v2(156.19,121.25) v2(156.19,120.55) v2(156.54,40.95) v2(156.54,39.75) v2(156.55,38.45) v2(156.59,20.43) v2(156.74,146.47) v2(156.82,139.66) v2(156.82,138.14) v2(156.82,136.62) v2(156.81,99.93) v2(157.06,33.34) v2(157.48,45.62) v2(157.52,44.35) v2(157.82,39.78) v2(157.86,41.06) v2(158.34,139.66) v2(158.34,138.14) v2(158.34,136.62) v2(158.32,20.43) v2(158.41,99.94) v2(158.46,146.47) v2(158.55,126.92) v2(158.54,75.39) v2(158.59,94.92) v2(158.59,93.55) v2(158.59,90.87) v2(159.07,96.47) v2(159.16,99.94) v2(159.4,125.78) v2(159.4,125) v2(159.4,124.21) v2(159.51,126.92) v2(159.87,139.66) v2(159.87,138.14) v2(159.87,136.62) v2(160.05,20.43) v2(160.19,146.47) v2(160.25,36.18) v2(160.26,125.78) v2(160.26,125) v2(160.26,124.21) v2(160.44,37.42) v2(160.49,40.72) v2(160.49,38.74) v2(161.13,125.78) v2(161.13,125) v2(161.13,124.21) v2(161.08,33.43) v2(161.56,99.94) v2(161.77,20.43) v2(161.92,146.47) v2(161.99,125.78) v2(161.99,125) v2(161.99,124.21) v2(162.08,33.29) v2(162.35,40.6) v2(162.29,39.37) v2(162.85,33.28) v2(163.34,122.77) v2(163.35,122.15) v2(163.26,90.04) v2(163.5,20.43) v2(163.64,146.47) v2(163.62,120.31) v2(163.92,123.37) v2(163.92,122.79) v2(163.95,122.15) v2(163.93,119.79) v2(163.91,99.93) v2(163.88,40.9) v2(163.88,39.66) v2(163.91,38.37) v2(163.93,36.84) v2(163.96,91.36) v2(163.98,90.03) v2(164.25,120.31) v2(164.25,109.55) v2(164.25,108.16) v2(164.5,122.79) v2(164.53,122.15) v2(164.57,119.79) v2(164.89,121.64) v2(164.89,120.94) v2(164.89,120.31) v2(165.01,33.42) v2(165.23,20.43) v2(165.27,114.65) v2(165.27,113.95) v2(165.37,146.47) v2(165.88,107.09) v2(165.89,33.43) v2(166.01,38.21) v2(166.28,99.94) v2(166.31,40.11) v2(166.95,20.43) v2(167.1,146.47) v2(167.12,123.44) v2(167.96,139.19) v2(167.96,41.4) v2(167.98,40.15) v2(168.02,37.56) v2(168.11,141.62) v2(168.09,125.56) v2(168.08,95.17) v2(168.08,94.53) v2(168.08,93.9) v2(168.08,93.26) v2(168.06,38.89) v2(168.19,33.37) v2(168.33,124.5) v2(168.33,123.34) v2(168.47,74.35) v2(168.57,139.19) v2(168.65,99.96) v2(168.72,142) v2(168.72,141.4) v2(168.72,140.82) v2(168.68,20.43) v2(168.83,146.47) v2(168.89,30.57) v2(169.13,124.5) v2(169.13,123.34) v2(169.2,134.46) v2(169.19,133.82) v2(169.33,141.51) v2(169.33,140.92) v2(169.33,140.3) v2(169.33,139.66) v2(169.47,30.57) v2(169.69,131.41) v2(169.69,130.83) v2(169.79,134.27) v2(169.78,73.1) v2(169.93,124.5) v2(169.93,123.2) v2(170,45.62) v2(170.05,30.57) v2(170.23,99.96) v2(170.37,134.27) v2(170.41,20.43) v2(170.55,75.85) v2(170.55,146.47) v2(170.64,30.57) v2(170.99,99.96) v2(171.77,99.93) v2(171.87,74.58) v2(172.14,20.43) v2(172.28,146.47) v2(172.25,77.4) v2(173.46,123.28) v2(173.46,122.65) v2(173.79,43.23) v2(173.91,139.92) v2(173.91,138.96) v2(173.86,20.43) v2(174.01,146.47) v2(174.05,145.19) v2(174.05,144.61) v2(174.22,127.47) v2(174.36,131.11) v2(174.36,130.14) v2(174.85,136.49) v2(174.85,135.85) v2(175.05,142.4) v2(175.05,141.54) v2(175.05,140.67) v2(175.05,139.81) v2(175.51,133.59) v2(175.51,132.72) v2(175.51,131.86) v2(175.51,131) v2(175.58,76.53) v2(175.59,20.43) v2(175.73,146.47) v2(175.72,115.31) v2(175.72,114.71) v2(175.84,142.4) v2(175.84,141.54) v2(175.84,140.67) v2(175.84,139.81) v2(175.89,118.6) v2(175.89,117.63) v2(176.29,133.59) v2(176.29,132.72) v2(176.29,131.86) v2(176.29,131) v2(176.38,125.72) v2(176.38,125.14) v2(176.38,124.55) v2(176.38,123.97) v2(176.38,123.38) v2(176.38,122.8) v2(176.45,136.86) v2(176.51,136.27) v2(176.51,135.69) v2(176.51,135.11) v2(176.62,142.4) v2(176.62,141.54) v2(176.62,140.67) v2(176.62,139.81) v2(176.76,145.25) v2(176.76,144.67) v2(177.04,136.87) v2(177.04,121.08) v2(177.04,120.21) v2(177.04,119.35) v2(177.04,118.48) v2(177.1,136.29) v2(177.1,135.7) v2(177.1,135.12) v2(177.07,133.59) v2(177.07,132.72) v2(177.07,131.86) v2(177.07,131) v2(177.32,20.43) v2(177.46,146.47) v2(177.62,136.86) v2(177.69,136.27) v2(177.69,135.69) v2(177.69,135.11) v2(177.82,121.08) v2(177.82,120.21) v2(177.82,119.35) v2(177.82,118.48) v2(177.88,134.55) v2(177.88,133.96) v2(178.23,136.86) v2(178.22,124.51) v2(178.22,123.88) v2(178.22,123.28) v2(178.25,122.51) v2(178.28,136.27) v2(178.28,135.69) v2(178.28,135.11) v2(178.47,134.55) v2(178.47,133.96) v2(178.61,144.29) v2(178.6,121.08) v2(178.6,120.21) v2(178.6,119.35) v2(178.6,118.48) v2(178.66,144.87) v2(178.66,143.12) v2(178.82,145.46) v2(178.82,136.87) v2(178.82,124.53) v2(178.82,123.89) v2(178.82,123.28) v2(178.83,122.51) v2(178.89,143.72) v2(178.88,136.29) v2(178.88,135.7) v2(178.88,135.12) v2(178.96,41.29) v2(179.04,20.43) v2(179.07,134.56) v2(179.07,133.98) v2(179.19,146.47) v2(179.2,144.3) v2(179.26,144.88) v2(179.26,143.13) v2(179.4,145.46) v2(179.4,136.86) v2(179.4,124.55) v2(179.4,123.92) v2(179.4,123.28) v2(179.36,122.13) v2(179.36,121.5) v2(179.49,143.73) v2(179.46,136.27) v2(179.46,135.69) v2(179.46,135.11) v2(179.57,35.93) v2(179.66,134.55) v2(179.66,133.96) v2(179.68,122.68) v2(179.85,144.87) v2(179.78,144.29) v2(179.85,143.12) v2(179.99,145.44) v2(180.02,136.87) v2(179.99,124.55) v2(179.99,123.92) v2(179.99,123.28) v2(179.96,122.11) v2(179.96,121.5) v2(180.07,143.72) v2(180.09,136.29) v2(180.09,135.7) v2(180.09,135.12) v2(180.28,134.56) v2(180.28,133.98) v2(180.28,122.7) v2(180.43,144.88) v2(180.37,144.3) v2(180.54,122.14) v2(180.54,121.5) v2(180.57,145.46) v2(180.61,136.86) v2(180.57,124.55) v2(180.57,123.92) v2(180.57,123.28) v2(180.67,136.27) v2(180.67,135.69) v2(180.67,135.11) v2(180.77,20.43) v2(180.92,146.47) v2(180.86,122.7) v2(181.01,144.88) v2(180.95,144.3) v2(181.13,122.14) v2(181.13,121.5) v2(181.05,23.47) v2(181.15,145.46) v2(181.2,124.55) v2(181.2,123.92) v2(181.2,123.28) v2(181.33,22.93) v2(181.4,41.37) v2(181.37,39.49) v2(181.45,38.32) v2(181.53,144.3) v2(181.46,122.71) v2(181.46,116.6) v2(181.51,82.37) v2(181.6,144.88) v2(181.74,145.46) v2(181.71,122.14) v2(181.71,121.5) v2(181.69,23.47) v2(181.81,124.17) v2(181.81,123.54) v2(181.9,117.19) v2(182.04,116.6) v2(181.97,22.93) v2(182.12,144.29) v2(182.18,144.87) v2(182.32,145.44) v2(182.32,23.47) v2(182.4,124.17) v2(182.4,123.54) v2(182.41,107.79) v2(182.49,117.19) v2(182.5,20.43) v2(182.64,146.47) v2(182.63,116.6) v2(182.6,22.93) v2(182.7,144.3) v2(182.77,144.88) v2(182.84,33.39) v2(182.91,145.46) v2(182.98,124.17) v2(182.98,123.54) v2(183.07,117.19) v2(183.29,144.3) v2(183.35,144.88) v2(183.49,145.46) v2(183.62,124.17) v2(183.62,123.54) v2(183.61,44.48) v2(183.57,33.37) v2(183.81,140.77) v2(183.81,140.13) v2(183.81,139.5) v2(183.81,138.86) v2(183.81,41.47) v2(183.81,40.2) v2(183.81,39.03) v2(183.81,37.59) v2(183.94,144.88) v2(183.87,144.3) v2(184.07,145.46) v2(184.23,20.43) v2(184.37,146.47) v2(184.44,140.77) v2(184.44,140.13) v2(184.44,139.5) v2(184.44,138.86) v2(184.44,138.23) v2(184.52,144.87) v2(184.46,144.29) v2(184.66,145.44) v2(184.82,66.39) v2(184.89,67.07) v2(185.02,143.72) v2(185.03,143.13) v2(185.12,144.88) v2(185.05,144.3) v2(185.05,142.55) v2(185.05,141.96) v2(185.05,141.38) v2(185.08,140.77) v2(185.08,140.13) v2(185.08,139.5) v2(185.08,138.86) v2(185.08,138.23) v2(185.14,33.4) v2(185.24,145.46) v2(185.64,144.3) v2(185.61,143.72) v2(185.61,143.13) v2(185.64,142.55) v2(185.64,141.96) v2(185.64,141.38) v2(185.7,144.88) v2(185.71,140.77) v2(185.71,140.13) v2(185.71,139.5) v2(185.71,138.86) v2(185.71,138.23) v2(185.83,145.46) v2(185.75,41.47) v2(185.79,40.2) v2(185.77,39.03) v2(185.75,37.73) v2(185.93,64.18) v2(185.87,20.98) v2(186.1,146.47) v2(186.22,144.3) v2(186.19,143.72) v2(186.2,143.13) v2(186.22,142.55) v2(186.22,141.96) v2(186.22,141.38) v2(186.28,144.88) v2(186.35,140.77) v2(186.35,140.13) v2(186.35,139.5) v2(186.35,138.86) v2(186.35,138.23) v2(186.29,72.7) v2(186.41,145.46) v2(186.41,23.59) v2(186.41,22.95) v2(186.57,33.4) v2(186.81,144.29) v2(186.78,143.7) v2(186.78,143.12) v2(186.81,142.53) v2(186.81,141.95) v2(186.81,141.37) v2(186.87,144.87) v2(187,145.44) v2(186.98,140.77) v2(186.98,140.13) v2(186.98,139.5) v2(186.98,138.86) v2(186.98,138.23) v2(187.18,41.42) v2(187.24,36.48) v2(187.52,74.84) v2(187.52,70.56) v2(187.49,38.51) v2(187.53,21.43) v2(187.57,140.57) v2(187.57,139.93) v2(187.57,139.35) v2(187.57,138.74) v2(187.57,138.15) v2(187.83,146.47) v2(187.93,33.4) v2(188.04,110.5) v2(188.25,139.3) v2(188.25,138.71) v2(188.25,138.13) v2(188.89,138.76) v2(188.89,138.18) v2(189.27,112.64) v2(189.27,108.36) v2(189.3,41.34) v2(189.33,40.1) v2(189.33,38.83) v2(189.33,37.56) v2(189.26,21.43) v2(189.4,33.4) v2(189.52,138.71) v2(189.52,138.13) v2(189.55,146.47) v2(189.98,74.84) v2(189.98,70.56) v2(190.08,36.1) v2(190.16,138.2) v2(190.2,121.31) v2(190.74,138.2) v2(190.78,121.31) v2(190.99,21.43) v2(191.15,41.51) v2(191.14,38.32) v2(191.21,72.7) v2(191.16,40.22) v2(191.16,37.03) v2(191.28,146.47) v2(191.36,121.31) v2(191.73,112.64) v2(191.73,108.36) v2(191.95,121.31) v2(192.66,44.41) v2(192.71,21.43) v2(193.01,146.47) v2(192.96,110.5) v2(193.08,36.03) v2(193.23,37.15) v2(193.26,39.09) v2(194.08,35.95) v2(194.41,40.62) v2(194.44,21.43) v2(194.45,129.06) v2(194.48,39.4) v2(194.48,38) v2(194.58,132.74) v2(194.58,127.92) v2(194.73,146.47) v2(195.03,129.06) v2(195.16,132.74) v2(195.16,127.92) v2(195.42,44.31) v2(195.5,116.87) v2(195.62,129.06) v2(195.57,115.41) v2(195.57,114.07) v2(195.57,111.53) v2(195.75,132.74) v2(195.75,127.92) v2(195.81,33.4) v2(196.2,129.06) v2(196.17,21.43) v2(196.33,132.74) v2(196.33,127.92) v2(196.4,39.53) v2(196.38,38.26) v2(196.46,146.47) v2(196.51,40.8) v2(196.76,136.68) v2(196.76,135.98) v2(196.76,135.28) v2(196.76,134.65) v2(197.08,35.95) v2(197.08,33.4) v2(197.4,137.7) v2(197.4,85.44) v2(197.89,21.43) v2(197.99,137.7) v2(198.19,146.47) v2(198.37,41.43) v2(198.52,38.38) v2(198.52,36.63) v2(198.57,33.4) v2(199.37,91.78) v2(199.58,80.58) v2(199.62,21.43) v2(199.92,146.47) v2(199.86,44.31) v2(200.06,33.4) v2(200.3,79.9) v2(200.88,44.31) v2(200.88,41.34) v2(200.85,40.07) v2(200.85,38.8) v2(200.85,37.53) v2(201.17,104.82) v2(201.18,102.7) v2(201.19,98.52) v2(201.18,96.33) v2(201.21,94.14) v2(201.18,92.13) v2(201.29,33.38) v2(201.35,21.43) v2(201.38,79.2) v2(201.64,146.47) v2(201.61,107.15) v2(201.72,108.8) v2(201.74,104.66) v2(201.74,102.63) v2(201.72,98.28) v2(201.74,96.33) v2(201.67,90.09) v2(201.78,98.83) v2(201.84,94.01) v2(201.75,85.8) v2(202.24,138.01) v2(202.32,120.04) v2(202.4,44.31) v2(202.48,108.74) v2(202.54,88.36) v2(202.6,102.52) v2(202.99,118.96) v2(203.06,90.15) v2(203.08,21.43) v2(203.15,108.75) v2(203.2,84.18) v2(203.37,146.47) v2(203.55,41.39) v2(203.85,107.25) v2(203.85,105.15) v2(203.85,103.05) v2(203.85,100.95) v2(203.85,98.85) v2(203.85,96.75) v2(203.85,94.65) v2(203.85,86.25) v2(204.01,118.13) v2(204,92.5) v2(204.55,107.35) v2(204.55,33.4) v2(204.65,106.65) v2(204.65,104.55) v2(204.65,102.45) v2(204.65,100.35) v2(204.65,98.25) v2(204.65,96.15) v2(204.65,94.05) v2(204.65,91.95) v2(204.65,89.85) v2(204.64,38.48) v2(204.7,117.13) v2(204.7,39.76) v2(204.76,40.93) v2(204.8,21.43) v2(205.1,146.47) v2(205.25,106.55) v2(205.25,104.45) v2(205.25,93.95) v2(205.25,91.85) v2(205.25,89.75) v2(205.57,33.39) v2(205.95,105.25) v2(205.95,98.95) v2(206.53,21.43) v2(206.59,83.6) v2(206.68,118.35) v2(206.73,39.43) v2(206.82,146.47) v2(206.86,38.13) v2(207.62,38) v2(207.81,36.81) v2(208.05,112.25) v2(208.15,114.35) v2(208.15,113.55) v2(208.15,85.65) v2(208.26,83.66) v2(208.26,21.43) v2(208.47,79.44) v2(208.55,146.47) v2(208.77,113.6) v2(208.75,111.55) v2(208.85,110.85) v2(208.85,84.85) v2(208.77,84.23) v2(208.91,39.31) v2(209.02,37.87) v2(209.5,105.9) v2(209.45,103.8) v2(209.45,102.4) v2(209.45,101) v2(209.45,99.6) v2(209.45,98.9) v2(209.45,97.5) v2(209.45,96.1) v2(209.45,95.4) v2(209.45,94) v2(209.45,92.6) v2(209.45,91.2) v2(209.45,89.8) v2(209.45,89.1) v2(209.55,36.72) v2(209.99,21.43) v2(210.15,85.55) v2(210.28,146.47) v2(210.4,118.26) v2(210.41,82.45) v2(210.67,81.33) v2(210.68,39.47) v2(210.85,105.9) v2(210.85,99.6) v2(210.85,98.9) v2(210.85,97.5) v2(210.85,96.1) v2(210.85,95.4) v2(210.85,94) v2(210.85,92.6) v2(210.85,84.95) v2(210.85,84.25) v2(210.99,38.26) v2(211.38,36.9) v2(211.71,21.43) v2(212.01,146.47) v2(211.99,117.61) v2(212.25,99.6) v2(212.25,98.9) v2(212.37,85.6) v2(212.74,80.76) v2(212.79,82.65) v2(212.77,81.33) v2(212.95,84.25) v2(212.9,38.31) v2(213.05,84.85) v2(213.44,21.43) v2(213.65,101) v2(213.73,146.47) v2(214.45,110.76) v2(214.45,84.92) v2(214.57,112.7) v2(214.64,37.77) v2(214.61,35.97) v2(214.86,80.86) v2(214.97,82.71) v2(214.97,41.02) v2(214.97,39.02) v2(215.08,112.21) v2(215.05,102.4) v2(215.05,101) v2(215.15,111.55) v2(215.17,21.43) v2(215.46,146.47) v2(216.33,71.97) v2(216.7,80.8) v2(216.9,85.11) v2(216.89,21.43) v2(217.03,84) v2(217.01,81.34) v2(216.96,39.63) v2(216.98,38.33) v2(216.96,37.11) v2(216.96,35.84) v2(217.15,82.85) v2(217.19,146.47) v2(217.25,91.2) v2(217.47,116.31) v2(217.95,99.55) v2(218.25,79.15) v2(218.55,103.8) v2(218.54,36.79) v2(218.62,21.43) v2(218.79,80.84) v2(218.91,146.47) v2(219.1,81.33) v2(219.35,99.6) v2(219.35,98.9) v2(219.29,83.5) v2(220.35,21.43) v2(220.64,146.47) v2(220.61,39.6) v2(220.69,38.28) v2(220.66,37.04) v2(220.75,101) v2(220.75,99.6) v2(220.75,98.9) v2(220.75,95.4) v2(220.75,85.65) v2(220.75,84.95) v2(220.75,82.11) v2(221.33,84.97) v2(221.35,81.45) v2(222.08,21.43) v2(222.15,99.6) v2(222.15,98.9) v2(222.15,95.4) v2(222.37,146.47) v2(222.54,39.27) v2(222.53,36.61) v2(222.56,37.91) v2(222.89,110.88) v2(222.95,85.45) v2(222.99,112.79) v2(223.15,80.86) v2(223.5,113.6) v2(223.47,112.22) v2(223.45,84.25) v2(223.45,81.45) v2(223.51,33.39) v2(223.55,95.4) v2(223.55,91.2) v2(223.55,89.8) v2(223.8,21.43) v2(223.85,118.85) v2(224.01,120.74) v2(224.1,146.47) v2(224.07,39) v2(224.07,38.33) v2(224.09,37.01) v2(224.95,103.8) v2(224.95,102.4) v2(224.95,101) v2(224.95,99.6) v2(224.95,98.9) v2(224.95,97.5) v2(224.95,89.8) v2(224.88,33.39) v2(225.01,83.98) v2(225.1,80.8) v2(225.1,79.87) v2(225.1,79.29) v2(225.25,82.28) v2(225.35,114.15) v2(225.53,21.43) v2(225.65,113.55) v2(225.82,146.47) v2(225.94,120.64) v2(225.95,118.81) v2(225.85,74.32) v2(226.35,105.9) v2(226.35,105.2) v2(226.35,103.8) v2(226.35,102.4) v2(226.35,101) v2(226.35,99.6) v2(226.35,98.9) v2(226.35,97.5) v2(226.35,96.1) v2(226.35,95.4) v2(226.35,94) v2(226.35,92.6) v2(226.35,91.2) v2(226.35,89.8) v2(226.35,89.1) v2(226.28,39.1) v2(226.28,37.82) v2(226.41,44.19) v2(226.61,23.69) v2(227.2,85.4) v2(227.15,82.7) v2(227.18,41.32) v2(227.17,39.4) v2(227.26,21.43) v2(227.55,146.47) v2(227.64,84.91) v2(227.55,82.15) v2(227.55,81.33) v2(227.7,83.45) v2(227.88,33.39) v2(228.05,117) v2(228.32,87.4) v2(228.47,23.69) v2(228.55,79.12) v2(228.64,33.43) v2(228.93,109.6) v2(229,41.21) v2(229,40.04) v2(229,38.72) v2(229.01,37.5) v2(228.98,21.38) v2(229.25,112.75) v2(229.15,111.55) v2(229.15,83.45) v2(229.28,146.47) v2(229.29,114.19) v2(229.63,110.93) v2(229.73,133.98) v2(229.72,113.6) v2(229.7,112.31) v2(229.75,111.55) v2(229.75,105.15) v2(229.75,88.35) v2(229.82,87.76) v2(229.85,118.98) v2(230.07,35.97) v2(230.35,104.69) v2(230.43,20.43) v2(230.52,88.33) v2(230.48,79.25) v2(230.89,41.48) v2(230.94,40.21) v2(230.94,39.02) v2(231.01,146.47) v2(230.95,37.74) v2(231.16,105.14) v2(231.23,88.36) v2(231.15,86.25) v2(231.26,113.65) v2(231.3,82.7) v2(231.34,80.92) v2(231.75,114.2) v2(231.78,118.01) v2(231.77,81.31) v2(231.8,20.43) v2(231.92,105.16) v2(232.07,33.3) v2(232.39,39.12) v2(232.4,37.22) v2(232.58,104.53) v2(232.59,87.73) v2(232.63,82.08) v2(232.73,146.47) v2(232.81,33.42) v2(232.99,21.5) v2(233.24,88.2) v2(233.28,81.43) v2(233.47,44.16) v2(233.95,87.65) v2(233.95,82.05) v2(234.03,115.79) v2(234.04,114.34) v2(234.05,100.35) v2(234.02,84.14) v2(234,23.24) v2(234.23,36.63) v2(234.25,39.14) v2(234.25,37.85) v2(234.42,98.48) v2(234.46,146.47) v2(234.5,102.6) v2(234.62,116.13) v2(234.65,82.15) v2(234.58,33.4) v2(234.7,115.05) v2(235.19,38.38) v2(235.35,82.15) v2(235.31,37.21) v2(235.38,115.68) v2(235.38,33.39) v2(235.5,115.1) v2(235.54,44.17) v2(236,23.24) v2(236.11,115.01) v2(236.19,146.47) v2(236.2,113.95) v2(236.27,39.22) v2(236.27,37.99) v2(236.78,102.09) v2(237.01,21.5) v2(237.1,85.35) v2(237.19,56.69) v2(237.19,54.75) v2(237.45,99.2) v2(237.58,102.09) v2(237.77,81.46) v2(237.78,55.72) v2(237.91,146.47) v2(237.87,101.3) v2(238.1,83.17) v2(238.15,97.2) v2(238.19,44.33) v2(238.24,40.8) v2(238.24,38.95) v2(238.22,37.64) v2(238.17,36.33) v2(238.28,20.43) v2(238.38,56.69) v2(238.38,54.75) v2(238.7,102.22) v2(238.87,33.4) v2(239.2,99.25) v2(239.33,41.4) v2(239.33,39.47) v2(239.64,146.47) v2(239.7,101.31) v2(239.88,20.43) v2(240.2,36.71) v2(240.68,35.97) v2(240.88,101.31) v2(241.37,146.47) v2(241.37,40.74) v2(241.36,39.48) v2(241.36,38.28) v2(241.61,20.43) v2(241.86,101.75) v2(241.95,44.81) v2(242.23,54.51) v2(242.23,53.88) v2(242.23,36.1) v2(243.1,146.47) v2(243.12,35.91) v2(243.33,20.43) v2(243.74,40.04) v2(243.73,38.61) v2(244.82,146.47) v2(245.06,20.43) v2(246.1,90.58) v2(246.55,146.47) v2(246.79,20.43) v2(247.13,23.49) v2(247.75,145.22) v2(248.45,43.53) v2(248.45,42.94) v2(248.45,42.36) v2(248.45,41.77) v2(248.45,41.19) v2(248.51,37.96) v2(248.51,37.38) v2(248.51,36.79) v2(248.52,20.43) v2(248.71,61.24) v2(248.71,51.59) v2(248.71,50.96) v2(248.71,50.32) v2(248.71,49.69) v2(249.02,48.03) v2(249.34,61.24) v2(249.34,51.59) v2(249.34,50.96) v2(249.34,50.37) v2(249.34,49.79) v2(249.47,145.22) v2(249.66,48.03) v2(249.98,61.24) v2(249.98,51.59) v2(249.98,50.96) v2(249.98,50.37) v2(249.98,49.79) v2(250.24,123.79) v2(250.24,20.42) v2(250.61,61.24) v2(250.61,50.96) v2(250.61,50.37) v2(250.61,49.79) v2(250.67,48.03) v2(250.92,40.45) v2(251.2,145.22) v2(251.16,130) v2(251.25,61.24) v2(251.25,50.96) v2(251.25,50.37) v2(251.25,49.79) v2(251.31,48.03) v2(251.88,61.24) v2(251.88,50.96) v2(251.88,50.37) v2(251.88,49.79) v2(251.88,19.87) v2(252.39,51.59) v2(252.46,132.26) v2(252.46,127.75) v2(252.52,61.24) v2(252.52,50.96) v2(252.52,50.37) v2(252.52,49.79) v2(252.93,145.22) v2(253.02,51.59) v2(253.15,50.96) v2(253.15,50.37) v2(253.15,49.79) v2(253.28,40.48) v2(253.4,123.73) v2(253.48,19.23) v2(253.66,51.59) v2(253.79,50.96) v2(253.79,50.37) v2(253.79,49.79) v2(253.86,40.48) v2(254.29,51.59) v2(254.42,50.96) v2(254.61,144.82) v2(254.61,143.09) v2(254.86,141.39) v2(254.93,51.59) v2(255.06,132.26) v2(255.06,127.75) v2(255.06,50.96) v2(255.21,19.23) v2(255.56,51.59) v2(255.69,50.96) v2(255.94,61.24) v2(256.2,51.59) v2(256.33,50.96) v2(256.36,130) v2(256.48,140.77) v2(256.71,39.53) v2(256.71,38.94) v2(256.79,18.52) v2(256.98,16.81) v2(257.29,39.53) v2(257.29,38.94) v2(257.87,39.53) v2(257.87,38.94) v2(257.88,15.33) v2(258.2,140.77) v2(258.23,51.08) v2(258.36,42.38) v2(258.99,42.38) v2(259.64,91.49) v2(259.55,14.89) v2(260.21,140.76) v2(260.29,137.3) v2(260.9,37.43) v2(261,13.94) v2(261.3,139.04) v2(261.3,135.56) v2(261.53,140.77) v2(261.48,37.43) v2(261.82,12.42) v2(261.82,10.7) v2(261.82,8.97) v2(261.82,7.24) v2(261.82,5.52) v2(261.82,3.79) v2(262.07,37.43) v2(263.3,139.04) v2(263.3,135.56) v2(263.49,140.77) v2(263.51,3.43) v2(264.31,137.3) v2(264.71,131.03) v2(264.71,130.39) v2(264.71,129.76) v2(264.71,129.12) v2(265.24,3.43) v2(265.39,140.74) v2(265.6,106.02) v2(265.78,101.12) v2(265.83,98.89) v2(266.73,140.18) v2(266.74,86.52) v2(266.74,85.88) v2(266.74,85.25) v2(266.74,84.61) v2(266.74,84.01) v2(266.74,83.42) v2(266.75,82.81) v2(266.96,3.43) v2(267.96,138.97) v2(268.69,3.43) v2(268.85,72.51) v2(268.85,137.48) v2(268.91,135.76) v2(268.91,134.03) v2(268.91,132.3) v2(268.91,130.58) v2(268.91,128.85) v2(268.91,127.12) v2(268.91,125.4) v2(268.91,123.67) v2(268.91,121.94) v2(268.91,120.21) v2(268.91,118.49) v2(268.91,116.76) v2(268.91,115.03) v2(268.91,113.3) v2(268.91,111.58) v2(268.91,109.85) v2(268.91,108.12) v2(268.91,106.4) v2(268.91,104.67) v2(268.91,102.94) v2(268.91,101.21) v2(268.91,99.49) v2(268.91,97.76) v2(268.91,96.03) v2(268.91,94.31) v2(268.91,92.58) v2(268.91,90.85) v2(269.06,89.13) v2(269.53,82.13) v2(269.72,81.56) v2(269.96,87.66) v2(270.15,74.76) v2(270.15,70.26) v2(270.18,76.63) v2(270.31,81.5) v2(270.36,6.06) v2(270.42,3.43) v2(270.49,79.15) v2(270.77,76.63) v2(270.99,6.06) v2(271.35,76.63) v2(271.47,86.81) v2(271.63,6.21) v2(271.93,76.62) v2(272.14,3.43) v2(272.24,6.23) v2(272.52,76.62) v2(272.75,74.76) v2(272.75,70.26) v2(272.86,6.23) v2(273.19,86.7) v2(273.87,3.43) v2(274.04,58.57) v2(274.04,57.94) v2(274.04,56.85) v2(274.05,72.51) v2(274.41,57.43) v2(274.58,85.68) v2(274.68,83.95) v2(274.72,82.23) v2(274.72,51.85) v2(274.87,29.81) v2(275.18,80.56) v2(275.5,29.81) v2(275.6,3.43) v2(276.1,79.1) v2(277.01,49.3) v2(277.15,48.16) v2(277.15,43.64) v2(277.33,50.96) v2(277.28,46.89) v2(277.33,3.43) v2(277.41,77.98) v2(277.56,52.56) v2(277.61,39) v2(278.23,42.47) v2(278.18,34.66) v2(278.42,46.89) v2(278.49,76.1) v2(278.47,4.73) v2(278.55,48.27) v2(278.93,39) v2(278.99,77.29) v2(279.12,48.66) v2(279.82,37.75) v2(280.04,5.44) v2(280.31,51.02) v2(280.43,46.9) v2(280.52,40.16) v2(280.71,77.09) v2(281.02,45.94) v2(281.34,43.63) v2(281.34,39.02) v2(281.6,45.95) v2(281.68,5.97) v2(282.44,77.09) v2(282.41,51.01) v2(283.33,41.64) v2(283.34,40.8) v2(283.28,38.53) v2(283.41,5.97) v2(283.71,48.9) v2(283.75,48.29) v2(283.76,36.46) v2(284.03,38.5) v2(284.14,76.82) v2(284.62,36.54) v2(284.84,48.49) v2(284.84,38.52) v2(284.76,37.26) v2(285.14,5.97) v2(285.15,75.42) v2(285.6,43.17) v2(285.6,41.58) v2(286.08,73.96) v2(286.07,48.29) v2(286.37,43.18) v2(286.39,42.35) v2(286.36,40.8) v2(286.87,5.97) v2(287.07,72.55) v2(287.12,40.8) v2(287.21,50.99) v2(287.17,43.18) v2(287.17,42.35) v2(287.16,41.58) v2(287.24,36.45) v2(287.9,38.52) v2(288.15,71.15) v2(288.26,37.24) v2(288.65,38.51) v2(288.59,5.97) v2(289.24,69.86) v2(289.15,14.19) v2(289.44,32.35) v2(289.5,45.62) v2(289.54,44.99) v2(289.65,37.48) v2(290.32,5.97) v2(290.41,68.59) v2(290.53,37.57) v2(290.68,45.75) v2(290.68,44.92) v2(290.68,15.71) v2(290.68,14.19) v2(290.68,12.66) v2(291.43,37.57) v2(291.36,35.58) v2(291.64,67.37) v2(291.63,34.19) v2(291.55,33.53) v2(291.74,50.95) v2(292.05,5.94) v2(292.16,37.47) v2(292.2,15.71) v2(292.2,14.19) v2(292.26,45.64) v2(292.27,44.86) v2(292.73,4.35) v2(292.8,35.64) v2(292.92,66.21) v2(293.1,48.69) v2(293.77,47.57) v2(294.24,65.11) v2(294.19,3.43) v2(294.41,46.88) v2(294.73,50.51) v2(295.62,64.07) v2(295.75,46.94) v2(295.77,42.45) v2(295.78,40.08) v2(295.86,49.37) v2(295.92,3.43) v2(297.04,63.09) v2(297.35,51.95) v2(297.37,51.36) v2(297.65,3.43) v2(297.93,51.95) v2(297.96,51.36) v2(298.51,62.17) v2(298.51,51.98) v2(298.54,51.39) v2(299.37,3.43) v2(300.01,61.32) v2(301.1,3.43) v2(301.55,60.53) v2(302.83,3.43) v2(303.12,59.82) v2(304.56,3.43) v2(304.72,59.17) v2(306.28,3.43) v2(306.35,58.6) v2(308.01,58.1) v2(308.01,3.43) v2(309.68,57.68) v2(309.74,3.43) v2(311.37,57.33) v2(311.46,3.43) v2(313.08,57.05) v2(313.19,3.43) v2(314.79,56.85) v2(314.92,3.43) v2(316.51,56.73) v2(316.65,3.43) v2(318.24,56.68) v2(318.37,3.43) v2(319.01,6.34) v2(319.09,39.63) v2(319.09,37.39) v2(319.61,6.34) v2(319.97,56.71) v2(320.1,3.43) v2(320.21,38.51) v2(321.32,39.63) v2(321.32,37.39) v2(321.69,56.81) v2(321.83,3.43) v2(323.41,57) v2(323.56,3.43) v2(325.12,57.25) v2(325.1,32.79) v2(325.28,3.43) v2(326.81,57.59) v2(327.01,3.43) v2(328.49,58) v2(328.67,3.92) v2(328.88,5.63) v2(330.15,58.48) v2(330.57,5.97) v2(330.73,7.51) v2(330.76,9.71) v2(330.76,8.88) v2(330.76,8.12) v2(331.78,59.04) v2(332.03,47.26) v2(332.03,45.91) v2(332.03,44.57) v2(332.03,43.22) v2(332.3,5.97) v2(333.39,59.66) v2(333.38,47.26) v2(333.38,45.91) v2(333.38,44.57) v2(333.38,43.22) v2(334.03,5.97) v2(334.72,47.26) v2(334.72,45.91) v2(334.72,44.57) v2(334.72,43.22) v2(334.97,60.36) v2(335.75,5.97) v2(336.07,47.26) v2(336.07,45.91) v2(336.07,44.57) v2(336.07,43.22) v2(336.52,61.13) v2(337.48,5.97) v2(338.24,60.95) v2(339.21,5.97) v2(339.97,60.93) v2(340.93,5.97) v2(341.29,29.6) v2(341.41,61.88) v2(341.92,29.6) v2(342.06,63.48) v2(342.48,22.03) v2(342.48,20.06) v2(342.48,18.09) v2(342.63,65.11) v2(342.66,5.97) v2(343.12,64.14) v2(343.83,64.75) v2(343.96,66.21) v2(344.38,5.81) v2(344.45,20.06) v2(344.45,18.09) v2(344.56,56.32) v2(344.78,4.13) v2(345.29,58.64) v2(345.54,55.08) v2(345.92,58.64) v2(345.86,55.91) v2(345.99,52.54) v2(346.42,20.06) v2(346.42,18.09) v2(346.36,3.43) v2(348.09,3.43) v2(348.16,32.15) v2(349.82,3.43) v2(350.6,52.58) v2(350.8,73.96) v2(351.24,56.47) v2(351.24,54.52) v2(351.44,30.8) v2(351.55,3.43) v2(351.73,75.42) v2(351.89,50.61) v2(352.46,65.69) v2(352.49,63.89) v2(352.54,52.57) v2(352.55,51.27) v2(352.59,76.91) v2(353.09,30.97) v2(353.27,3.43) v2(353.38,78.45) v2(353.84,57.76) v2(353.84,55.82) v2(353.84,55.17) v2(354.08,79.92) v2(354.49,55.82) v2(354.49,55.17) v2(354.64,64.11) v2(354.64,62.36) v2(354.98,82.15) v2(355,3.32) v2(355.14,55.17) v2(355.31,29.49) v2(355.31,27.73) v2(355.35,83.24) v2(355.49,79.9) v2(355.79,57.77) v2(355.79,57.12) v2(355.87,84.88) v2(356.3,86.55) v2(356.5,81.64) v2(356.5,78.16) v2(356.61,2.71) v2(356.67,88.24) v2(356.96,89.95) v2(357.07,57.77) v2(357.17,91.66) v2(357.31,93.38) v2(357.37,117.56) v2(357.37,115.83) v2(357.37,112.38) v2(357.37,110.65) v2(357.37,108.93) v2(357.37,107.2) v2(357.37,105.47) v2(357.37,103.74) v2(357.37,102.02) v2(357.37,100.29) v2(357.37,98.56) v2(357.37,96.83) v2(357.37,95.11) v2(357.49,121.01) v2(357.93,30.83) v2(357.95,1.63) v2(358.4,122.48) v2(358.5,81.64) v2(358.5,78.16) v2(358.74,117.84) v2(358.74,115.56) v2(358.88,99.98) v2(359.31,123.94) v2(359.35,0.61) v2(359.51,79.9) v2(360.21,37.68) v2(360.24,9) v2(360.27,0.43) v2(360.54,71.78) v2(360.71,124.97) v2(360.7,118.71) v2(360.7,114.69) v2(361.08,0.51) v2(361.25,7.26) v2(361.35,36.41) v2(361.35,35.72) v2(361.66,122.39) v2(362.43,124.97) v2(362.35,68.77) v2(362.58,1.36) v2(362.66,117.84) v2(362.66,115.56) v2(362.93,71.09) v2(362.93,70.51) v2(362.93,69.93) v2(362.94,69.34) v2(363.25,59.16) v2(363.25,7.26) v2(363.58,84.93) v2(363.86,2.52) v2(364.16,124.97) v2(364.26,9) v2(365.35,84.86) v2(365.43,3.24) v2(365.89,124.97) v2(365.86,102.45) v2(366.31,41.49) v2(366.69,38.32) v2(366.69,37.62) v2(367.26,106.07) v2(367.51,41.05) v2(367.61,125.02) v2(367.77,67.72) v2(367.77,67.08) v2(368.35,67.72) v2(368.35,67.08) v2(368.67,60.07) v2(368.85,108.68) v2(368.77,59.48) v2(369,56.32) v2(369,54.59) v2(369,42.25) v2(369,33.81) v2(369,21.72) v2(369.13,125.85) v2(369.06,35.53) v2(369.38,121.16) v2(369.42,37.56) v2(369.64,20.11) v2(369.86,39.72) v2(369.86,38.64) v2(370.45,127.13) v2(370.36,57.13) v2(370.47,41.34) v2(370.78,35.63) v2(370.9,124.54) v2(371.34,142.46) v2(371.28,141.11) v2(371.28,139.38) v2(371.28,137.65) v2(371.28,135.93) v2(371.28,134.2) v2(371.28,132.47) v2(371.28,130.75) v2(371.28,129.02) v2(371.31,20.57) v2(371.39,105.06) v2(371.64,109.44) v2(371.55,78.77) v2(371.93,132.54) v2(371.9,121.62) v2(371.92,117.02) v2(372.02,111.85) v2(372.04,56.73) v2(372.17,142.87) v2(372.24,113.85) v2(372.16,41.67) v2(372.3,115.34) v2(372.51,35.63) v2(372.59,19.01) v2(372.76,122.05) v2(373.03,20.57) v2(373.12,99.38) v2(373.12,97.66) v2(373.12,95.93) v2(373.12,94.2) v2(373.12,92.47) v2(373.12,90.75) v2(373.12,89.02) v2(373.12,87.29) v2(373.12,86.2) v2(373.32,118.16) v2(373.52,131.59) v2(373.52,101.06) v2(373.74,103.91) v2(373.83,83.99) v2(373.77,56.73) v2(373.9,142.87) v2(373.89,41.67) v2(373.99,139) v2(374.24,35.52) v2(374.56,37.11) v2(374.75,108.04) v2(374.82,19.14) v2(375,140.74) v2(375,137.26) v2(375.01,114.84) v2(375.01,39.97) v2(375.07,106.01) v2(375.21,100.73) v2(375.31,73.88) v2(375.39,79.47) v2(375.39,61.23) v2(375.5,84.47) v2(375.62,142.87) v2(375.83,38.13) v2(376.21,67.11) v2(376.34,130.11) v2(376.45,81.3) v2(376.45,77.64) v2(376.45,63.06) v2(376.45,59.4) v2(376.72,39.78) v2(376.77,128.43) v2(376.77,116.34) v2(376.77,114.62) v2(376.84,112.89) v2(376.91,134.08) v2(376.94,100.73) v2(377,140.74) v2(377,137.26) v2(377.22,84.47) v2(377.2,56.43) v2(377.32,41.97) v2(377.35,142.87) v2(377.55,38.64) v2(377.68,35.33) v2(378.01,139) v2(377.97,130.68) v2(378.12,37.11) v2(378.18,39.72) v2(378.37,20.87) v2(378.46,132.55) v2(378.47,112.31) v2(378.47,110.58) v2(378.47,108.85) v2(378.47,107.13) v2(378.47,105.4) v2(378.55,81.3) v2(378.55,77.64) v2(378.55,63.06) v2(378.55,59.4) v2(378.93,56.43) v2(379.04,41.97) v2(379.08,142.87) v2(379.25,103.86) v2(379.41,35.33) v2(379.5,134.9) v2(379.77,79.48) v2(379.77,61.12) v2(379.77,57.94) v2(379.87,40.45) v2(379.87,38.72) v2(379.87,37) v2(379.87,20.46) v2(379.87,18.74) v2(380.8,142.87) v2(381.04,134.95) v2(380.97,103.71) v2(380.98,82.34) v2(381.79,76.83) v2(381.99,63.77) v2(382.12,100.73) v2(382.17,141.81) v2(382.17,140.08) v2(382.17,138.35) v2(382.17,136.63) v2(382.16,135.59) v2(382.17,102.46) v2(382.17,83.6) v2(382.85,75.56) v2(382.85,73.83) v2(382.85,72.1) v2(382.85,70.38) v2(382.85,68.65) v2(382.85,66.92) v2(382.85,65.2) v4(65.91,41.86) v4(69.83,39.18) v4(72.19,41.33) v4(114.86,122.79) v4(121.22,122.63) v4(122.01,85.09) v4(122.81,128.23) v4(123.57,83.68) v4(125.6,83.82) v4(148.36,122.55) v4(169.52,135.7) v4(170,139.96) v4(183.31,116.68) v4(246.08,50.76) v4(255.42,62.11) v4(272.92,57.7) v4(338.35,58.21) v4(362.97,101.81) v4(365.15,107.52)
