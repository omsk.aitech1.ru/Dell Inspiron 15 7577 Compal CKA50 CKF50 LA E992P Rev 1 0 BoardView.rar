# Allegro board Dell_Inspiron_15_7577_Compal_CKA50_CKF50_LA_E992P_Rev_1_0_BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
V18: length 4.6
  BOTTOM w0.14: CR8.2 12.05,29.26 v1(11.41,28.62)
  BOTTOM w0.254: 14.33,30.51 14.54,30.3 UR1.1
  BOTTOM w0.305: CR8.2 12.82,30.51 14.33,30.51
VCC_1.8V: length 1.2
  TOP w0.127: PC18V08.1 269.71,79.57 v1(269.86,79.42)
  vias: v2(269.03,81.51) v2(269.03,80.93)
VCC_CHG: length 36.1
  TOP w0.508: v2(61.38,56.86) 61.38,58.45 v1(61.97,59.04) 62.12,59.19 R3.1
  IN4 w0.508: v2(61.38,56.86) 61.19,57.05 57.09,57.05 54.74,54.7 54.74,53.11 51.73,50.1 42.52,50.1 41.66,49.24 41.66,44.88 v2(40.3,43.53)
VCC_CHG_1: length 1.3
  BOTTOM w0.127: v1(37.63,40.67) 38.04,40.26 38.77,40.26
  vias: v2(39.28,40.86)
VCC_CORE_PH1: length 5
  TOP w0.14: v2(151.49,118.72) v1(152.34,118.72)
  TOP w0.254: v2(151.49,118.72) 151.29,118.52 PR5108.1 150.23,119.04 PR5107.2
  BOTTOM w0.254: PL5101.2 151.37,118.83 v2(151.49,118.72)
  vias: v2(150.79,121.63)
VCC_CORE_PH2: length 5.8
  TOP w0.14: PR5121.1 v1(139.92,122.77)
  TOP w0.254: v2(143.42,118.64) 143.42,118.65 142.79,119.28 PR5120.1 142.22,119.33 PR5119.2
  BOTTOM w0.254: PL5102.2 143.13,118.93 v2(143.42,118.64)
  vias: v2(141.58,121.57)
VCC_CORE_PH3: length 5.4
  TOP w0.14: v1(160.61,119.6) PR5132.2
  TOP w0.254: PR5132.2 158.48,119.06 PR5133.1 158.85,118.52 v2(159.11,118.77)
  BOTTOM w0.254: PL5103.2 159.88,119.55 v2(159.11,118.77)
  vias: v2(159.74,121.69)
VCC_GT_PH1: length 7.8
  TOP w0.14: PR5206.1 v1(123.23,120.93)
  TOP w0.508: v2(125.07,119.92) PR5206.1 ; v2(127.93,123.92) 127.17,123.15 PR5208.1 126.66,122.98 126.15,122.47 PR5207.2
  BOTTOM w0.508: v2(127.93,123.92) 127.6,123.59 PL5201.2
VCC_GT_PH2: length 8
  TOP w0.14: PR5218.1 v1(127.64,132.87)
  TOP w0.254: v2(126.98,134.01) PR5220.1 126.9,134.78 125.83,134.78
  BOTTOM w0.254: PL5202.2 127.06,131.44 127.36,131.73 127.36,133.63 v2(126.98,134.01)
  vias: v2(124.82,133.76) v2(125.45,133.76)
VCCGT_SENSE: length 60.7
  TOP w0.127: v2(127.85,138.89) v1(127.85,139.54)
  TOP w0.254: PR5031.2 128.22,138.2 PC5009.1 127.85,138.56 v2(127.85,138.89)
  IN4 w0.254: v2(127.85,138.89) 127.85,138.71 128.17,138.39 129.24,138.39 130.94,140.1 133.8,140.1 135.17,138.72 135.17,131.97 137.2,129.94 137.2,113.22 143.08,107.34 152.64,107.34 153.02,106.97 153.02,106.95 153.26,106.71 v2(153.26,106.64)
  BOTTOM w0.254: v2(153.26,106.64) 153.63,106.28 156.31,106.28 RH204.2
VCCIO_EN: length 221.5
  TOP w0.14: v2(265.65,63.22) 267.3,64.86 v1(273.36,64.86) CZ108.1 RZ108.2 276.31,65.99 275.97,66.33 DZ2.2
  IN4 w0.137: v2(265.65,63.22) 265.64,63.23 247.71,63.23 246.74,62.26 246.74,60.99 245.01,59.26 245.01,53.43 237.68,46.1 205.78,46.1 205.33,45.65 198.85,45.65 198.28,46.23 186.22,46.23 184.92,47.53 173.01,47.53 166.65,53.89 134.48,53.89 123.57,64.79 122.79,65.57 122.79,85.8 130.44,93.45 130.44,95.93 130.09,96.27 130.09,99.87 128.88,101.08 v2(128.88,106.58)
  BOTTOM w0.14: PR4003.1 v2(128.88,106.58)
VCCIO_SENSE: length 57.4
  TOP w0.14: v2(172.06,88.34) 172.38,88.66 RH514.2
  IN4 w0.137: v2(172.06,88.34) 171.85,88.55 167.81,88.55 166.82,89.53 162.75,89.53 161.83,90.45 155.25,90.45 155.09,90.61 150.91,90.61 150.7,90.4 150.3,90.4 150.26,90.45 148.75,90.45 148.07,89.76 145.43,89.76 144.99,89.33 139.09,89.33 136.98,91.43 136.98,94.37 137.9,95.28 137.9,101.49 135.59,103.8 131.8,103.8 v2(131.6,103.6)
  BOTTOM w0.127: v2(131.6,103.6) v1(132.02,104.02)
  BOTTOM w0.254: v2(131.6,103.6) 131.69,103.51 PR4007.2
VCCSA_SENSE: length 65.6
  TOP w0.127: v2(144.82,136.2) 145.21,136.2 v1(145.7,135.72)
  TOP w0.254: v2(144.82,136.2) 144.74,136.27 PC5015.2 143.85,137.05 PR5033.2
  IN4 w0.254: v2(144.82,136.2) 145.2,135.82 145.2,132.93 144.76,132.49 144.76,132.46 141.48,129.19 139.1,129.19 138.72,128.81 138.72,113.88 143.74,108.87 155.71,108.87 157.68,110.84 169.12,110.84 v2(170.5,109.45)
  BOTTOM w0.254: RH202.2 v2(170.5,109.45)
VCCSENSE: length 48.5
  TOP w0.254: v2(137.97,129.95) 137.64,130.28 133.76,130.28 133.47,130.57 133.47,131.08 134.13,131.74 PC5034.1 134.67,132.63 PR5050.1
  IN4 w0.254: v2(154.85,107.09) 154.22,107.72 143.23,107.72 137.58,113.38 137.58,129.56 v2(137.97,129.95)
  BOTTOM w0.254: v2(154.85,107.09) 154.85,108.05 RH198.2
VCCST_EN: length 103.6
  TOP w0.14: v2(189.99,105.11) v1(189.12,105.11) ; v2(193.53,70.34) 192.84,69.64 192.29,69.64 191,68.34 190.18,68.34 189.95,68.11 186.61,68.11 185.9,68.82 184.43,68.82 181.56,65.95 181.56,62.03 182.14,61.45 184.54,61.45 191.76,54.23 215.47,54.23 216.23,54.99 217.86,54.99 218.36,54.49 RZ111.2 RZ112.2
  IN1 w0.097: v2(189.99,105.11) 189.82,104.93 189.82,80.68 191.63,78.86 191.63,76.42 194.06,74 194.06,70.86 v2(193.53,70.34)
  BOTTOM w0.14: UZ15.4 186.9,108.31 189.99,105.22 v2(189.99,105.11)
VCCST_PWRGD_CPU: length 10.1
  TOP w0.14: RH154.2 181.78,81.84 v2(182.09,82.15)
  IN1 w0.097: v2(182.09,82.15) 182.09,82.72 181.53,83.28 180.79,83.28 179.86,84.22 179.86,84.51 179.81,84.55
  IN1 w0.102: v2(176.05,86.05) 176.99,85.11 176.99,85.1 177.23,84.86 179.5,84.86 179.81,84.55
  BOTTOM w0.076: v2(176.05,86.05) 175.7,86.41 UH1.H13
VDD_1.2V: length 6.5
  TOP w0.14: PR201.1 111.86,71.83 v1(111.51,72.19)
  TOP w0.203: v2(113.2,69.24) 112.6,69.24 112.39,69.04 PU200.11
  TOP w0.254: PR201.1 111.23,71.2 v2(111.23,71.21)
  BOTTOM w0.254: v2(111.23,71.21) 111.23,71.19 PR203.2
  BOTTOM w0.508: PR203.2 PC214.1 113.14,69.3 v2(113.2,69.24)
VDD_DAC_33: length 16
  TOP w0.127: v2(313.92,36.54) 313.92,36.74 313.61,37.05 v1(313.39,37.05)
  TOP w0.203: CVGA3.1 320.41,42.11 UVGA1.20
  TOP w0.508: RVGA2.2 v2(313.92,36.54) ; CVGA3.1 320.27,42.27 CVGA2.2 v2(320.27,44.16)
  BOTTOM w0.508: v2(320.27,44.16) 319.77,44.16 318.09,42.48 318.09,41.34 313.92,37.18 v2(313.92,36.54)
VDDP_1.2V: length 6.4
  TOP w0.14: v1(114.54,72.88) 114.9,72.52 114.9,70.92 PC209.2
  TOP w0.203: 112.43,69.75 112.2,69.75 111.99,69.55 PU200.12
  TOP w0.508: PC209.2 114.22,70.27 PR204.2 112.95,70.27 112.43,69.75
VIN: length 84.2
  TOP w0.254: PR720.1 33.76,46.68 32.2,46.68 v2(32.13,46.74) ; PR16.2 v2(52.86,27.89)
  TOP w0.508: PR31.1 54.7,30.8 53.89,31.61 52.43,31.61 v2(51.74,30.92) PR15.1
  IN2 w0.254: v2(49.57,55.65) 47.98,55.65 42.76,50.43 36.79,50.43 33.1,46.74 v2(32.13,46.74)
  IN4 w0.254: v2(52.86,27.89) 52.86,29.81 v2(51.74,30.92) 49.9,32.77 43.83,32.77 42.86,33.74 42.86,36.7 39.87,39.7 39.87,40.96 39.18,41.65 39.18,42.5 39.56,42.88 39.56,48.15 40.64,49.23 40.64,53.2 41.19,53.75 49.19,53.75
  BOTTOM w0.508: PC700.1 47.91,49.48 43.03,44.6 PD700.2
  vias: v2(49.57,57.88) v2(49.57,57.11) v2(49.57,56.35) v2(50.2,57.88) v2(50.2,57.11) v2(50.2,56.35) v2(50.2,55.65) v2(50.84,57.88) v2(50.84,57.11) v2(50.84,56.35) v2(50.84,55.65) v2(51.47,57.88) v2(51.47,57.11) v2(51.47,56.35) v2(51.47,55.65) v2(52.17,57.88) v2(52.17,57.11) v2(52.17,56.35) v2(52.17,55.65) v4(49,57.8) v4(49.04,55.98) v4(52.86,57.69)
VIN1N: length 7.4
  BOTTOM w0.127: RG59.2 231.4,76.7 v1(231.4,77.27)
  BOTTOM w0.254: UG11.11 226.18,77.01 226.68,77.51 228.63,77.51 CG62.2 RG59.2
VIN1P: length 7.5
  BOTTOM w0.127: RG62.2 231.43,74.51 v1(231.43,73.99)
  BOTTOM w0.254: UG11.12 226.83,76.75 227.09,77.02 228.41,77.02 228.86,76.57 228.86,75.26 229.22,74.89 CG62.1 230.92,74.89 RG62.2
VIN2N: length 6.2
  BOTTOM w0.127: RG64.2 231.53,73.54 v1(233.17,73.54)
  BOTTOM w0.254: RG64.2 230.65,73.05 230.4,73.3 CG63.2 228.51,74.64 UG11.14
VIN2P: length 5.8
  BOTTOM w0.127: RG66.2 231.05,71.47 v1(231.55,70.97)
  BOTTOM w0.254: RG66.2 230.52,72.1 230.33,71.91 CG63.1 228.96,72.8 228.96,73.29 228.26,73.99 UG11.15
VIN_2.5V: length 1
  TOP w0.14: v2(174.93,27.57) v4(173.98,27.57)
VINMON: length 3.5
  TOP w0.203: PU6000.27 v2(154.98,137.54) 154.08,137.54 PR6006.2
  BOTTOM w0.127: v2(154.98,137.54) v1(155.7,137.54)
  BOTTOM w0.254: v2(154.98,137.54) 154.98,137.43 PR6000.1
VSSGT_SENSE: length 54.6
  TOP w0.203: PU5000.6 v2(133.52,138.93)
  IN4 w0.254: v2(133.52,138.93) 133.87,138.93 134.79,138.01 134.79,131.82 136.82,129.78 136.82,113.06 142.92,106.96 151.93,106.96 v2(152.25,106.64)
  BOTTOM w0.254: v2(152.25,106.64) 152.76,107.15 153.7,107.15 154.2,106.64 155.94,106.64 156.38,107.08 156.38,107.36 RH32.2 ; v2(133.52,138.93) 133.7,138.93 v1(134.04,139.28) 134.18,139.41 PC5014.1
VSSIO_SENSE: length 57.4
  TOP w0.14: RH513.2 172.66,87.75 v2(172.06,87.75)
  IN4 w0.137: v2(132.94,101.76) 133.39,101.76 134.28,102.64 135.65,102.64 137.13,101.17 137.13,95.6 136.21,94.69 136.21,91.11 138.77,88.56 144.94,88.56 145.33,88.17 147.57,88.17 149.07,89.67 149.94,89.67 149.98,89.63 151.95,89.63 152,89.67 161.51,89.67 162.43,88.76 166.5,88.76 167.69,87.57 171.88,87.57 v2(172.06,87.75)
  BOTTOM w0.127: PR4010.2 133.47,103.57 v1(133.76,103.86)
  BOTTOM w0.254: PR4010.2 133.47,102.28 v2(132.94,101.76)
VSSSA_SENSE: length 70.1
  TOP w0.203: v2(141.92,138.92) 141.9,138.93 PU5000.31
  IN4 w0.254: v2(169.65,109.5) 168.7,110.45 157.84,110.45 155.87,108.49 143.55,108.49 138.34,113.69 138.34,129 138.91,129.57 141.33,129.57 144.37,132.62 144.37,132.65 144.69,132.96 144.69,135.54 143.83,136.4 143.83,137.85 142.76,138.92 v2(141.92,138.92)
  BOTTOM w0.127: v1(141.12,140.5) 140.81,140.19 PC5016.1
  BOTTOM w0.254: RH31.2 169.61,109.47 v2(169.65,109.5) ; v2(141.92,138.92) 141.76,139.08 141.14,139.08 PC5016.1
VSSSENSE: length 48.9
  TOP w0.203: v2(137.54,134.67) 137.67,134.81 PU5000.18
  IN4 w0.254: v2(137.54,134.67) 137.54,133.8 138.91,132.43 138.91,130.14 137.96,129.19 137.96,113.54 143.39,108.11 154.6,108.11 v2(155.61,107.09)
  BOTTOM w0.127: v1(138.43,135.98) 138.38,135.93 PC5035.1
  BOTTOM w0.254: v2(137.54,134.67) 137.2,135.02 PC5035.1 ; RH28.2 156.82,108.99 155.61,107.79 v2(155.61,107.09)
+CHGRTC: length 0.8
  TOP w0.127: v2(266.62,18.82) 266.29,19.15 v4(266.29,19.54)
+CRT_5V_OUT: length 5.3
  BOTTOM w0.127: 369.65,120.35 v1(369.2,120.35)
  BOTTOM w1.016: JCRT1.9 373.99,120.61 372.94,119.55 372.94,119.23 372.33,118.62
+DCPRTC: length 2.8
  TOP w0.14: CH70.1 283.68,31.65 284.01,31.65 284.29,31.93 v1(284.29,32.22) 284.29,32.31 v2(284.65,32.67)
  BOTTOM w0.102: UH2.BA26 284.59,32.67 v2(284.65,32.67)
+DEBUG_PWR: length 14
  TOP w0.127: v2(293.78,5.01) 293.78,4.56 293.98,4.36 v1(294.18,4.36)
  TOP w0.508: v2(293.78,5.01) 293.96,5.18 RE130.2
  IN5 w0.508: v2(300.27,7.97) 300.27,7.34 298.6,5.68 294.46,5.68 v2(293.78,5.01)
  BOTTOM w0.14: JESPI1.2 299.26,7.7 299.4,7.84 299.62,7.84 299.76,7.7 JESPI1.1 299.76,6.82 299.89,6.7 300.24,6.7 300.33,6.79 300.33,7.9 v2(300.27,7.97)
+EDPVDD:
  vias: v2(93.66,51.68) v2(93.66,51.04) v2(94.3,51.68) v2(94.3,51.04) v4(95.26,53.04) v4(95.28,50.4) v4(96.58,51.62)
+EDPVDD_OUT:
  vias: v1(86.6,53.2)
+FBA_VREFC: length 10.5
  BOTTOM w0.381: 217.65,135.47 218.16,135.98 UG1.J14 ; UG2.J14 211.05,135.98 211.74,135.28 213.06,135.28 RG112.1 213.01,135.36 RG110.2
  BOTTOM w0.406: RG110.2 213.06,136.11 RG111.2 214.26,135.66 CG78.1 CG79.1 215.65,135.18 v1(216.68,135.18) 217.36,135.18 217.65,135.47
+FBB_VREFC: length 29.1
  BOTTOM w0.381: UG3.J14 258.38,120.02 258.38,120.65 ; 246.46,135.66 245.65,135.66 UG4.J14
  BOTTOM w0.406: 258.38,120.65 CG113.1 ; CG113.1 CG114.1 RG123.1 258.38,124.98 257.02,126.33 257.02,127.22 258.07,128.27 258.07,131.76 254.17,135.66 v1(252.02,135.66) 246.46,135.66 ; CG113.1 RG121.2 RG122.2
+FBC_VREFC: length 11.5
  BOTTOM w0.14: v1(254.99,90) 255.39,90.4 RG132.2
  BOTTOM w0.254: UG5.J14 256.93,85.64 256.93,86.32
  BOTTOM w0.381: RG133.2 RG132.2 ; RG133.2 256.38,91.86 256.02,92.23 256.02,92.67 256.4,93.05 UG6.J14 ; RG133.2 CG148.1 RG134.1 CG149.1
  BOTTOM w0.406: 256.93,86.32 256.93,86.49 256.38,87.03 CG149.1
+FBX_PLLAVDD: length 73.3
  TOP w0.254: CG54.1 212.76,107.51 213.1,107.85 v2(213.1,108) ; CG58.1 223.06,87.54 v2(223.55,87.05) ; v2(228.4,99) 228.21,99.19 CG60.1 ; CG56.1 228.2,105.3 v2(228.4,105.3) ; v2(218.5,108) 219,107.5 CG59.1
  TOP w0.508: v2(228.34,90.69) 228.1,90.45 CG57.1 ; CG55.1 215.32,80.29 v2(214.8,79.78) 214.57,80.02 LG6.1
  IN2 w0.381: v2(213.1,108) 213.13,108 213.76,107.37 217.87,107.37 v2(218.5,108) 219.13,107.37 227.1,107.37 227.89,106.58 227.89,106.17 228.4,105.66 v2(228.4,105.3) 227.89,104.79 227.89,100.2 228.4,99.7 v2(228.4,99) 227.85,98.45 227.85,91.19 v2(228.34,90.69)
  IN2 w0.457: 223.6,87.36 223.55,87.31 v2(223.55,87.05)
  IN2 w0.508: v2(228.34,90.69) 228.18,90.53 228.18,88.99 227.18,87.99 224.23,87.99 223.6,87.36
  IN5 w0.35: v2(213.1,108) 213.68,107.42 226.45,107.42 228.4,105.47 v2(228.4,105.3)
  BOTTOM w0.127: 215.33,77.12 v1(216.1,77.12)
  BOTTOM w0.254: UG9.L38 228.65,105.55 v2(228.4,105.3) ; v2(218.5,108) 218.5,108.1 UG9.AF42 ; UG9.AN42 213.35,108.25 v2(213.1,108) ; UG9.L29 228.5,99 v2(228.4,99)
  BOTTOM w0.508: 224.27,87.4 224.52,87.65 226.04,87.65 226.3,87.4 227.12,87.4 228.08,88.35 228.08,90.09
+IFPX_PLLVDD: length 7.3
  TOP w0.089: v1(200.93,92.73) 200.79,92.59 200.79,92 201.48,91.31 LG8.2
  TOP w0.508: LG8.2 201.88,91.15 202.12,91.39 CG47.1 202.59,91.28 205.59,91.28 205.95,91.64 v2(205.95,91.85)
  BOTTOM w0.254: UG9.BD18 v2(205.95,91.85)
+INV_PWR_SRC: length 4.3
  TOP w0.127: v4(94.78,42.99) 94.58,42.99 v2(93.73,42.14) ; v2(93.73,42.14) v4(92.4,42.14) ; v2(93.73,42.14) 94.74,41.13 v4(94.83,41.13)
+LAN_IO: length 2.1
  BOTTOM w0.254: v2(23.55,39.39) 23.55,39.26 23.58,39.22 25.25,39.22 RL42.1
  vias: v2(23.66,48.86) v2(23.72,48.22) v2(24.58,42.26) v2(25.15,42.47) v2(29.69,46.17) v2(30.33,46.17) v4(24.3,46.04)
+LAN_VDD: length 1.8
  BOTTOM w0.203: CL32.1 25.73,41.69 UL1.22
  vias: v1(25.86,51.35) v2(22.77,46.64) v2(23.22,42.26) v2(23.53,42.83) v2(23.85,42.26) v2(26.7,51.04) v2(27.33,51.04)
+NVVDD1: length 4
  TOP w0.254: PC6536.1 221.28,88.94 v2(221.45,89.1) ; v2(224.25,89.1) 223.95,88.8 PC6535.1 ; v2(227.05,94) 227.1,93.95 PC6519.1 ; v2(214.35,95.4) v2(214.35,96.1) ; v2(214.35,89.8) v2(214.35,89.1)
  BOTTOM w0.114: v2(208.85,110.15) UG9.AW45
  vias: v2(180.95,134.14) v2(181.27,135.03) v2(181.53,134.14) v2(181.9,135.03) v2(182.12,134.14) v2(182.54,135.03) v2(182.7,134.14) v2(183.17,135.03) v2(183.29,134.14) v2(183.81,135.03) v2(183.87,134.14) v2(184.44,135.03) v2(184.46,134.14) v2(185.04,134.14) v2(185.08,137.57) v2(185.08,136.93) v2(185.08,136.3) v2(185.08,135.66) v2(185.08,135.03) v2(185.18,113.63) v2(185.26,133.57) v2(185.26,132.98) v2(185.26,132.4) v2(185.26,131.82) v2(185.26,131.23) v2(185.26,130.65) v2(185.26,130.06) v2(185.26,129.48) v2(185.26,128.9) v2(185.26,128.31) v2(185.62,134.14) v2(185.71,137.57) v2(185.71,136.93) v2(185.71,136.3) v2(185.71,135.66) v2(185.71,135.03) v2(185.84,133.57) v2(185.84,132.98) v2(185.84,132.4) v2(185.84,131.82) v2(185.84,131.23) v2(185.84,130.65) v2(185.84,130.06) v2(185.84,129.48) v2(185.84,128.9) v2(185.84,128.31) v2(185.76,113.63) v2(186.21,134.14) v2(186.21,119.13) v2(186.21,118.52) v2(186.21,117.94) v2(186.21,117.35) v2(186.21,116.77) v2(186.35,137.57) v2(186.35,136.93) v2(186.35,136.3) v2(186.35,135.66) v2(186.35,135.03) v2(186.35,113.63) v2(186.42,133.57) v2(186.42,132.98) v2(186.42,132.4) v2(186.42,131.82) v2(186.42,131.23) v2(186.42,130.65) v2(186.42,130.06) v2(186.42,129.48) v2(186.42,128.9) v2(186.42,128.31) v2(186.79,134.14) v2(186.79,119.13) v2(186.79,118.52) v2(186.79,117.94) v2(186.79,117.35) v2(186.79,116.77) v2(186.98,137.57) v2(186.98,136.93) v2(186.98,136.3) v2(186.98,135.66) v2(186.98,135.03) v2(187.01,133.57) v2(187.01,132.98) v2(187.01,132.4) v2(187.01,131.82) v2(187.01,131.23) v2(187.01,130.65) v2(187.01,130.06) v2(187.01,129.48) v2(187.01,128.9) v2(187.01,128.31) v2(187.11,114.07) v2(187.38,134.14) v2(187.35,120.49) v2(187.35,119.9) v2(187.35,119.32) v2(187.35,118.74) v2(187.35,118.15) v2(187.35,117.57) v2(187.35,116.98) v2(187.35,116.4) v2(187.35,115.81) v2(187.35,115.23) v2(187.35,114.65) v2(187.62,137.57) v2(187.62,136.93) v2(187.62,136.3) v2(187.62,135.66) v2(187.62,135.03) v2(187.59,133.57) v2(187.59,132.98) v2(187.59,128.9) v2(187.59,128.31) v2(187.94,120.49) v2(187.94,119.9) v2(187.94,119.32) v2(187.94,118.74) v2(187.94,118.15) v2(187.94,117.57) v2(187.94,116.98) v2(187.94,116.4) v2(187.94,115.81) v2(187.94,115.23) v2(187.94,114.65) v2(188.19,133.57) v2(188.22,132.98) v2(188.25,137.44) v2(188.52,120.49) v2(188.52,119.9) v2(188.52,119.32) v2(188.52,118.74) v2(188.52,118.15) v2(188.52,117.57) v2(188.52,116.98) v2(188.52,116.4) v2(188.52,115.81) v2(188.52,115.23) v2(188.77,133.57) v2(188.8,132.98) v2(188.89,137.44) v2(189.1,120.49) v2(189.1,119.9) v2(189.1,119.32) v2(189.1,118.74) v2(189.1,118.15) v2(189.1,117.57) v2(189.1,116.98) v2(189.1,116.4) v2(189.1,115.81) v2(189.1,115.23) v2(189.36,133.57) v2(189.38,132.98) v2(189.52,137.44) v2(189.69,120.49) v2(189.69,119.9) v2(189.69,119.32) v2(189.69,118.74) v2(189.69,118.15) v2(189.69,117.57) v2(189.69,116.98) v2(189.69,116.4) v2(189.69,115.81) v2(189.69,115.23) v2(189.97,132.98) v2(190.16,137.57) v2(190.18,136.93) v2(190.18,136.3) v2(190.18,135.66) v2(190.18,135.03) v2(190.34,120.42) v2(190.34,119.79) v2(190.34,119.21) v2(190.34,118.62) v2(190.34,118.04) v2(190.34,117.45) v2(190.41,134.39) v2(190.46,132.04) v2(190.46,131.46) v2(190.46,130.88) v2(190.46,130.29) v2(190.46,129.71) v2(190.46,129.12) v2(190.46,128.54) v2(190.46,127.96) v2(190.46,127.37) v2(190.46,126.79) v2(190.55,132.98) v2(190.74,137.57) v2(190.77,136.93) v2(190.77,136.3) v2(190.77,135.66) v2(190.77,135.03) v2(190.92,120.42) v2(190.92,119.79) v2(190.92,119.21) v2(190.92,118.62) v2(190.92,118.04) v2(190.92,117.45) v2(191.05,134.39) v2(191.05,132.04) v2(191.05,131.46) v2(191.05,130.88) v2(191.05,130.29) v2(191.05,129.71) v2(191.05,129.12) v2(191.05,128.54) v2(191.05,127.96) v2(191.05,127.37) v2(191.05,126.79) v2(191.14,132.98) v2(191.38,137.57) v2(191.4,136.93) v2(191.4,136.3) v2(191.4,135.66) v2(191.43,135.03) v2(191.5,120.42) v2(191.5,119.79) v2(191.5,119.21) v2(191.5,118.62) v2(191.5,118.04) v2(191.5,117.45) v2(191.63,132.04) v2(191.63,131.46) v2(191.63,130.88) v2(191.63,130.29) v2(191.63,129.71) v2(191.63,129.12) v2(191.63,128.54) v2(191.63,127.96) v2(191.63,127.37) v2(191.63,126.79) v2(191.68,134.39) v2(192.01,136.93) v2(192.04,136.3) v2(192.04,135.66) v2(192.04,135.03) v2(192.06,137.57) v2(192.09,120.42) v2(192.09,119.79) v2(192.09,119.21) v2(192.09,118.62) v2(192.09,118.04) v2(192.09,117.45) v2(192.22,132.04) v2(192.22,131.46) v2(192.22,130.88) v2(192.22,130.29) v2(192.22,129.71) v2(192.22,129.12) v2(192.22,128.54) v2(192.22,127.96) v2(192.22,127.37) v2(192.22,126.79) v2(192.67,120.42) v2(192.67,119.79) v2(192.67,119.21) v2(192.67,118.62) v2(192.67,118.04) v2(192.67,117.45) v2(192.8,132.04) v2(192.8,131.46) v2(192.8,130.88) v2(192.8,130.29) v2(192.8,129.71) v2(192.8,129.12) v2(192.8,128.54) v2(192.8,127.96) v2(192.8,127.37) v2(192.8,126.79) v2(195.5,117.48) v2(195.57,116.02) v2(195.57,114.68) v2(195.57,113.41) v2(195.57,112.14) v2(199.65,112.9) v2(201.05,112.9) v2(201.75,113.6) v2(202.45,112.9) v2(203.15,110.8) v2(203.85,111.5) v2(204.41,111.14) v2(205.25,111.5) v2(205.25,107.35) v2(205.28,110.43) v2(205.3,109.41) v2(205.59,118.33) v2(205.89,110.68) v2(205.88,109.91) v2(205.89,108.99) v2(206.05,112.95) v2(206.59,109.44) v2(207.22,109.44) v2(207.33,108.7) v2(207.33,108.09) v2(207.33,107.37) v2(207.4,105.92) v2(207.4,105.3) v2(208.05,111.55) v2(208.07,108.67) v2(208.75,109.4) v2(209.45,108.7) v2(209.45,107.3) v2(209.53,106.6) v2(210.15,94) v2(210.15,92.6) v2(210.12,91.2) v2(210.12,89.8) v2(210.15,105.2) v2(210.15,99.65) v2(210.15,98.9) v2(210.15,97.5) v2(210.15,96.1) v2(210.15,95.35) v2(210.18,89.1) v2(210.85,107.3) v2(211.55,105.9) v2(211.55,104.5) v2(211.55,103.8) v2(211.55,99.6) v2(211.55,98.9) v2(211.55,97.5) v2(211.55,96.1) v2(211.55,95.4) v2(211.55,94) v2(211.55,92.6) v2(211.55,91.2) v2(211.55,89.8) v2(211.55,89.1) v2(212.95,105.9) v2(212.95,104.5) v2(212.95,103.8) v2(212.95,102.4) v2(212.95,101) v2(212.95,99.65) v2(212.95,98.9) v2(212.95,97.5) v2(212.95,96.1) v2(212.95,95.35) v2(212.95,94) v2(212.95,92.6) v2(212.95,91.2) v2(212.92,89.8) v2(212.95,89.1) v2(214.35,105.9) v2(214.35,104.5) v2(214.35,103.8) v2(214.35,102.4) v2(214.35,101.7) v2(214.35,101) v2(214.35,99.6) v2(214.35,98.9) v2(214.35,97.5) v2(214.35,94) v2(214.35,92.6) v2(214.35,91.2) v2(215.7,102.4) v2(215.71,101.7) v2(215.7,101) v2(215.75,94) v2(215.75,92.6) v2(215.7,89.8) v2(215.74,89.06) v2(215.75,105.9) v2(215.75,104.5) v2(215.75,103.8) v2(215.75,99.55) v2(215.75,98.9) v2(215.75,97.5) v2(215.75,96.1) v2(215.75,95.45) v2(215.75,91.2) v2(216.58,89.8) v2(216.6,89.1) v2(217.15,105.9) v2(217.15,104.5) v2(217.15,103.8) v2(217.15,99.6) v2(217.15,98.9) v2(217.15,97.5) v2(217.15,96.1) v2(217.15,95.4) v2(217.82,105.91) v2(217.8,105.21) v2(217.85,103.8) v2(217.85,98.9) v2(217.95,96.1) v2(217.95,91.2) v2(217.95,90.5) v2(217.95,89.1) v2(218.61,102.39) v2(218.61,100.99) v2(218.65,99.6) v2(218.65,95.4) v2(218.65,91.2) v2(218.65,90.5) v2(218.65,89.1) v2(218.68,105.9) v2(218.68,105.2) v2(218.7,98.9) v2(218.7,97.5) v2(218.7,96.1) v2(220.05,105.9) v2(220.05,99.65) v2(220.05,98.9) v2(220.05,95.35) v2(220.05,91.2) v2(220.05,90.5) v2(220.05,89.1) v2(220.06,101) v2(220.1,94) v2(220.1,92.6) v2(221.45,105.9) v2(221.45,101) v2(221.45,99.6) v2(221.5,98.9) v2(221.5,95.4) v2(221.45,94) v2(221.45,92.6) v2(221.45,91.2) v2(221.45,90.5) v2(222.85,105.9) v2(222.88,105.2) v2(222.85,103.8) v2(222.86,102.4) v2(222.86,101) v2(222.85,99.65) v2(222.85,98.9) v2(222.85,97.5) v2(222.85,96.1) v2(222.85,95.35) v2(222.85,94) v2(222.85,92.6) v2(222.85,91.2) v2(222.85,90.5) v2(222.85,89.1) v2(224.25,105.9) v2(224.25,98.9) v2(224.25,97.5) v2(224.25,96.1) v2(224.25,95.4) v2(224.25,91.2) v2(224.25,89.8) v2(224.26,105.2) v2(224.26,103.8) v2(224.26,102.4) v2(224.26,101) v2(224.26,99.6) v2(225.65,105.9) v2(225.65,99.65) v2(225.65,98.9) v2(225.65,95.35) v2(225.65,91.2) v2(225.65,89.8) v2(225.65,89.1) v2(225.68,105.2) v2(225.68,103.8) v2(225.66,102.4) v2(225.66,101) v2(225.7,97.5) v2(225.7,96.1) v4(189.55,127.36)
+PEX_PLL_HVDD: length 3.3
  TOP w0.457: LG9.1 208.84,99.23 CG34.1 208.8,100.2 v1(207.96,100.2) v2(207.4,100.2)
  BOTTOM w0.254: UG9.BB30 207.15,99.95 v2(207.4,100.2)
+PEX_VDD: length 93
  TOP w0.381: v2(197.56,59.29) 197.13,59.72 RG544.1
  TOP w2.032: 189.35,80.28 188.6,79.53 186.6,79.53 181.46,74.39 181.46,71.53
  IN4 w0.508: v2(197.56,59.29) 197.42,59.29 195.17,61.54 195.17,65.15 196.52,66.5 196.52,69.48 196,70 196,70.68 195.27,71.41 195.27,73.72 194.42,74.57 194.42,81.39 v2(194.07,81.74)
  IN4 w2.032: 130.98,77.82 133.8,75 133.8,72.56 137.78,68.57 178.88,68.57
  vias: v2(129.74,79.21) v2(129.74,78.63) v2(130.33,79.21) v2(130.91,79.21) v2(180.57,69.76) v2(180.57,69.18) v2(180.57,68.6) v2(180.57,68.01) v2(203.94,90.45) v2(205.95,104.45) v2(205.95,102.35) v2(206.65,104.45) v2(206.65,103.15) v2(206.65,102.35) v2(206.65,94.75) v2(206.65,93.95) v2(206.65,92.65) v2(206.65,91.85) v2(206.65,90.55) v2(206.65,89.75) v2(207.37,103.85) v2(207.4,103.2) v2(207.4,94.8) v2(207.46,102.3) v2(207.5,93.67) v4(197.75,88.47)
+RTC_CELL_VBAT: length 5.9
  TOP w0.203: v2(303.32,24.67) 303.32,24.09 303.2,23.98 UE1.122
  BOTTOM w0.14: v1(304.66,24.45) 304.66,25.03 305.09,25.46 CE73.1
  BOTTOM w0.508: CE73.1 305.08,25.94 RE16.2 304.14,25.49 v2(303.32,24.67)
+RTCBATT: length 3.4
  BOTTOM w0.127: v1(260.5,17.47) 261.16,17.47 RC11.2
  BOTTOM w0.508: JRTC.1 261.5,18.75 261.74,18.52 RC11.2
+RTCVCC: length 129.1
  TOP w0.127: v2(272.71,23.74) v4(272.71,24.31)
  TOP w0.457: v2(286.39,32.65) 286.32,32.72 CH80.1 CH173.1
  TOP w0.508: RH84.1 RH143.2 RH83.1 296.37,26.5 v2(296.63,26.24) ; v2(343.64,7.98) 344.05,8.39 RA18.2
  IN3 w0.508: v2(302.43,24.29) 302.43,25.11 305.09,27.78 305.09,27.97 305.47,28.35 306.49,28.35 308.87,25.97 308.87,24.26 309.72,23.41 312.52,23.41 314.63,21.3 320.22,21.3 320.61,21.69 326.73,21.69 329.34,19.09 330.73,19.09 332.27,17.55 332.27,15.15 339.45,7.98 v2(343.64,7.98) ; v2(272.71,23.74) 281.19,23.74 281.95,22.98 283.16,22.98 283.49,23.31 283.49,23.73 284.08,24.31 286.3,24.31 286.93,23.68 287.44,23.68 287.8,24.03 287.8,24.54 287.79,24.54 287.79,24.89 289.56,26.66 296.22,26.66 v2(296.63,26.24)
  IN5 w0.508: v2(302.43,24.29) 301.77,23.63 300.02,23.63 299.62,24.03 299.62,25.52 299.26,25.88 298.75,25.88 298.1,25.23 297.37,25.23 296.63,25.96 v2(296.63,26.24) 295.03,27.84 292.04,27.84 292.01,27.88 291.67,27.88 291.02,28.53 291.02,29.59 289.83,30.78 288.85,30.78 287.52,32.11 286.93,32.11 v2(286.39,32.65) ; v2(272.71,23.74) 272.71,21.62 v2(266.09,15)
  BOTTOM w0.254: UH2.BA22 286.39,32.55 v2(286.39,32.65)
  BOTTOM w0.508: v2(266.09,15) CC27.1 266.09,16.36 DC2.1 ; RE31.1 RE52.2 v2(302.43,24.29) 302.6,24.46 302.6,24.79 302.74,24.93 RE16.1
+TBTA_VBUS:
  vias: v2(363.32,67.27) v2(364.68,72.51) v2(364.68,71.92) v2(364.68,71.34) v2(365.27,72.51) v2(365.27,71.92) v2(365.27,71.34) v2(369.93,72.74) v2(369.93,69.43) v2(369.95,68.81) v2(373.29,73.05) v2(373.55,69.24) v2(373.85,72.8) v2(374.18,72.29) v2(374.18,69.24) v2(376.67,71.83) v2(376.67,68.89) v4(364.97,70.55)
+V_DAC: length 5
  BOTTOM w0.508: TL2.7 v2(25,66.07) ; TL2.1 v2(30.94,66) ; TL2.4 v2(27.97,66.07) ; TL2.10 v2(22.03,66)
  vias: v4(29,66.2)
+V_DDR_REFA: length 60.5
  TOP w0.127: RH45.2 v4(112.55,59.64)
  TOP w0.508: CD96.1 145.45,33.68 v2(145.79,33.34) ; v2(114.91,57.75) 114.52,58.14 RH206.2 114.06,58.51 113.84,58.29 RH209.1 RH45.2
  IN3 w0.508: v2(145.79,33.34) 145.79,34.91 147.23,36.35 147.23,41.12 145.52,42.84 120.57,42.84 114.47,48.94 114.47,55.91 115.14,56.58 115.14,57.52 v2(114.91,57.75)
  BOTTOM w0.305: JDIMM1.164 145.58,33.56 v2(145.79,33.34)
+V_DDR_REFA_R: length 55
  TOP w0.127: v2(110.6,57.37) 110.01,56.78 v4(109.73,56.78)
  TOP w0.508: RH45.1 CH101.1 v2(110.6,57.37)
  IN1 w0.508: v2(141.94,86.61) 140.32,84.99 138.6,84.99 137.77,85.82 135.46,85.82 133.2,83.56 128.61,83.56 124.47,79.42 124.47,67.22 120.22,62.97 117.5,62.97 116.88,62.36 114.4,62.36 113.89,61.85 113.89,60.67 v2(110.6,57.37)
+V_DDR_REFB: length 5.9
  TOP w0.127: v2(222.11,33.4) v1(222.11,32.54)
  TOP w0.508: RH210.1 CD29.1 223.09,34.21 RH207.2 ; RH210.1 222.05,33.46 v2(222.11,33.4) ; RH210.1 221.16,34.19 RH46.2
  BOTTOM w0.305: JDIMM2.164 222.07,33.44 v2(222.11,33.4)
+V_DDR_REFB_R: length 205
  TOP w0.127: RH46.1 v1(221.13,36.11)
  TOP w0.508: RH46.1 CH100.1 220.12,36.3 v2(219.88,36.54)
  IN1 w0.508: v2(140.01,86.61) 139.53,87.09 135.87,87.09 132.95,84.17 128.36,84.17 123.86,79.67 123.86,67.48 120.04,63.66 114.64,63.66 113.29,62.3 113.29,60.92 109.99,57.63 109.99,57.12 109.99,56.18 99.99,46.19 99.99,38.38 103.04,35.33 125.58,35.33 125.64,35.27 126.15,35.27 126.21,35.33 168.09,35.33 169.14,36.38 169.14,39.46 169.84,40.16 172.98,40.16 178.08,35.05 218.39,35.05 v2(219.88,36.54)
+VDISPLAY_VCC: length 0.8
  TOP w0.127: v2(368.03,87.54) 368.42,87.16 v4(368.42,86.92)
A_DE0: length 3.2
  BOTTOM w0.14: RI19.1 RI54.2 13.04,50.51 v1(12.57,50.04) 12.15,49.62 UI3.3
A_DE1: length 6.6
  BOTTOM w0.127: v1(15.19,44.62) 14.68,45.13 RI20.1
  BOTTOM w0.14: UI3.6 11.96,48.12 12.1,47.97 12.1,45.51 RI57.2 RI20.1
A_EQ0: length 4.5
  BOTTOM w0.14: v1(12.49,52.43) 12.62,52.29 RI15.1 RI55.2 13.17,51.09 12.84,51.09 11.86,50.12 UI3.2
A_OS0: length 3
  BOTTOM w0.14: UI3.4 12.19,49.12 v1(12.57,48.73) RI46.2 RI16.1
AC_DIS: length 319.4
  TOP w0.14: v2(316.21,10.76) 316.03,10.59 UE1.69 ; v1(47.91,25.4) 48.06,25.25 v2(48.49,25.25)
  TOP w0.254: v2(32.58,47.99) PQ708.2 32.37,50.13 PR734.1
  IN1 w0.097: v2(316.21,10.76) 316.07,10.76 312.47,7.17 295.32,7.17 294.49,7.99 286.66,7.99 286.05,8.6 278.74,8.6 276.94,10.4 271.97,10.4 268.52,13.86 264.49,13.86 255.81,22.54 239.7,22.54 236.73,25.5 136.89,25.5 135.87,24.48 134.79,24.48 132.05,27.21 122.58,27.21 121.97,26.6 106.71,26.6 105.48,27.83 104.62,27.83 103.93,27.14 91.43,27.14 89.21,24.92 80.62,24.92 79.36,26.18 61.99,26.18 61.63,25.82 49.06,25.82 v2(48.49,25.25)
  IN4 w0.137: v2(48.49,25.25) 48.49,28.1 47.92,28.67 45.68,28.67 43.46,30.89 40.12,30.89 38.47,32.54 38.47,36.19 38.13,36.52 37.78,36.52 36.42,37.87 36.42,39.65 35.09,40.99 35.09,43.41 33.8,44.71 33.8,46.77 v2(32.58,47.99)
AC_PRESENT: length 10.3
  TOP w0.14: v2(289.86,25.48) v1(290.28,25.06) 290.64,24.7 RH125.1 291.07,23.55 DV1.2
  IN2 w0.097: v2(289.86,25.48) 289.86,25.56 289.85,25.57 289.85,28.78 v2(289.5,29.14)
  BOTTOM w0.076: v2(289.5,29.14) 289.5,29.23 289.31,29.42 289.31,29.89 289.8,30.37
  BOTTOM w0.102: UH2.BB15 290.02,31.77 289.8,31.54 289.8,30.37
ACAV_IN: length 301.8
  TOP w0.14: v2(33.41,41.79) 33.41,41.71 34.14,40.99 PU700.5 ; v2(295.45,23.4) 295.45,23.35 v1(294.9,22.79) 294.49,22.39 292.9,22.39 292.7,22.58 DV1.1 ; PR20.1 48.53,27.57 48.06,27.57 v2(47.79,27.84)
  IN3 w0.124: v2(295.45,23.4) 295.45,23.38 294.98,22.91 292.03,22.91 290.16,21.03 288.91,21.03 287.88,20 286.28,20 285.73,20.55 283.63,20.55 283.14,21.04 280.99,21.04 280.51,20.55 277.71,20.55 277.02,21.24 271.41,21.24 270.71,20.54 268.13,20.54 267.17,21.5 265.98,21.5 265.56,21.08 264.28,21.08 263.95,20.75 261.21,20.75 255.68,26.29 251.74,26.29 249.83,28.2 224.24,28.2 223.06,27.02 209.95,27.02 209.46,27.5 190.6,27.5 189.86,28.24 163.5,28.24 162.76,27.5 136.76,27.5 136.24,28.02 126.98,28.02 126.15,28.84 115.29,28.84 114.2,27.75 104.77,27.75 104.11,27.1 86.07,27.1 85.62,26.65 67.78,26.65 64.13,30.29 60.5,30.29 59.89,29.68 59.89,27.53 58.77,26.42 49.22,26.42 v2(47.79,27.84)
  IN4 w0.137: v2(47.79,27.84) 45.77,27.84 43.25,30.37 39.89,30.37 37.95,32.31 37.95,35.22 37.56,35.61 33.93,35.61 32.23,37.3 32.23,40.73 33.29,41.79 v2(33.41,41.79)
  BOTTOM w0.14: v2(33.41,41.79) 33.4,41.8 PR719.1 34.27,42.96 PR718.2 ; RE138.1 300.04,21.95 CE84.2 296.9,21.95 v2(295.45,23.4)
ACDET_CHG: length 11.2
  TOP w0.14: PC724.1 34.02,43.46 32.64,42.08 v1(32.64,42.04) 32.64,41.58 32.83,41.39 33.29,41.39 33.74,40.94 PU700.6
  TOP w0.254: PQ708.1 31.62,47.71 31.62,46.57 31.98,46.21 33.82,46.21 PR720.2 34.01,45.77 33.82,45.58 33.82,44.62 PR725.1 PC724.1
ACDRV_CHG:
  vias: v1(33.96,42.01)
ADPIN: length 2.9
  TOP w0.14: v4(46.74,62.79) v2(48.06,62.79) v4(48.06,61.24)
  vias: v2(37.19,51.45) v2(37.67,52.64) v2(37.71,52.06) v2(37.77,51.44) v2(38.33,53.27) v2(38.3,52.64) v2(38.34,52.06) v2(38.41,51.44) v2(38.94,52.64) v2(38.96,53.32) v2(38.98,52.06) v2(39.04,51.44) v2(50.52,62.58) v2(50.52,61.81) v2(51.16,62.58) v2(51.16,61.81) v2(51.79,62.58) v2(51.79,61.81) v2(52.43,62.58) v2(52.43,61.81) v2(53.13,62.58) v2(53.13,61.81) v2(53.76,62.58) v2(53.76,61.81) v4(54.45,61.97)
ALERT#: length 7.8
  TOP w0.14: v1(206.96,77.37) RG504.1 v2(206.07,77.92)
  IN1 w0.097: v2(206.07,77.92) 206.07,78.79 204.64,80.23 203.65,80.23 203.12,80.75 v2(201.85,80.75)
  BOTTOM w0.114: UG9.BJ3 v2(201.85,80.75)
ALL_SYS_PWRGD: length 294.4
  TOP w0.14: v2(308.39,30.19) 308.74,30.19 309.92,31.37 RH105.2 310.05,31.52 310.3,31.27 UH14.2 ; PQ305.2 81.77,52.11 v2(82.82,52.11) 83.17,52.47 v1(83.17,53.36)
  IN2 w0.097: v2(308.39,30.19) 307.89,29.68 307.89,27.38 306.68,26.18 306.68,15.89 306.95,15.62 306.95,11.9 305.83,10.79 305.83,6.66 v2(306.33,6.16)
  IN3 w0.124: v2(85.54,30.23) 85.54,29.58 86.86,28.26 113.95,28.26 115.11,29.42 135.87,29.42 136.98,28.32 154.94,28.32 155.25,28.01 162.42,28.01 163.18,28.77 190.07,28.77 190.72,28.11 209.57,28.11 210.13,27.55 222.48,27.55 223.66,28.73 245.47,28.73 246.01,29.27 249.09,29.27 249.22,29.4 253.23,29.4 254.21,28.43 256.06,28.43 262.09,22.4 264.24,22.4 264.66,22.82 268.22,22.82 268.78,23.38 271.3,23.38 271.72,22.96 279.49,22.96 280.1,22.36 284.81,22.36 284.87,22.42 285.5,22.42 286.04,21.87 287.88,21.87 288.84,22.82 288.84,23.87 291.01,26.04 295.8,26.04 296.51,25.33 298.44,25.33 299.57,26.46 299.57,28.74 300.05,29.21 307.41,29.21 v2(308.39,30.19)
  IN4 w0.137: v2(82.82,52.11) 84.24,50.69 84.24,47.72 83.73,47.21 83.73,46.13 84.22,45.64 84.22,40.5 83.27,39.55 83.27,32.94 83.62,32.59 83.62,32.14 v2(85.54,30.23)
  BOTTOM w0.14: RE62.2 305.97,6.52 v2(306.33,6.16)
ALWON: length 306.7
  TOP w0.14: UE1.121 303.6,23.93 v2(303.95,24.29) ; v2(99.8,52.42) 99.24,52.42 v1(98.96,52.7) ; PR313.1 83.86,48.2 v2(83.76,48.1)
  IN1 w0.097: v2(99.8,52.42) 99.54,52.16 89.96,52.16 88.56,50.76 88.56,49.37 86.4,47.21 85,47.21 84.11,48.1 v2(83.76,48.1) ; v2(303.95,24.29) 303.95,23.02 303.85,22.93 300.32,22.93 299.99,23.26 299.66,23.26 299.48,23.08 298.87,23.08 298.24,23.71 296.43,23.71 296.23,23.91 295.88,23.91 295.81,23.84 291.31,23.84 291.11,24.04 287.99,24.04 287.79,23.84 286.42,23.84 285.61,24.65 285.26,24.65 285.26,24.65 278.34,24.65 276.66,26.32 276.66,28.99 276.15,29.5 276.15,29.79 273.07,32.88 273.07,40.12 271.54,41.65 271.54,42.85 271.97,43.29 271.97,53.72 v2(270.55,55.15)
  IN4 w0.137: v2(270.55,55.15) 270.55,58.14 265.89,62.79 247.9,62.79 247.18,62.08 247.18,60.81 245.45,59.08 245.45,53.24 237.86,45.66 205.96,45.66 205.52,45.21 198.66,45.21 198.09,45.78 174.13,45.78 171.19,48.72 130.46,48.72 128.44,50.74 101.47,50.74 v2(99.8,52.42)
  BOTTOM w0.14: PR18V00.1 266.66,75.72 266.97,75.41 266.97,70.21 272.82,64.37 273.06,64.37 275.48,64.37 276.96,62.89 276.96,56.54 275.57,55.15 v2(270.55,55.15)
AUD_AGND: length 95.9
  TOP w0.127: v4(352.77,18.44) v2(351.96,18.44) ; v2(347.31,26.53) 348.13,26.53 v4(348.16,26.56)
  TOP w0.14: v2(352.72,22.89) v4(351.85,22.89)
  TOP w0.203: v2(347.17,24.09) 346.62,24.09 346.25,23.72 HDA1.38 ; HDA1.25 v2(347.5,17.33)
  TOP w0.508: v2(350.05,25.62) CA63.1 ; RA11.1 v2(351.74,17.36) ; CA17.2 349.4,14.85 CA18.2 350.58,14.85 v2(350.81,15.08) ; v2(356.59,8.41) 357.35,7.65 RA12.1 ; CA16.1 v2(351.44,19.52) ; v2(347.31,26.53) 346.75,26.53 CA2.2 ; CA24.2 341.02,15.93 v2(341.36,16.27) ; JHP1.5 368.18,5.45 367.64,5.98 367.64,13.12 v2(366.08,14.68) ; JHP1.7 v2(373.25,17.39) ; RA15.1 v2(352.72,22.89) ; CA40.2 v2(354.74,11.04) ; RA13.1 v2(353.02,19.85) ; CA22.1 348.46,24.92 v2(348.27,24.73) ; v2(350.75,25.62) 350.75,25.53 350.88,25.4 350.88,25.3 CA1.2 ; CA61.2 356.19,11.64 v2(355.8,11.26) ; CA60.2 v2(356.58,10.39) ; CA41.2 v2(354.59,11.98) ; v2(351.96,18.44) CA19.1 ; v2(347.38,8.16) RA9.1
  GND1 w0.203: 369.52,4.78 JHP1.5 ; JHP1.5 370.6,4.78 ; JHP1.5 369.52,5.45 ; JHP1.5 371.68,4.78 ; JHP1.5 371.68,5.45 ; JHP1.7 374.33,15.62 ; JHP1.7 372.17,14.95 ; JHP1.7 374.33,14.95 ; JHP1.7 372.17,15.62 ; JHP1.7 373.25,15.62
  GND2 w0.203: 372.17,14.95 JHP1.7 ; JHP1.7 373.25,15.62 ; JHP1.7 374.33,15.62 ; JHP1.7 372.17,15.62 ; JHP1.7 374.33,14.95 ; 370.6,4.78 JHP1.5 ; JHP1.5 371.68,5.45 ; JHP1.5 369.52,4.78 ; JHP1.5 369.52,5.45 ; JHP1.5 371.68,4.78
  VCC w0.203: JHP1.5 371.68,5.45 ; JHP1.5 369.52,5.45 ; JHP1.5 371.68,4.78 ; JHP1.5 369.52,4.78 ; JHP1.5 370.6,4.78 ; JHP1.7 373.25,15.62 ; JHP1.7 372.17,15.62 ; JHP1.7 374.33,15.62 ; JHP1.7 372.17,14.95 ; JHP1.7 374.33,14.95
  GND3 w0.203: 372.17,14.95 JHP1.7 ; JHP1.7 372.17,15.62 ; JHP1.7 373.25,15.62 ; JHP1.7 374.33,15.62 ; JHP1.7 374.33,14.95 ; 370.6,4.78 JHP1.5 ; JHP1.5 371.68,4.78 ; JHP1.5 371.68,5.45 ; JHP1.5 369.52,5.45 ; JHP1.5 369.52,4.78
  GND4 w0.203: 370.6,4.78 JHP1.5 ; JHP1.5 369.52,4.78 ; JHP1.5 369.52,5.45 ; JHP1.5 371.68,5.45 ; JHP1.5 371.68,4.78 ; 372.17,15.62 JHP1.7 ; JHP1.7 373.25,15.62 ; JHP1.7 374.33,14.95 ; JHP1.7 372.17,14.95 ; JHP1.7 374.33,15.62
  BOTTOM w0.508: CA43.2 366.64,14.13 v2(366.08,14.68) ; v2(347.5,17.33) 347.09,16.92 CA23.2 ; RA14.1 345.73,23.33 346.49,24.09 v2(347.17,24.09) ; RA16.1 v2(341.42,12.42) ; CA42.2 v2(364.1,14.73)
AUD_AZA_CPU_SCLK: length 193.9
  IN2 w0.097: v2(192.38,76.93) 192.06,76.61 192.06,71.33 189.24,68.5 189.24,67.21 190.92,65.52 192.85,65.52 193.24,65.91 196.28,65.91 198.06,67.69 211.63,67.69 212.46,68.52 227.14,68.52 228.26,67.4 232.45,67.4 233.36,68.31 261.61,68.31 263.45,66.47 276.08,66.47 279.21,63.35 287.87,63.35 289.51,61.71 289.51,61.67 291.71,59.46 293.71,59.46 297.69,55.48 301.19,55.48 302.69,53.97 305.23,53.97 306.51,52.69 306.51,48.85 305.62,47.96 305.62,46.42 304.67,45.47 304.67,39.87 303.82,39.02 303.82,32.86 v2(302.7,31.74)
  IN4 w0.102: 182.3,97.46 180.76,99.01 179.16,99.01 178.4,98.24 177.04,98.24 v2(176.66,97.86)
  IN4 w0.137: v2(192.38,76.93) 192.38,79.43 189.27,82.54 189.27,90.49 182.3,97.46
  BOTTOM w0.076: v2(176.66,97.86) 176.4,97.6 UH1.G27
  BOTTOM w0.14: RH147.1 302.25,32.55 302.68,32.12 302.68,31.74 v2(302.7,31.74)
AUD_AZA_CPU_SCLK_R: length 7.1
  BOTTOM w0.076: UH2.AM2 296.32,36.78 296.65,36.45 296.96,36.45 297.23,36.72 297.73,36.72 297.96,36.49 297.96,35.68 298.25,35.39
  BOTTOM w0.14: 298.25,35.39 299.37,34.27 299.37,34 299.95,33.42 299.95,33.14 RH147.2
AUD_AZA_CPU_SDI: length 8.3
  TOP w0.102: v2(176.7,98.64) 177.06,98.29 177.06,97.7 177.3,97.46 178.24,97.46 178.47,97.69 178.77,97.69 179.03,97.44 180.32,97.44 180.51,97.63 180.97,97.63
  TOP w0.14: 180.97,97.63 181.51,97.63 182.4,98.52 RH145.1
  BOTTOM w0.102: v2(176.7,98.64) 176.7,98.73 176.4,99.04 UH1.G29
AUD_AZA_CPU_SDI_R: length 195.8
  TOP w0.14: v1(183.95,99.53) RH145.2 184.72,98.52 v2(185.1,98.14)
  IN1 w0.097: v2(297.5,36.36) 297.49,36.37 296.45,36.37 296.29,36.54 292.43,36.54 292.18,36.29 291.94,36.29 290.98,37.24 290.98,37.9 290.57,38.31 290.57,39.26 290.98,39.67 290.98,42.4 289.51,43.87 289.51,44.23 288.84,44.9 288.84,45.99 288.52,46.31 287.66,46.31 287.56,46.21 287.56,45.4 287.47,45.3 287.28,45.3 287.18,45.4 287.18,46.21 287.08,46.31 286.89,46.31 286.79,46.21 286.79,45.4 286.7,45.3 286.5,45.3 286.41,45.4 286.41,46.21 286.31,46.31 286.12,46.31 286.02,46.21 286.02,45.4 285.92,45.3 285.73,45.3 285.63,45.4 285.63,46.21 285.54,46.31 285.03,46.31 284.38,46.96 284.38,50.27 283.84,50.81 283.84,51.84 283.75,51.94 282.83,51.94 282.73,52.03 282.73,52.23 282.83,52.32 283.75,52.32 283.84,52.42 283.84,52.61 283.75,52.71 282.83,52.71 282.73,52.81 282.73,53 282.83,53.1 283.75,53.1 283.84,53.19 283.84,53.42 283.75,53.51 282.83,53.51 282.73,53.61 282.73,53.8 282.83,53.9 283.75,53.9 283.84,54 283.84,54.22 283.75,54.32 282.84,54.32 282.74,54.41 282.74,54.61 282.84,54.7 283.76,54.7 283.86,54.8 283.86,54.97 283.76,55.07 282.98,55.07 282.63,55.43 282.63,56.81 282.63,57.2 281.95,57.87 281.82,57.87 281.1,57.15 280.96,57.15 280.83,57.29 280.83,57.43 281.55,58.15 281.55,58.28 281.41,58.42 281.27,58.42 280.55,57.7 280.42,57.7 280.28,57.84 280.28,57.97 281,58.69 281,58.83 280.86,58.97 280.73,58.97 280.01,58.25 279.87,58.25 279.73,58.38 279.73,58.52 280.45,59.24 280.45,59.37 280.32,59.51 280.18,59.51 279.46,58.79 279.32,58.79 279.19,58.93 279.19,59.06 279.91,59.78 279.91,59.92 276.84,62.99 267.5,62.99 265.02,65.47 229.67,65.47 229.54,65.6 223.71,65.6 222.92,64.81 219.35,64.81 217.47,62.93 214.01,62.93 213.62,62.54 210.99,62.54 210.79,62.34 197.66,62.34 196.92,63.08 195.48,63.08 193.97,64.58 193.97,66.03 192.74,67.26 192.74,67.93 193.13,68.32 193.13,69.41 192.54,70 192.54,74.27 190.32,76.49 190.32,78.42 188.94,79.8 188.94,94.93 188.82,95.05 188.68,95.05 188.42,94.79 188.28,94.79 188.15,94.93 188.15,95.07 188.41,95.33 188.41,95.46 188.27,95.6 188.13,95.6 187.87,95.34 187.74,95.34 187.6,95.48 187.6,95.61 187.86,95.87 187.86,96.01 187.73,96.15 187.59,96.15 187.33,95.89 187.19,95.89 187.05,96.02 187.05,96.16 187.32,96.42 187.32,96.56 187.18,96.69 187.04,96.69 186.78,96.43 186.65,96.43 186.51,96.57 186.51,96.7 186.77,96.97 186.77,97.1 186.63,97.24 186.5,97.24 186.24,96.98 186.1,96.98 185.96,97.11 185.96,97.25 186.22,97.51 186.22,97.65 185.74,98.14 v2(185.1,98.14)
  BOTTOM w0.076: UH2.AN2 296.55,36.29 296.56,36.28 297.42,36.28 v2(297.5,36.36)
AUD_AZA_CPU_SDO: length 193.7
  IN2 w0.097: v2(192.89,76.42) 192.29,75.82 192.29,71.24 189.46,68.41 189.46,67.3 191.02,65.74 192.75,65.74 193.14,66.13 193.33,66.13 196.19,66.13 197.97,67.91 211.54,67.91 212.37,68.74 227.23,68.74 228.36,67.62 232.36,67.62 233.27,68.53 261.71,68.53 263.55,66.69 276.18,66.69 279.3,63.57 288.06,63.57 289.73,61.89 289.73,61.76 291.81,59.69 293.8,59.69 297.79,55.7 301.28,55.7 302.79,54.19 305.33,54.19 307,52.52 307,49.03 305.84,47.87 305.84,46.32 304.89,45.38 304.89,38.39 304.08,37.58 304.08,32.39 303.3,31.62 v2(303.3,31.59)
  IN4 w0.102: v2(176.1,96.29) 176.48,95.91 180.9,95.91
  IN4 w0.137: v2(192.89,76.42) 192.29,76.42 191.82,76.89 191.82,79.16 188.57,82.41 188.57,88.74 181.4,95.91 180.9,95.91
  BOTTOM w0.076: UH1.G25 176.1,96.19 v2(176.1,96.29)
  BOTTOM w0.14: RH146.1 302.22,33.45 v1(302.82,32.85) 303.3,32.37 v2(303.3,31.59)
AUD_AZA_CPU_SDO_R: length 5.7
  BOTTOM w0.076: UH2.AM1 297.01,36.88 297.8,36.88 298.16,36.53 298.16,35.99 v1(298.79,35.36) 298.79,35.13 300.47,33.45 RH146.2
AUD_HP1_JACK_L: length 13.3
  TOP w0.127: v2(349.16,12.92) 349.11,12.92 v1(348.64,12.45)
  TOP w0.203: HDA1.32 348.74,20.66 v2(348.86,20.78)
  TOP w0.305: v2(349.16,12.92) 351.74,12.92 RA44.1
  IN1 w0.305: v2(348.86,20.78) 348.7,20.78 348.21,20.28 348.21,18.73 348.93,18.01 348.93,13.15 v2(349.16,12.92)
AUD_HP1_JACK_L1: length 4.2
  TOP w0.305: RA46.2 RA44.2 RA48.2 352.79,14.05 353.51,14.05 v1(353.66,13.9) 353.8,13.76 353.8,13.18 LA20.1
AUD_HP1_JACK_R: length 17.7
  TOP w0.127: v2(352.34,10.25) v1(353.65,10.25)
  TOP w0.203: HDA1.33 348.26,21.06 v2(348.31,21.11)
  TOP w0.305: v2(352.34,10.25) RA49.1
  IN1 w0.305: v2(348.31,21.11) 348.24,21.11 347.65,20.52 347.65,18.5 348.08,18.07 348.08,11.33 349.16,10.25 v2(352.34,10.25)
AUD_HP1_JACK_R1: length 4
  TOP w0.127: RA51.2 v1(350.83,8.04)
  TOP w0.305: RA53.2 RA49.2 350.8,9.32 RA51.2 LA21.1
AUD_PC_BEEP: length 2.1
  TOP w0.127: CA29.2 343.24,13.2 v1(343.85,13.2)
  TOP w0.203: RA19.2 CA29.2
AUD_PC_BEEP_C: length 4.6
  TOP w0.14: D1.1 341.12,8.5 341.43,8.19 v1(341.94,8.19) 342.81,8.19 RA30.1
AUD_PORTA_L_R_B: length 18.5
  TOP w0.305: JHP1.1 369.69,14.95 369.36,15.28 362.83,15.28 362.38,15.73 DA6.2 361.42,16.28 v1(359.28,14.15) 358.03,12.89 CA61.1 CA41.1 LA20.2
AUD_PORTA_R_R_B: length 37.1
  TOP w0.305: LA21.2 354.04,9.3 354.22,9.48 CA40.1 CA60.1 355.65,9.11 354.92,8.37 354.92,7.75 355.18,7.48 DA5.2 355.78,8.53 357.71,10.46 357.71,10.78 360.4,13.47 v1(362,13.47) 364.18,13.47 366.72,10.93 366.72,5.5 367.82,4.4 374.3,4.4 375.35,5.45 JHP1.2
AUD_SENSE: length 9.6
  TOP w0.14: v1(340.83,12.63) 341.26,13.06 v2(341.86,13.06)
  TOP w0.203: v2(341.86,13.06) RA22.2
  BOTTOM w0.203: RA56.2 346.67,8.25 v2(341.86,13.06)
AUD_SENSE_A: length 4.4
  TOP w0.203: HDA1.13 342.25,16.35 341.94,16.03 CA24.1 341.94,14.79 RA22.1 341.01,14.71 v1(340.92,14.62) 340.79,14.49 RA24.2
AUD_SPK_L+: length 27.4
  TOP w0.127: v1(332,16.69) 331.37,17.32 330.8,17.32
  IN1 w1.016: 329.22,18.19 329.22,18.7 328.08,19.85 328.08,23.27 329.76,24.95 330.46,24.95 334.25,28.73 343.78,28.73 345.42,27.1 345.42,27.02
  vias: v2(330.24,17.03) v2(330.82,17.03) v2(345.03,25.42) v2(345.03,24.83)
AUD_SPK_L+_C: length 2.2
  TOP w0.127: v4(330.58,15.83) 330.01,16.4 LA25.2
  IN1 w1.016: 323.72,16.77 324.44,16.77
  vias: v2(322.87,16.97) v2(322.87,16.33) v2(324.93,15.94) v2(325.38,15.53)
AUD_SPK_L-: length 21
  TOP w0.127: 330.89,18.44 331.7,18.44 v1(331.93,18.21)
  IN1 w1.016: 330.47,19.13 330.47,19.26 329.36,20.36 329.36,22.72 330.3,23.66 330.98,23.66 334.63,27.32 343.24,27.32 343.26,27.31
  vias: v2(330.25,18.03) v2(330.84,18.03) v2(344.39,25.39) v2(344.39,24.81)
AUD_SPK_L-_C: length 7.2
  TOP w0.127: 329.74,19.51 330.44,19.51 v4(330.65,19.71)
  IN1 w1.016: 323.74,19.14 324.98,19.14 326.24,17.88 326.24,16.44 326.95,15.73 326.95,14.94
  vias: v2(322.31,19.15) v2(322.9,19.15) v2(327.67,14.57) v2(327.67,13.95)
AUD_SPK_R+: length 10.1
  TOP w0.127: v1(331.94,20.91) 331.64,21.21 330.87,21.21
  IN1 w1.016: 331.93,20.59 332.51,20.59 333.53,21.61 333.53,22.63 334.79,23.88 338.81,23.88 338.82,23.87
  vias: v2(330.57,20.9) v2(331.15,20.92) v2(342.43,24.92) v2(342.86,24.46)
AUD_SPK_R+_C: length 6.1
  TOP w0.127: v2(322.35,20.97) 322.19,21.12 v4(322.19,21.78)
  IN1 w1.016: 321.95,20.26 321.18,19.5 321.18,17.47 321.73,16.92 321.73,15.59
  vias: v2(321.83,14.56) v2(322.26,14.96) v2(322.93,20.97)
AUD_SPK_R-: length 10.5
  IN1 w1.016: 340.59,25.56 337.67,25.56 337.48,25.75 336.17,25.75 335.65,25.23 334.34,25.23 331.94,22.83 331.94,22.23
  vias: v1(330.68,22.69) v2(330.49,22.05) v2(331.08,22.05) v2(343.32,25.11) v2(343.7,24.48)
AUD_SPK_R-_C: length 20.7
  TOP w0.127: v2(322.35,23.76) 321.88,23.76 v4(320.49,22.37)
  IN1 w1.016: 323.79,14.58 325.5,12.87 328.13,12.87 328.72,13.45 328.72,15.78 327.51,16.98 327.51,18.43 324.79,21.15 324.79,22.93 324.02,23.71 323.83,23.71
  vias: v2(322.93,23.76) v2(323.48,15.76) v2(323.95,15.41)
AUX_ON: length 6.3
  TOP w0.14: UE1.3 300.06,20.59 300.25,20.77 300.25,21.51 299.7,22.06 297.73,22.06 RE131.1 297.41,22.79 297.59,22.96 297.59,23.49 v1(297.56,23.52)
B2B_G: length 88.5
  TOP w0.127: v2(57.04,56.1) v1(57.04,56.61)
  TOP w0.254: v2(53.75,48.81) 53.75,48.06 54.22,47.59 PQ703.4 ; v2(35.93,45.11) 35.76,45.11 PR709.1 ; v2(56.05,25.29) 56.08,25.25 PC702.2 55.16,24.48 54.84,24.8 PQ700.1 ; PC701.2 PR704.2 54.57,55.58 54.87,55.87 56.81,55.87 v2(57.04,56.1)
  IN2 w0.508: v2(35.93,45.11) 35.73,45.32 35.73,47.89 36.86,49.02 53.53,49.02 v2(53.75,48.81)
  IN4 w0.508: v2(56.05,25.29) 53.82,27.51 53.82,29.72 50.3,33.25 44.03,33.25 43.35,33.94 43.35,36.9 40.35,39.9 40.35,41.19 40.44,41.28 40.44,42.52 42.27,44.35 42.27,48.99 42.77,49.49 45,49.49 45.68,48.81 v2(53.75,48.81) 53.75,50.94 55.35,52.54 55.35,54.41 v2(57.04,56.1)
  BOTTOM w0.254: v2(53.75,48.81) PR702.2 PC700.2
B+: length 416.9
  TOP w1.016: 255.94,47.78 256.33,47.78 258.42,49.88 260.23,49.88 260.9,50.54 260.9,61.09 267.21,67.4 273.71,67.4 276.85,70.54 ; 248.13,32.54 248.13,30.65 246.91,29.43 244.49,29.43 241.89,26.83 233.92,26.83 232.02,24.92 186.22,24.92 183.17,21.87 165.39,21.87 162.15,25.11 159.44,25.11 158.89,24.56 158.89,23.27 158.47,22.85 151.52,22.85 150.92,23.46 132.31,23.46 128.5,27.27 121.47,27.27 116.88,22.69 99.55,22.69 97.51,24.73 84.74,24.73 80.11,29.35 80.11,33.75
  TOP w2.54: 69.7,53.56 75.54,53.56 80.82,58.84 80.82,60.6 90.93,70.7 93.92,70.7
  IN1 w1.905: 42.41,33.86 43.52,32.74 52.69,32.74 56.19,36.24 60.25,36.24 63.25,33.24 65.88,33.24 68.94,36.3 72.61,36.3 73.32,35.59 82.68,35.59
  IN2 w1.016: 249.15,33.87 250.61,35.33 255.56,35.33 260.07,39.84 260.07,44.61 256.39,48.29 255.18,48.29
  IN2 w2.032: 82.68,36.06 73.18,36.06 72.49,36.74 69.47,36.74 66.26,33.53 62.27,33.53 61.13,32.39 44.87,32.39 43.51,33.75 42.22,33.75
  IN3 w2.032: 83.83,34.19 83.83,31.32 81.22,28.7 71.49,28.7 67.02,33.18 66.84,33.18 66.83,33.19 64.42,33.19 64.41,33.18 60.21,33.18 59.35,32.31 56.05,32.31 55.72,32.64 44.55,32.64 42.89,34.31
  vias: v2(39.9,35.28) v2(39.9,34.7) v2(40.5,35.31) v2(40.5,34.72) v2(41.09,35.31) v2(41.09,34.72) v2(58.42,43.04) v2(58.42,42.46) v2(58.42,41.87) v2(58.42,41.29) v2(59.01,43.04) v2(59.01,42.46) v2(59.01,41.87) v2(59.01,41.29) v2(59.59,43.04) v2(59.59,42.46) v2(59.59,41.87) v2(59.59,41.29) v2(60.17,43.04) v2(60.17,42.46) v2(60.17,41.87) v2(60.17,41.29) v2(60.76,43.04) v2(60.76,42.46) v2(60.76,41.87) v2(60.76,41.29) v2(84.33,36.53) v2(84.33,35.92) v2(84.66,35.39) v2(84.96,36.53) v2(84.96,35.93) v2(85.61,36.52) v2(85.61,35.92) v2(86.18,36.21) v2(86.18,35.52) v2(99.86,68.86) v2(99.86,68.23) v2(99.86,67.59) v2(99.86,66.96) v2(100.5,68.86) v2(100.5,68.23) v2(100.5,67.59) v2(100.5,66.96) v2(101.13,68.86) v2(101.13,66.96) v2(109.36,81.02) v2(109.36,80.38) v2(110,82.29) v2(110,81.65) v2(110,81.02) v2(110,80.38) v2(110.63,82.29) v2(110.63,81.65) v2(110.63,81.02) v2(110.63,80.38) v2(116.42,103.53) v2(116.42,102.9) v2(117.06,103.53) v2(117.06,102.9) v2(117.69,103.53) v2(117.69,102.9) v2(117.9,99.72) v2(118.33,103.53) v2(118.33,102.9) v2(118.71,102.26) v2(118.71,101.63) v2(118.71,100.99) v2(118.71,100.36) v2(118.96,103.53) v2(118.96,102.9) v2(119.34,102.26) v2(119.34,101.63) v2(119.34,100.99) v2(119.6,103.53) v2(119.6,102.9) v2(247.87,33.29) v2(248.5,33.29) v2(254.36,48.67) v2(254.36,48.03) v2(276.48,72.17) v2(276.5,71.5) v2(277.11,72.17) v2(277.14,71.5) v4(59.84,44.52)
B+_VCCIO: length 0.9
  TOP w0.14: v2(123.06,107.29) v1(123.06,108.14)
B_DE0: length 3.1
  BOTTOM w0.14: UI3.16 6.41,49.62 v1(6.33,49.71) 5.72,49.71 RI56.2 RI21.1
B_DE1: length 4.6
  BOTTOM w0.14: UI3.18 7.02,50.62 6.83,50.8 6.83,52.15 6.57,52.42 v1(6.33,52.42) 6.14,52.23 RI22.1 RI58.2
B_EQ0: length 3.6
  BOTTOM w0.14: UI3.17 6.88,50.12 6.47,50.54 6.47,50.87 v1(6.32,51.01) 6.06,51.27 RI17.1 RI47.2
B_OS0: length 4.8
  BOTTOM w0.14: RI18.1 RI48.2 5.69,46.51 5.88,46.7 5.88,47.95 v1(6.33,48.39) 7.05,49.11 7.38,49.11 UI3.15
BAT1_LED#: length 128.8
  TOP w0.203: RE39.1 310.05,24.51 309.6,24.07 UE1.106
  TOP w0.254: v2(223.32,62.29) v1(223.32,61.78) 223.32,61.58 223.56,61.34 223.56,59.79 222.16,58.4 222.16,57.34 221.81,56.99 221.08,56.99 220.8,56.71 QE20.5 ; v2(309.41,27.71) 309.41,26.57 RE39.1
  IN1 w0.254: v2(309.41,27.71) 308.64,26.94 299.93,26.94 298.08,28.79 293.7,28.79 293.41,28.5 292.9,28.5 292.23,29.17 291.59,29.17 290.45,30.32 288.77,30.32 288.77,30.33 288.71,30.33 288.52,30.51 284.59,30.51 284.01,29.94 284.01,29.37 283.5,28.86 283.5,28.67 282.87,28.03 282.04,28.03 281.6,28.48 281.6,30.14 281.17,30.57 280.44,30.57 277.84,33.18 277.25,33.18 275.84,34.59 275.84,37.07 275.21,37.69 275.21,39.75 274.8,40.16 273.63,40.16 272.69,41.1 272.69,41.73 273,42.04 273,44.58 272.4,45.18 272.4,54.65 268.91,58.14 264.58,58.14 262.49,60.23 239.71,60.23 238.99,59.5 234.56,59.5 232.29,61.77 225.28,61.77 224.76,62.29 v2(223.32,62.29)
BAT2_LED#: length 121.1
  TOP w0.127: QE23.2 216.19,56.01 v1(215.7,55.51)
  TOP w0.203: RE113.1 296.09,21.41 298.31,21.41 298.34,21.39 UE1.1
  TOP w0.254: RE113.1 295.95,21.55 295.95,23.05 296.05,23.15 296.05,23.47 v2(296.06,23.48) ; v2(216.84,57.48) 216.19,56.84 QE23.2
  IN1 w0.254: v2(296.06,23.48) 296.06,23.31 295.56,22.81 291.73,22.81 290.93,23.61 288.17,23.61 287.97,23.41 286.25,23.41 285.44,24.22 278.16,24.22 276.11,26.27 276.11,27.65 274.96,28.8 v2(274.96,28.92)
  IN3 w0.254: v2(216.84,57.48) 216.84,58.32 218.1,59.58 225.79,59.58 226.23,59.14 227.14,59.14 227.96,59.95 231.03,59.95 231.37,60.29 233.15,60.29 233.85,59.59 246.1,59.59 248.39,61.88 263.92,61.88 267.78,58.01 267.78,37.18 268.97,35.99 268.97,34.99 271.31,32.64 271.31,32.36 272.27,31.4 273.1,31.4 274.38,30.11 274.38,29.49 v2(274.96,28.92)
BATDRV_CHG: length 18.2
  TOP w0.14: PR707.2 50.13,36.05 v1(49.82,35.74)
  TOP w0.254: PR707.2 v2(49.52,36.67)
  IN1 w0.254: v2(34.42,34.23) v2(34.42,34.87) 34.75,35.19 38.5,35.19 39.11,35.8 48.76,35.8 49.52,36.57 v2(49.52,36.67)
BATLOW#: length 3.1
  BOTTOM w0.076: 361.23,55.41 361.23,55.62 360.11,56.73 359.64,56.73 359.42,56.95 UT1.F2
  BOTTOM w0.14: 361.23,55.41 361.56,55.08 RT31.2
BATPRES#_CHG: length 4.1
  TOP w0.127: v1(30.81,33.56) 31.74,34.49 PR723.2
  TOP w0.203: PU700.15 33.34,36.09 32,34.75 PR723.2
BATSRC_CHG: length 19.5
  TOP w0.127: 33.57,33.87 v1(33.57,32.95)
  TOP w0.254: PR708.2 49.67,37.62 48.93,36.88 v2(48.93,36.68)
  IN1 w0.254: v2(48.93,36.68) 48.41,36.16 38.96,36.16 38.36,35.55 34.21,35.55 v2(33.53,34.87) v2(33.53,34.16)
