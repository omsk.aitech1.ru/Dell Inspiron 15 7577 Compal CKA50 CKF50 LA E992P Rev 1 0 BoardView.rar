# Allegro board Dell_Inspiron_15_7577_Compal_CKA50_CKF50_LA_E992P_Rev_1_0_BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
BATT+: length 0.9
  TOP w0.14: v2(58.17,37.59) v4(59.02,37.59)
BATT++: length 30.2
  IN2 w0.508: 56.55,34.45 56.55,34.95 54.97,36.54 51.89,36.54 51.23,35.88 43.65,35.88 41.92,37.61 40.65,37.61 38.65,39.61 38.65,42.76 v2(40.32,44.44)
  BOTTOM w0.508: v2(40.32,44.44) 41.64,44.44 42.19,43.89 42.19,43.22 42.74,42.67 PD700.3
  vias: v2(56.94,33.8) v2(57.54,33.8) v2(57.84,34.37) v2(58.18,33.8) v4(56.07,32.92) v4(57.77,35.08) v4(59.51,35.25)
BATT_PRS: length 19
  TOP w0.14: v2(44.96,30.86) v1(45.53,30.86)
  TOP w0.254: v2(58.45,28.7) 58.54,28.7 PR12.1
  IN2 w0.254: v2(58.45,28.7) 58.41,28.73 57.44,28.73 56.45,29.72 46.1,29.72 v2(44.96,30.86)
  BOTTOM w0.254: v2(44.96,30.86) 43.6,32.22 PBATT1.6
BBS_BIT0: length 2.9
  TOP w0.14: v2(282.4,34.93) 282.4,35.47 RH130.2 281.88,35.39 281.88,35.07 v1(281.47,34.66)
  BOTTOM w0.102: v2(282.4,34.93) 282.78,34.93 UH2.AT29
BEEP: length 41.1
  TOP w0.14: v2(305.77,5.85) 305.74,5.85 305.6,5.99 UE1.45 ; v1(338.57,12.64) 338.57,11.57 D1.2 339.04,10.24 v2(339.03,10.23)
  IN4 w0.137: v2(305.77,5.85) 306.03,5.59 310.15,5.59 311.16,4.57 315.82,4.57 322.4,11.15 338.1,11.15 v2(339.03,10.23)
BIA_PWM_PCH: length 223.7
  TOP w0.14: RH20.2 278.82,42.49 v2(278.82,42.48) ; DV2.2 92.18,47.19 v2(92.36,47.02) ; v2(99.29,50.89) v1(98.32,50.89)
  IN4 w0.137: v2(99.29,50.89) 100.17,50.89 100.79,50.27 128.24,50.27 130.36,48.15 171.09,48.15 173.93,45.31 197.89,45.31 198.47,44.73 205.72,44.73 206.16,45.18 238.06,45.18 245.93,53.05 245.93,58.88 247.66,60.61 247.66,61.88 248.09,62.32 265.7,62.32 269.83,58.18 269.83,52 270.69,51.14 270.69,47.96 273.85,44.8 274.05,44.8 274.3,44.8 275.36,43.73 275.36,42.75 276.21,41.9 278.37,41.9 278.82,42.35 v2(278.82,42.48)
  IN5 w0.097: v2(92.36,47.02) 98.76,47.02 100.07,48.33 100.07,50.11 v2(99.29,50.89)
  BOTTOM w0.089: v2(278.82,42.48) UH2.W36
BKLT_IN_EC: length 4.5
  TOP w0.14: UE1.67 312.97,9.79 v2(312.93,9.74)
  BOTTOM w0.14: v1(312.93,8.75) v2(312.93,9.74) RE134.1 RE114.2
BOARD_ID: length 4.9
  TOP w0.14: UE1.111 307.6,24.02 307.62,24.04 v1(307.62,24.82) 307.62,25.66 CE98.1 ; RE14.2 CE98.1 ; CE98.1 308.67,25.87 RE13.2
BOOT_1.2V: length 1.4
  TOP w0.14: PR200.2 107.68,67.54 v1(106.66,67.54)
BREATH_LED#: length 49.8
  TOP w0.203: UE1.70 315.73,10.99 316.12,11.37 v2(316.23,11.37)
  TOP w0.254: v2(281.26,7) 281.26,7.03 280.84,7.45 QE24.2
  IN1 w0.254: v2(281.26,7) 281.83,7.58 285.6,7.58 286.21,6.97 294.07,6.97 294.89,6.14 300.12,6.14 301.73,4.54 308.97,4.54 309.56,5.13 316.93,5.13 317.41,5.62 317.41,9.4 317.7,9.69 317.7,10.91 317.24,11.37 v2(316.23,11.37)
  BOTTOM w0.254: v2(316.23,11.37) v1(316.78,11.37) 317.26,11.37 RE119.1
BREATH_LED_MB: length 93.7
  TOP w0.254: v2(271.12,7.52) v4(276.63,7.52) 277.47,7.52 278.75,8.8 281.14,8.8 281.49,8.46 QE24.3 281.49,7.6 282.23,6.85 283.58,6.85 LED3.1
  IN1 w0.254: v2(220.12,23.73) 220.83,23.02 225.25,23.02 226.91,24.68 236.39,24.68 239.69,21.37 251.67,21.37 252.93,20.11 256.52,20.11 258.33,18.29 v2(258.33,17.43)
  IN5 w0.254: v2(258.33,17.43) 261.3,17.43 266,12.73 266.7,12.73 268.02,11.41 271.27,11.41 273.17,9.52 273.17,8.17 272.52,7.52 v2(271.12,7.52)
  BOTTOM w0.254: JPW.5 215.65,29.01 217.88,31.24 D5225.3 217.91,31.44 219.68,31.44 220.64,30.48 220.64,29.63 220.04,29.04 220.04,23.81 v2(220.12,23.73)
BREATH_LED_R2: length 2.3
  TOP w0.127: v1(282.78,9.69) 282.6,9.52 RW3.1
  TOP w0.254: RW3.1 282.75,8.45 LED3.2
BS_1.8V: length 1.8
  TOP w0.14: PR18V01.1 273.34,79.77 v1(273.83,79.29)
  vias: v2(272.45,80.61) v2(272.84,80.17)
BS_VCCIO: length 1.4
  BOTTOM w0.127: PR4000.1 120.7,102.26 v1(120.26,102.71)
BST_1.2V: length 2.4
  TOP w0.14: v1(110.24,71.9) 109.36,71.02 108.64,71.02 108.31,70.69
BST_1.8V: length 1.6
  TOP w0.14: v1(273.76,83.68) 273.34,83.26 PR18V01.2
BST_1V: length 4.2
  TOP w0.14: PC106.1 252.81,46.1 v1(255.83,46.1)
BST_3V: length 2.2
  TOP w0.14: PR307.1 79.9,47.85 v4(78.98,48.77)
BST_5V: length 2.5
  TOP w0.14: PR308.2 79.14,37.82 v1(78.98,37.98)
  TOP w0.254: PR308.2 80.88,37.82 PC310.1
BST_+1.35V: length 1.7
  TOP w0.14: v1(244.04,54.31) 242.93,55.43 PC808.1
BST_CHG: length 1.4
  TOP w0.14: v1(41.43,37.91) 40.83,37.91 PR712.1
BST_GPU_PH1: length 1.1
  BOTTOM w0.14: PC6102.1 v1(168.97,133.25)
BST_GPU_PH2: length 1.2
  BOTTOM w0.14: v1(168.3,142.45) 169.44,142.45 PC6115.1
BST_GPU_PH3: length 1
  BOTTOM w0.14: PC6129.1 v1(170.77,121.28)
BT_RADIO_DIS#: length 86.6
  TOP w0.14: DN2.1 343.57,44.05 343.77,43.84 v1(344.67,43.84) 346.25,43.84 346.98,43.12 346.98,41.05 v2(346.25,40.33)
  IN4 w0.137: v2(277.48,33.84) 277.58,33.84 277.74,33.67 278.62,33.67 279.23,33.06 280.24,33.06 282.87,30.43 296.32,30.43 297.02,31.13 297.88,31.13 298.39,31.64 300.23,31.64 300.92,32.33 301.83,32.33 302.59,33.08 305.7,33.08 307.85,35.24 316.96,35.24 317.42,34.78 327.82,34.78 328.66,35.62 333.03,35.62 333.61,36.21 333.61,36.74 334.04,37.16 336.33,37.16 337.39,36.11 343.94,36.11 345.53,37.69 345.97,37.69 346.95,38.68 346.95,39.63 v2(346.25,40.33)
  BOTTOM w0.102: v2(277.48,33.84) UH2.AV43
BT_RADIO_DIS#_R: length 7.2
  TOP w0.14: DN2.2 341.57,43.82 v2(340.92,43.18)
  BOTTOM w0.14: JNGFF1.46 339.28,46.55 340,45.83 340,44.43 340.92,43.51 v2(340.92,43.18)
BTST_CHG:
  vias: v1(37.73,38.47)
BUSPOWER#: length 2.8
  BOTTOM w0.076: 364.53,70.53 363.69,70.53 UT4.F10
  BOTTOM w0.14: 364.53,70.53 365,70.53 365.15,70.39 RT74.2
CAM_CBL_DET#: length 6.3
  BOTTOM w0.076: 274.23,45.11 274.26,45.11 275.05,44.32 275.66,44.32 276,43.98 UH2.U43
  BOTTOM w0.14: RH79.1 271.06,46 v1(273.03,46) 273.33,46 274.06,45.27 274.07,45.27 274.23,45.11
CAP_LED: length 10.1
  TOP w0.127: v4(107.49,32.02) 107.2,32.32 v2(106.18,32.32)
  BOTTOM w0.203: JKB1.4 v2(106.18,32.32)
  BOTTOM w0.254: RE2.2 110.26,32.72 106.58,32.72 v2(106.18,32.32)
CAP_LED#: length 210.5
  TOP w0.203: v2(304.58,18.08) 306.95,18.08 307.81,18.94 311.53,18.94 312.78,20.19 UE1.93
  IN4 w0.254: v2(117.48,31.69) 118.52,32.73 135.93,32.73 136.69,31.97 158.03,31.97 158.79,31.21 190.35,31.21 191.64,29.91 213.54,29.91 215.26,31.64 249.41,31.64 250.56,30.48 253.86,30.48 253.89,30.44 255.28,29.06 256.88,29.06 263.02,22.91 269.95,22.91 271.43,21.43 275.77,21.43 276.66,20.54 285.88,20.54 287.03,19.38 297.09,19.38 297.85,18.62 298.6,18.62 298.98,19 302.05,19 302.54,18.51 304.15,18.51 v2(304.58,18.08)
  BOTTOM w0.127: v2(117.48,31.69) v1(118.38,31.69)
  BOTTOM w0.254: QE3.3 118.36,29.71 RE120.1 v2(117.48,31.69)
CAP_LED_R: length 5.8
  BOTTOM w0.254: v2(113.65,32.02) RE2.1 115.13,30.24 115.86,29.5 QE4.1
CBN: length 2.9
  TOP w0.203: HDA1.35 347.95,21.86 348.21,22.13
  TOP w0.305: CA20.2 349.92,22.25 v1(348.78,22.25) 348.34,22.25 348.21,22.13
CBP: length 3.4
  TOP w0.305: CA20.1 349.45,23.46 349.34,23.57 v1(348.73,23.57) 347.88,23.57 347.7,23.4 346.85,23.4
CFG0: length 199.9
  TOP w0.14: v2(215.29,57.53) 215.18,57.53 212.67,55.03 v1(209.45,55.03) 199.94,55.03 199.24,55.73 RH528.2 ; v2(141.95,96.05) 141.95,95.71 141.56,95.32 RH183.1
  IN3 w0.124: v2(215.29,57.53) 208.33,50.57 203.12,50.57 202.76,50.21 197.66,50.21 197.39,49.94 192.01,49.94 189.8,47.73 132.23,47.73 120.24,59.71 120.24,65.56 118.09,67.72 118.09,77.18 121.09,80.18 121.09,85.26 129.48,93.65 129.7,93.65 131.87,95.83 132.09,95.83 132.94,96.68 133.77,96.68 134.29,97.2 135.85,97.2 136.66,96.39 140.88,96.39 140.99,96.5 141.82,96.5 141.95,96.37 v2(141.95,96.05)
  BOTTOM w0.114: v2(141.95,96.05) 141.62,95.73 UH1.BN25
  BOTTOM w0.14: JXDP1.9 208.87,63.32 209.31,63.76 209.9,63.76 210.74,64.6 217.68,64.6 218.26,64.02 218.26,58.02 217.04,56.81 216.02,56.81 v2(215.29,57.53)
CFG1: length 128.1
  IN3 w0.124: v2(141.97,97.6) 143.55,96.02 143.55,89.42 139.2,85.08 138.7,85.08 138.3,84.68 136.38,84.68 134.73,83.03 133.74,83.03 132.2,81.49 132.2,76.49 134.09,74.6 134.09,61.24 137.19,58.14 184.39,58.14 190.88,64.62 193.85,64.62 195.14,65.92 196.62,65.92 197.76,67.06 204.11,67.06 204.82,66.36 204.82,66.33 v2(204.93,66.21)
  BOTTOM w0.076: UH1.BN27 141.63,97.24 141.97,97.58 v2(141.97,97.6)
  BOTTOM w0.14: JXDP1.11 208.37,64.35 207.99,64.73 206.34,64.73 205.73,65.34 205.19,65.34 204.94,65.59 204.94,66.2 v2(204.93,66.21)
CFG2: length 161.4
  TOP w0.14: RH184.1 140.4,95.8 141.04,95.8 v2(141.3,96.05) ; v2(212.52,57.36) 212.01,57.36 v1(211.71,57.06)
  IN3 w0.124: v2(141.3,96.05) 141.2,95.96 136.48,95.96 135.74,95.22 134.37,95.22 133.64,94.5 132.18,94.5 130.18,92.49 129.96,92.49 122.25,84.78 122.25,79.66 119.35,76.75 119.35,68.1 121.41,66.04 121.41,60.19 132.71,48.89 189.2,48.89 191.55,51.24 197.05,51.24 197.29,51.48 202.38,51.48 202.94,52.03 207.21,52.03 212.52,57.34 v2(212.52,57.36)
  BOTTOM w0.114: UH1.BN26 141.62,96.38 v2(141.3,96.05)
  BOTTOM w0.14: v2(212.52,57.36) 212.51,57.37 208.5,57.37 207.57,58.3 207.57,60.21 207.37,60.41 JXDP1.15
CFG3: length 142
  TOP w0.14: RH517.2 212.22,58.74 v1(212.95,58.01) 213.1,57.86 v2(213.1,57.19)
  IN3 w0.124: v2(141.31,98.45) 142.53,98.45 143.98,97.01 143.98,89.25 139.38,84.65 138.88,84.65 136.84,82.6 133.92,82.6 132.63,81.31 132.63,76.67 134.6,74.7 134.6,61.48 137.5,58.57 184.22,58.57 190.72,65.08 193.7,65.08 194.97,66.35 196.44,66.35 197.58,67.49 205.63,67.49 207.37,65.75 207.37,64.25 v2(207.16,64.05)
  BOTTOM w0.076: UH1.BN28 141.62,98.07 141.31,98.38 v2(141.31,98.45)
  BOTTOM w0.14: v2(213.1,57.19) 212.71,56.8 208.81,56.8 208.45,56.8 207.13,58.12 207.13,60.02 206.87,60.28 JXDP1.17 206.87,63.54 207.16,63.83 v2(207.16,64.05)
CFG4: length 127.3
  IN3 w0.124: v2(205.02,59.42) 205.01,59.42 204.85,59.58 203.57,59.58 202.2,58.21 200.32,58.21 200,57.89 191.28,57.89 186.91,53.52 135.9,53.52 128.87,60.55 128.87,65.3 123.97,70.2 123.97,74.84 126.87,77.74 126.87,82.14 131.95,87.22 132.75,87.22 133.97,88.43 v2(133.97,88.86)
  BOTTOM w0.14: JXDP1.27 204.37,60.3 205.02,59.65 v2(205.02,59.42) ; v2(133.97,88.86) 133.97,89.28 v1(134.18,89.49) 134.51,89.82 136.09,89.82 136.16,89.88 136.83,89.88 136.83,89.87 136.92,89.87 RH185.1 137.84,90.36 138.35,90.87 138.61,90.87 139.02,91.28 139.52,91.28 139.52,91.29 139.81,91.29 139.82,91.28 139.85,91.28 139.89,91.32 139.91,91.32 UH1.BR20
CFG5: length 131.8
  TOP w0.14: v2(137.41,88.78) v1(137.41,89.5)
  IN3 w0.124: v2(137.41,88.78) 137.41,88.68 136.67,87.94 135.99,87.94 134.11,86.05 132.43,86.05 128.04,81.66 128.04,77.26 125.14,74.35 125.14,70.68 130.03,65.78 130.03,61.3 136.65,54.68 186.43,54.68 192.24,60.49 194.69,60.49 195.35,61.15 200.11,61.15 200.52,61.56 203.3,61.56 204.72,62.97 204.72,64.43 204.39,64.76 204.39,65.25 v2(204.54,65.41)
  IN5 w0.097: v2(142.58,91.32) 142.18,91.72 139.95,91.72 137.41,89.18 v2(137.41,88.78)
  BOTTOM w0.14: UH1.BM20 v2(142.58,91.32) ; v2(204.54,65.41) 204.52,65.39 204.52,63.86 203.87,63.21 JXDP1.29 ; v2(137.41,88.78) RH186.1
CFG6: length 130
  IN3 w0.124: v2(133.07,89.44) 131.92,88.29 131.7,88.29 126.44,83.04 126.44,77.92 123.54,75.01 123.54,70.02 128.42,65.14 128.42,60.39 135.73,53.09 187.09,53.09 191.41,57.41 200.13,57.41 200.41,57.69 202.28,57.69 203.26,58.66 204.85,58.66 v2(205.02,58.83)
  BOTTOM w0.14: UH1.BT20 138.84,91.72 138.42,91.31 RH187.1 136.93,90.83 v1(134.86,90.83) 134.46,90.83 v2(133.07,89.44) ; v2(205.02,58.83) 204.63,58.45 203.84,58.45 203.37,58.93 203.37,59.74 202.87,60.24 JXDP1.33
CFG7: length 118.6
  TOP w0.14: v2(141.28,91.32) v1(140.53,91.32)
  IN3 w0.124: v2(141.28,91.32) 141.28,91.14 141.8,90.63 141.8,90.25 141.11,89.56 141.03,89.56 137.69,86.22 136.71,86.22 134.38,83.89 133.39,83.89 131.34,81.84 131.34,76.14 133.15,74.33 133.15,60.97 136.83,57.28 184.75,57.28 190.01,62.54 191.33,62.54 191.6,62.27 194.05,62.27 195.3,63.53 196.98,63.53 197.64,62.87 199.4,62.87 199.81,63.27 201.72,63.27 v2(202.56,64.11)
  BOTTOM w0.14: v2(202.56,64.11) 202.37,63.93 JXDP1.35 ; RH188.1 138.44,92.2 138.61,92.03 140.77,92.03 140.97,91.84 UH1.BP20 v2(141.28,91.32)
CFG8: length 152.8
  TOP w0.14: v2(210.26,65.31) v1(209.55,65.31)
  IN3 w0.124: v2(140.63,93.68) 140.63,93.68 140.09,94.22 138.11,94.22 136.89,93 134.62,93 134.25,92.64 133.56,92.64 132.67,91.75 131.91,91.75 130.9,90.75 130.68,90.75 123.99,84.05 123.99,78.93 121.09,76.03 121.09,69 125.36,64.73 125.36,58.71 133.43,50.64 188.48,50.64 191.34,53.5 201.93,53.5 202.64,54.21 206.91,54.21 208.98,56.27 208.98,59.92 209.51,60.46 209.51,64.56 210.25,65.31 v2(210.26,65.31)
  BOTTOM w0.14: v2(210.26,65.31) 209.78,65.31 208.87,66.22 JXDP1.10 ; UH1.BR23 140.63,93.78 v2(140.63,93.68)
CFG9: length 142.6
  TOP w0.14: v2(139.96,92.94) 139.96,92.82 v1(139.49,92.34)
  IN3 w0.124: v2(208.39,66.21) 207.94,65.76 207.94,65.2 208.22,64.92 208.22,60.99 207.26,60.03 207.26,58.67 206.04,57.45 204.06,57.45 201.86,55.25 198.54,55.25 198.31,55.02 190.68,55.02 187.59,51.92 135.24,51.92 127.22,59.95 127.22,64.7 122.38,69.54 122.38,75.5 125.28,78.4 125.28,83.52 131.22,89.46 131.43,89.46 132.44,90.46 133.21,90.46 133.58,90.83 137.39,90.83 138.49,91.93 138.89,91.93 139.9,92.94 v2(139.96,92.94)
  BOTTOM w0.102: v2(208.39,66.21) 208.37,66.24 JXDP1.12
  BOTTOM w0.14: UH1.BR22 v2(139.96,92.94)
CFG10: length 152.4
  IN3 w0.124: v2(139.99,93.7) 139.66,93.37 138.46,93.37 137.72,92.62 137.12,92.62 137.07,92.57 135.54,92.57 134.66,91.69 133.22,91.69 132.85,91.32 132.08,91.32 131.08,90.32 130.86,90.32 124.42,83.88 124.42,78.75 121.52,75.85 121.52,69.18 126.01,64.69 126.01,59.94 134.89,51.07 188.3,51.07 191.38,54.14 201.97,54.14 202.53,54.7 206.8,54.7 208.55,56.45 208.55,60.1 209.08,60.63 209.08,64.89 209.42,65.24 209.42,66.84 207.71,68.55 v2(207.71,69.9)
  BOTTOM w0.14: v2(207.71,69.9) 207.37,69.56 JXDP1.16 ; v2(139.99,93.7) 139.99,93.76 UH1.BT23
CFG11: length 149.3
  IN3 w0.124: v2(207.06,69.91) 207.06,68.59 208.99,66.67 208.99,65.48 208.65,65.13 208.65,60.81 207.69,59.85 207.69,56.48 206.4,55.2 202.42,55.2 202.04,54.82 198.72,54.82 198.49,54.59 190.86,54.59 187.77,51.49 135.07,51.49 126.56,60.01 126.56,64.75 121.95,69.36 121.95,75.67 124.85,78.58 124.85,83.7 131.04,89.89 131.26,89.89 132.26,90.89 133.03,90.89 133.4,91.26 134.96,91.26 135.43,91.73 137.43,91.73 138.64,92.94 v2(139.31,92.94)
  BOTTOM w0.14: v2(207.06,69.91) 206.87,69.72 JXDP1.18 ; UH1.BT22 v2(139.31,92.94)
CFG12: length 116.7
  TOP w0.14: v1(142.93,89.37) 142.58,89.72 v2(142.58,90.53)
  IN3 w0.124: v2(204.39,66) 204.39,66.18 203.94,66.63 197.93,66.63 196.79,65.49 195.32,65.49 194.03,64.19 191.97,64.19 191.11,63.34 190.2,63.34 184.57,57.71 137.01,57.71 133.58,61.14 133.58,74.51 131.77,76.32 131.77,81.66 133.57,83.46 134.55,83.46 136.65,85.56 138.51,85.56 138.72,85.78 138.72,86.65 140.8,88.73 141.67,88.73 142.58,89.64 v2(142.58,90.53)
  BOTTOM w0.14: JXDP1.28 204.37,66.02 v2(204.39,66) ; UH1.BM19 v2(142.58,90.53)
CFG13: length 123.7
  TOP w0.14: v1(139.92,89.4) 140.63,90.11 v2(140.63,90.53)
  IN3 w0.124: v2(140.63,90.53) 140.63,90.38 137.33,87.08 136.35,87.08 134.02,84.75 133.03,84.75 128.9,80.61 128.9,76.9 125.99,74 125.99,71.04 130.92,66.11 130.92,61.76 137.14,55.54 184.22,55.54 190.36,61.68 190.97,61.68 191.31,61.35 194.34,61.35 195.66,62.67 196.62,62.67 197.28,62.01 199.75,62.01 200.16,62.42 202.39,62.42 203.41,63.44 203.41,64.2 203.53,64.31 203.53,65.79 v2(203.81,66.07)
  BOTTOM w0.14: JXDP1.30 203.87,66.13 v2(203.81,66.07) ; UH1.BR19 v2(140.63,90.53)
CFG14: length 119
  TOP w0.14: v2(141.28,90.53) 141.28,89.49 v1(141.4,89.37)
  IN3 w0.124: v2(202.65,66.21) 202.65,65.79 202.73,65.71 203.1,65.35 203.1,64.49 202.98,64.38 202.98,63.62 202.21,62.84 199.98,62.84 199.58,62.44 197.46,62.44 196.8,63.1 195.48,63.1 194.16,61.78 191.48,61.78 191.15,62.11 190.19,62.11 184.93,56.85 136.61,56.85 132.69,60.78 132.69,74.13 129.33,77.5 129.33,80.44 133.21,84.32 134.2,84.32 136.53,86.65 137.51,86.65 141.28,90.43 v2(141.28,90.53)
  BOTTOM w0.14: v2(202.65,66.21) 202.87,66.43 JXDP1.34 ; UH1.BP19 v2(141.28,90.53)
CFG15: length 126
  TOP w0.14: v2(139.98,90.53) 139.27,90.53 v1(139.04,90.76)
  IN3 w0.124: v2(139.98,90.53) 139.98,90.34 137.15,87.51 136.17,87.51 133.84,85.18 132.85,85.18 128.47,80.79 128.47,77.08 125.56,74.18 125.56,70.86 130.46,65.96 130.46,61.48 136.83,55.11 186.25,55.11 192.06,60.92 194.51,60.92 195.17,61.58 199.93,61.58 200.34,61.99 203.12,61.99 204.29,63.15 204.29,64.25 203.96,64.58 v2(203.96,65.43)
  BOTTOM w0.14: UH1.BT19 v2(139.98,90.53) ; v2(203.96,65.43) 202.37,65.43 202.23,65.57 202.23,66.64 202.37,66.79 JXDP1.36
CFG16: length 156.1
  TOP w0.14: v2(141.26,93.68) 141.26,93.65 v1(141.62,93.3)
  IN3 w0.124: v2(141.26,93.68) 141.26,93.87 140.33,94.8 137.87,94.8 136.65,93.58 134.38,93.58 134.13,93.33 133.41,93.33 132.41,92.33 131.66,92.33 130.66,91.33 130.44,91.33 123.41,84.3 123.41,79.17 120.51,76.27 120.51,68.76 124.78,64.49 124.78,58.47 133.19,50.05 188.72,50.05 191.41,52.75 202.01,52.75 202.74,53.48 207.01,53.48 209.56,56.03 209.56,59.68 210.09,60.21 210.09,63.77 210.86,64.54 v2(210.86,65.05)
  BOTTOM w0.14: v2(141.26,93.68) 141.26,93.79 UH1.BP23 ; v2(210.86,65.05) 210.86,65.41 209.87,66.39 JXDP1.6
CFG17: length 161.2
  TOP w0.14: v2(210.89,66.22) 210.65,66.22 v1(210.24,66.64)
  IN3 w0.124: v2(141.93,93.7) 141.93,93.71 142.36,94.14 142.36,94.65 141.64,95.38 136.84,95.38 136.1,94.64 134.61,94.64 133.88,93.91 132.42,93.91 130.42,91.91 130.2,91.91 122.83,84.54 122.83,79.41 119.93,76.51 119.93,68.34 121.99,66.28 121.99,60.44 132.95,49.47 188.96,49.47 191.55,52.06 202.14,52.06 202.84,52.76 207.11,52.76 210.14,55.79 210.14,59.44 210.67,59.97 210.67,63.53 211.44,64.3 211.44,65.36 210.89,65.91 v2(210.89,66.22)
  BOTTOM w0.14: v2(210.89,66.22) 210.88,66.22 210.37,66.74 JXDP1.4 ; UH1.BN23 141.93,93.78 v2(141.93,93.7)
CFG18: length 132.2
  TOP w0.14: v1(141.96,91.89) 141.26,92.59 v2(141.26,92.92)
  IN3 w0.124: v2(205.37,65.76) 205.84,65.29 205.84,65.12 205.84,64.67 205.65,64.48 205.65,63.97 205.41,63.73 205.41,62.84 203.54,60.98 200.76,60.98 200.35,60.57 195.59,60.57 194.93,59.91 192.48,59.91 186.67,54.1 136.41,54.1 129.45,61.06 129.45,65.54 124.55,70.44 124.55,74.6 127.46,77.5 127.46,81.9 132.19,86.63 133.1,86.63 135.73,89.26 137.47,89.26 138.77,90.57 139.17,90.57 141.26,92.65 v2(141.26,92.92)
  BOTTOM w0.14: UH1.BN22 141.29,92.97 141.29,92.93 141.28,92.92 v2(141.26,92.92) ; v2(205.37,65.76) JXDP1.24
CFG19: length 140.6
  TOP w0.14: v1(205.4,66.94) 205.4,66.63 v2(205.8,66.23)
  IN3 w0.124: v2(205.8,66.23) 206.74,65.29 206.74,63.78 207.06,63.47 207.06,61.08 206.07,60.08 206.07,58.6 205.5,58.03 203.45,58.03 202.49,57.06 200.61,57.06 200.33,56.78 191.61,56.78 187.33,52.51 135.49,52.51 127.82,60.17 127.82,64.92 122.96,69.78 122.96,75.26 125.86,78.16 125.86,83.28 131.46,88.88 131.68,88.88 132.68,89.88 137.26,89.88 138.58,91.2 138.98,91.2 140.61,92.83 v2(140.61,92.94)
  BOTTOM w0.102: v2(205.8,66.23) 205.87,66.3 JXDP1.22
  BOTTOM w0.14: UH1.BP22 v2(140.61,92.94)
CFG_RCOMP: length 3
  BOTTOM w0.254: RH59.1 137.64,93.98 139.33,95.66 UH1.BT25
CHG_B+: length 1.8
  TOP w0.14: 41.14,46.37 v1(41.14,48.14)
  vias: v2(41.01,40.85) v2(41.06,41.43) v2(41.59,40.82) v2(41.7,41.43) v2(42.08,39.91) v2(42.08,39.27)
CLK_PCIE_LAN: length 299
  IN5 w0.104: v2(31.72,31.01) 32.12,31.01 32.22,30.9 32.22,30.09 36.57,25.74 61.15,25.74 61.9,25 67.51,25 68.75,26.23 104.21,26.23 104.39,26.41 138.89,26.41 139.7,25.6 179.28,25.6 179.91,26.23 221.42,26.23 222.75,27.56 230.91,27.56 231.31,27.97 246.1,27.97 246.47,28.33 250.29,28.33 250.66,27.97 258.95,27.97 264.07,33.09 264.07,34.56 266.11,36.6 266.11,36.6 266.82,37.31 266.83,37.31 268.11,38.6 270.13,38.6 273.34,41.81 282.89,41.81 284.2,43.13 284.2,43.78 284.67,44.25 285.18,44.25 285.36,44.44 288.29,44.44 289.03,45.18 289.03,45.73 292.67,49.37 294,49.37 294.53,49.9 295.6,49.9 295.64,49.94 v2(295.66,49.94)
  BOTTOM w0.076: UH2.F2 295.71,49.93 295.7,49.94 v2(295.66,49.94)
  BOTTOM w0.14: UL1.15 28.87,44.34 28.94,44.26 29.33,44.26 30,43.59 31.5,43.59 32.61,42.48 32.61,41.35 32.91,41.06 32.91,37.1 32.3,36.49 32.3,35.61 32.3,35.61 32.3,34.97 32.3,34.96 32.3,33.78 33.24,32.85 33.24,31.36 32.91,31.03 31.75,31.03 v2(31.72,31.01)
CLK_PCIE_LAN#: length 299.1
  IN5 w0.104: v2(31.72,31.59) 31.85,31.72 32,31.72 32.16,31.56 32.16,31.24 32.41,30.98 32.41,30.17 36.65,25.94 61.23,25.94 61.98,25.19 67.43,25.19 68.67,26.42 104.13,26.42 104.31,26.6 138.97,26.6 139.78,25.8 179.2,25.8 179.83,26.42 221.34,26.42 222.67,27.76 230.83,27.76 231.23,28.16 246.02,28.16 246.39,28.53 250.37,28.53 250.74,28.16 258.87,28.16 263.88,33.17 263.88,34.64 265.92,36.68 265.92,36.68 266.74,37.51 266.75,37.51 268.03,38.79 270.05,38.79 273.26,42 282.81,42 284.01,43.21 284.01,43.86 284.59,44.44 285.1,44.44 285.28,44.63 288.21,44.63 288.83,45.26 288.83,45.81 292.59,49.56 293.92,49.56 294.45,50.09 294.93,50.09 295.26,50.42 v2(295.3,50.42)
  BOTTOM w0.076: v2(295.3,50.42) 295.75,50.42 UH2.D3
  BOTTOM w0.14: UL1.16 28.87,43.94 28.92,43.98 29.21,43.98 29.86,43.34 31.4,43.34 32.36,42.37 32.36,41.25 32.65,40.96 32.65,37.2 32.04,36.6 v3(32.04,35.21) 32.04,33.68 32.96,32.77 32.96,31.48 32.77,31.29 32.41,31.29 32.3,31.4 32.3,31.87 32.16,32.01 31.89,32.01 31.72,31.84 v2(31.72,31.59)
CLK_PCIE_N5: length 74.1
  IN4 w0.147: v2(351.24,52.57) 351.02,52.35 350.98,52.35 349.92,51.3 349.92,46.45 349.06,45.58 345.15,45.58 344.42,46.3 340.12,46.3 339.98,46.45 339.07,46.45 336.7,48.82 334.47,48.82 333.5,49.78 328.78,49.78 326.67,47.67 319.61,47.67 319.07,48.22 315.23,48.22 314.2,49.25 309.85,49.25 309.16,49.94 306.24,49.94 305.04,48.75 301.56,48.75 301.35,48.96 301.35,51.34 299.92,52.77 296.97,52.77 295.68,51.49 293.54,51.49 293.13,51.08 293.13,50.17 v2(292.96,50)
  BOTTOM w0.076: v2(292.96,50) 292.87,50.1 292.87,50.21 293.16,50.5 293.26,50.5 UH2.D8 ; UT1.T19 351.56,52.25 v2(351.24,52.57)
CLK_PCIE_P5: length 74.1
  IN4 w0.147: v2(293.73,50) 293.85,50 294,50.15 294,50.39 293.89,50.5 293.55,50.5 293.41,50.64 293.41,50.96 293.65,51.21 295.8,51.21 297.08,52.49 299.8,52.49 301.07,51.22 301.07,48.84 301.45,48.47 305.16,48.47 306.35,49.66 309.04,49.66 309.73,48.98 314.09,48.98 315.12,47.95 318.95,47.95 319.5,47.4 326.78,47.4 328.89,49.51 333.39,49.51 334.35,48.54 336.58,48.54 338.95,46.17 339.87,46.17 340.01,46.03 344.31,46.03 345.03,45.3 349.17,45.3 350.2,46.33 350.2,51.19 350.93,51.92 v2(351.24,51.92)
  BOTTOM w0.076: UT1.V19 351.56,51.6 v2(351.24,51.92) ; v2(293.73,50) 293.73,50.2 UH2.D7
CLK_PCIE_SSD: length 48.5
  IN2 w0.104: v2(276.37,13.54) 276.37,14.21 276.47,14.32 277.34,14.32 277.79,14.76 277.79,17.81 277.33,18.26 277.33,28.28 278.69,29.63 278.69,32.84 278.42,33.1 278.42,33.98 279.06,34.62 279.06,34.94 280.61,36.49 280.61,36.99 280.92,37.3 281.21,37.3 281.85,37.95 281.85,38.49 282.95,39.59 287.51,39.59 288.09,40.17 288.09,41.6 290.17,43.69 292,43.69 293.3,44.98 293.3,45.27 v2(293.76,45.73)
  BOTTOM w0.114: v2(293.76,45.73) 294.14,45.35 UH2.R7
  BOTTOM w0.14: JNGFF2.55 275.94,12.28 276.37,12.7 v2(276.37,13.54)
CLK_PCIE_SSD#: length 48.4
  IN2 w0.104: v2(275.78,13.54) 276.17,13.93 276.17,14.29 276.39,14.51 277.26,14.51 277.6,14.84 277.6,17.73 277.14,18.18 277.14,28.4 278.5,29.76 278.5,32.76 278.23,33.02 278.23,34.06 278.87,34.7 278.87,35.02 280.42,36.57 280.42,37.07 280.84,37.49 281.13,37.49 281.66,38.03 281.66,38.57 282.87,39.78 287.43,39.78 287.9,40.25 287.9,41.68 290.09,43.88 291.92,43.88 293.1,45.06 293.1,45.62 v2(292.99,45.73)
  BOTTOM w0.114: v2(292.99,45.73) 293.38,45.35 UH2.R8
  BOTTOM w0.14: v2(275.78,13.54) 275.78,13.52 276.11,13.19 276.11,12.81 275.83,12.53 275,12.53 274.76,12.78 JNGFF2.53
CLK_PCIE_WLAN: length 57
  IN4 w0.147: v2(294.6,49.37) 294.61,49.22 294.61,49.21 294.69,49.13 294.69,48.77 294.99,48.46 296.66,48.46 298,49.79 298.99,49.79 301.11,47.67 303.27,47.67 303.98,46.95 305.39,46.95 305.48,46.87 307.74,46.87 309.05,48.17 313.75,48.17 314.78,47.15 318.55,47.15 319.26,46.43 319.49,46.43 323.78,46.43 324.21,46 327.88,46 329.57,47.69 336.25,47.69 339.12,44.82 340.69,44.82 v2(340.89,45.01)
  BOTTOM w0.076: v2(294.6,49.37) 294.6,49.37 294.92,49.04 UH2.G4
  BOTTOM w0.14: v2(340.89,45.01) 341.18,45.01 341.47,44.73 343.43,44.73 343.49,44.8 JNGFF1.39
CLK_PCIE_WLAN#: length 57.1
  IN4 w0.147: v2(340.89,45.6) 340.79,45.5 340.56,45.5 340.48,45.42 340.48,45.19 340.38,45.09 339.24,45.09 336.36,47.96 329.46,47.96 327.77,46.28 324.32,46.28 323.89,46.71 319.38,46.71 318.66,47.42 314.9,47.42 313.87,48.45 308.94,48.45 307.63,47.14 305.59,47.14 305.5,47.23 304.09,47.23 303.38,47.94 301.23,47.94 299.1,50.07 297.88,50.07 296.55,48.73 295.11,48.73 294.96,48.88 294.96,49.09 295.06,49.18 295.06,49.3 v2(295.24,49.49)
  BOTTOM w0.076: UH2.E5 295.08,49.64 295.23,49.49 v2(295.24,49.49)
  BOTTOM w0.14: JNGFF1.41 344.07,45.3 343.84,45.06 343.4,45.06 343.32,44.99 341.59,44.99 341.11,45.47 341.02,45.47 v2(340.89,45.6)
CLK_PEG_GPU: length 156.5
  IN1 w0.104: v2(199.62,96.93) 199.62,97.01 199.79,97.18 200.17,97.18 200.38,96.97 200.38,96.48 200.06,96.17 196.25,96.17 190.92,90.83 190.92,81.79 194.42,78.28 194.42,74.55 194.66,74.31 194.66,72.13 195.07,71.73 195.07,70.3 194.66,69.89 194.66,68.9 195.08,68.48 195.08,66.74 198.4,63.42 210.14,63.42 210.6,63.88 210.66,63.94 211.11,64.39 216.57,64.39 218.86,66.69 265.34,66.69 267.95,64.08 277.94,64.08 280.5,61.52 281.8,61.52 285.7,57.62 285.7,55.4 286.58,54.52 286.58,50.67 286.94,50.3 287.1,50.3 287.45,49.96 287.45,49.24 288.3,48.39 290.2,48.39 292.27,46.32 293.83,46.32 294.14,46 294.14,45.54 294,45.4 294,45.04 v2(293.79,44.83)
  BOTTOM w0.076: v2(293.79,44.83) 293.79,44.55 UH2.U7
  BOTTOM w0.089: v2(199.62,96.93) 199.62,97.06 199.75,97.19 200.01,97.19 UG9.BM26
CLK_PEG_GPU#: length 156.7
  IN1 w0.104: v2(199.65,97.54) 199.81,97.38 200.25,97.38 200.57,97.05 200.57,96.4 200.14,95.97 196.33,95.97 191.11,90.75 191.11,81.87 194.62,78.36 194.62,74.63 194.86,74.39 194.86,72.21 195.26,71.81 195.26,70.22 194.86,69.81 194.86,68.98 195.27,68.56 195.27,66.82 198.48,63.62 210.06,63.62 210.46,64.02 211.03,64.58 216.49,64.58 218.78,66.88 265.42,66.88 268.03,64.27 278.02,64.27 280.58,61.71 281.88,61.71 285.89,57.7 285.89,55.48 286.77,54.6 286.77,50.75 287.02,50.5 287.18,50.5 287.64,50.04 287.64,49.32 288.38,48.58 290.28,48.58 292.35,46.51 293.91,46.51 294.34,46.08 294.34,45.46 294.2,45.32 294.2,45.04 v2(294.41,44.83)
  BOTTOM w0.076: UH2.U5 294.41,44.7 v2(294.41,44.83)
  BOTTOM w0.089: UG9.BM27 199.74,97.54 v2(199.65,97.54)
CLK_SMB: length 16.7
  TOP w0.14: v1(59.12,31.18) 59.12,30.17 PR8.1
  TOP w0.254: PR8.1 58.83,29.88 58.34,29.88 v2(58.28,29.94)
  BOTTOM w0.14: PBATT1.4 46.86,33.5 46.72,33.36 46.72,32.24 49.16,29.8 58.14,29.8 v2(58.28,29.94)
CLK_TP_SIO: length 189.6
  TOP w0.14: v2(310.57,15.82) 311.89,14.51 313.6,14.51 313.92,14.19 UE1.78 315.76,14.19 316.22,13.73 317.38,13.73 RE24.2
  IN4 w0.137: v2(153.14,33.26) 153.64,33.76 157.95,33.76 159.53,32.18 211.5,32.18 211.84,32.51 249.72,32.51 250.91,31.32 254.2,31.32 255.63,29.9 257.41,29.9 261.71,25.59 264.7,25.59 265.03,25.26 269.38,25.26 270.46,24.17 270.46,23.58 271.37,22.68 273.56,22.68 273.89,23.02 279.68,23.02 280.18,22.51 281.72,22.51 282.85,21.38 293.08,21.38 293.27,21.58 298.46,21.58 298.74,21.3 298.74,21.3 300.15,19.89 304.83,19.89 305.78,18.94 305.78,17.71 307.67,15.82 v2(310.57,15.82)
  BOTTOM w0.14: v2(153.14,33.26) 153.14,32.35 154.15,31.33 154.15,29.81 154.99,28.97 CE10.1 155.49,27.63 ; DE4.4 155.49,27.63 ; 155.49,27.63 152.8,30.32 149.71,30.32 149.45,30.06 JTP.1
CMP_VIN0: length 14.7
  TOP w0.14: UE1.20 300.92,13.79 v2(301.41,14.28)
  BOTTOM w0.14: RE33.1 311.48,17.23 RE73.2 309.86,17.24 306.89,14.28 v1(304.06,14.28) v2(301.41,14.28)
CMP_VOUT0: length 437.9
  TOP w0.089: QG23.3 210,80.84 210.16,80.67 211.11,80.67 211.3,80.48 211.3,80.04 212.51,78.83 v2(212.51,78.19)
  TOP w0.14: UE1.85 313.18,16.99 v2(313.16,16.96) ; v2(81.04,49.27) 80.8,49.27 v1(80.39,49.67) ; RG580.1 212.57,78.13 v2(212.51,78.19)
  TOP w0.254: v2(81.04,49.27) 81.59,48.72 PR315.1
  IN2 w0.097: v2(313.16,16.96) 313.24,16.96 314.47,18.19 314.47,21.46 313.86,22.08 313.86,28.03 311.63,30.25 311.63,36.55 307.92,40.27 307.92,44.47 310.94,47.49 310.94,51.95 306.83,56.07 303.88,56.07 302.38,57.57 298.58,57.57 294.59,61.56 292.58,61.56 291.61,62.54 291.61,62.67 288.83,65.45 284.81,65.45 281.77,68.49 277.36,68.49 277.35,68.49 275.5,68.49 275.18,68.17 264.16,68.17 262.19,70.13 245.47,70.13 244.67,70.93 238.14,70.93 237.34,70.13 226.54,70.13 v2(226.35,70.32)
  IN3 w0.124: v2(313.16,16.96) 311.02,16.96 309.11,15.05 309.11,14.69 305.18,10.76 300.84,10.76 300.64,10.96 292.38,10.96 292.1,10.68 292.1,9.98 291.33,9.21 276.27,9.21 275.34,10.14 272.63,10.14 269.5,13.27 264.18,13.27 254.96,22.49 239.34,22.49 236.93,24.91 226.59,24.91 224.6,22.91 210.06,22.91 208.3,24.68 162.68,24.68 161.05,23.05 140.55,23.05 140.45,23.15 130.29,23.15 128.79,24.65 123.15,24.65 121.42,22.92 116.28,22.92 114.78,24.43 89.97,24.43 v2(88.69,23.14) ; v2(212.51,78.19) 217.53,78.19 222.38,73.34 222.38,72.24 223.44,71.18 224.8,71.18 225.65,70.32 v2(226.35,70.32)
  IN4 w0.137: v2(88.69,23.14) 88.62,23.14 88.11,22.63 82.28,22.63 80.54,24.37 80.54,26.62 82.86,28.93 82.86,32.39 82.17,33.07 82.17,33.45 81.53,34.1 81.53,38.43 82.18,39.08 82.18,40.98 82.86,41.66 82.86,46.03 81.04,47.85 v2(81.04,49.27)
  BOTTOM w0.14: v2(313.16,16.96) 313.04,16.96 RE33.2 RE38.2
CMPIN: length 5.7
  TOP w0.127: v1(28.37,33.63) 28.37,34.42 27.94,34.85 PR27.2
  TOP w0.254: PR732.1 29.56,36.9 28.46,35.8 PR26.1 PR27.2
CMPOUT: length 23.6
  TOP w0.127: v2(29.64,35.4) 29.64,35.17 v1(29.15,34.67)
  TOP w0.254: v2(37.09,48.29) 36.69,47.89 PR30.1 PR29.1 36.22,46.93 PR28.2 ; v2(29.64,35.4) 29.64,36.01 PR733.1
  IN4 w0.254: v2(37.09,48.29) 37.02,48.35 33.2,48.35 33.07,48.48 32.14,48.48 30.87,47.21 30.87,45.72 30.1,44.95 30.1,35.85 v2(29.64,35.4)
CMSRC_CHG:
  vias: v1(35.31,42)
COMP: length 4.3
  TOP w0.203: PU6000.30 155.44,136.34 155.04,135.94 v2(155.04,135.22) 154.75,134.93 PC6008.2
  BOTTOM w0.127: v2(155.04,135.22) 155.27,135.22 v1(155.68,134.81)
  BOTTOM w0.254: PR6017.1 154.9,135.08 v2(155.04,135.22)
COMP_GPU_1: length 2.2
  BOTTOM w0.127: PR6017.2 155.56,135.99 v1(155.68,136.11)
  BOTTOM w0.254: PR6017.2 PC6006.2
CPU_24MHZ_N: length 170.3
  IN2 w0.104: v2(297.77,50.81) 297.78,50.81 298.08,50.5 298.08,50.21 297.9,50.03 297.05,50.03 296.89,50.19 296.89,50.98 295.97,51.9 293.28,51.9 293.07,52.1 290.4,52.1 290.04,52.45 290.04,54.34 284.49,59.89 277.56,59.89 274.78,62.67 262.54,62.67 260.23,64.98 234.76,64.98 231.53,61.75 230.45,61.75 229.71,61.01 226.57,61.01 226.54,60.99 224.6,60.99 224.55,60.94 223.63,60.94 223.58,60.99 221.64,60.99 221.05,61.58 212.68,61.58 212.14,61.03 197.83,61.03 197.48,61.38 194.23,61.38 193.54,62.07 190.86,62.07 190.8,62.13 190.8,62.15 187.11,65.83 187.11,67.55 183.68,70.97 183.68,75.93 180.25,79.36 180.25,84.1 183.18,87.03 183.18,97.37 183.18,97.38 183.18,99.15 182.46,99.86 181.99,99.86 v2(181.79,100.06)
  BOTTOM w0.076: UH1.D31 178.18,100.61 178.1,100.54 178.1,100.43 178.2,100.33 179.9,100.33 180.06,100.5 180.46,100.5 181.31,99.64 181.42,99.64 181.5,99.72 181.5,100.04 181.57,100.12 181.74,100.12 v2(181.79,100.06) ; v2(297.77,50.81) 297.92,50.66 297.92,50.06 297.27,49.42 296.77,49.42 296.69,49.49 296.69,49.61 296.77,49.69 UH2.F1
CPU_24MHZ_P: length 170.3
  IN2 w0.104: v2(181.79,99.48) 181.99,99.67 182.38,99.67 182.98,99.07 182.98,97.3 182.99,97.29 182.99,87.11 180.06,84.18 180.06,79.28 183.49,75.85 183.49,70.89 186.92,67.47 186.92,65.75 190.6,62.07 190.6,62.05 190.78,61.87 193.46,61.87 194.15,61.19 197.4,61.19 197.75,60.84 212.22,60.84 212.76,61.38 220.97,61.38 221.56,60.79 223.5,60.79 223.55,60.74 224.63,60.74 224.68,60.79 226.62,60.79 226.65,60.82 229.79,60.82 230.53,61.56 231.61,61.56 234.84,64.79 260.15,64.79 262.46,62.48 274.7,62.48 277.48,59.7 284.41,59.7 289.85,54.26 289.85,52.37 290.32,51.91 292.99,51.91 293.2,51.7 295.89,51.7 296.7,50.9 296.7,50.11 296.97,49.84 297.98,49.84 298.29,50.14 298.29,50.74 v2(298.36,50.81)
  BOTTOM w0.076: 298.11,50.02 297.34,49.25 296.93,49.25 UH2.G1 ; UH1.E31 177.7,100.6 178.13,100.17 179.97,100.17 180.13,100.33 180.39,100.33 181.25,99.48 v2(181.79,99.48)
  BOTTOM w0.14: 298.11,50.02 298.16,50.07 298.16,50.61 v2(298.36,50.81)
CPU_B+: length 20
  BOTTOM w0.254: 148.44,135.19 147.32,136.31 147.32,144.45 146.18,145.6 138.85,145.6 138.67,145.42 138.67,144.73 PR5005.2
  vias: v2(117.23,131.09) v2(117.16,130.51) v2(117.31,131.68) v2(117.32,123.03) v2(117.32,122.39) v2(117.96,123.03) v2(117.96,122.39) v2(118.77,121.85) v2(118.77,121.04) v2(118.92,130.58) v2(118.92,129.77) v2(119.44,121.85) v2(119.44,121.04) v2(119.59,130.58) v2(119.59,129.77) v2(120.85,112.74) v2(120.85,112.16) v2(120.85,111.57) v2(120.85,110.99) v2(121.43,112.74) v2(121.43,112.16) v2(121.43,111.57) v2(121.43,110.99) v2(122.01,112.74) v2(122.01,112.16) v2(122.01,111.57) v2(122.01,110.99) v2(143.91,127.06) v2(143.91,126.39) v2(144.72,127.06) v2(144.72,126.39) v2(144.79,128.78) v2(145.1,128.25) v2(145.4,128.78) v2(145.71,128.25) v2(146.01,128.81) v2(148.15,134.75) v2(148.15,134.14) v2(148.15,133.53) v2(148.15,132.92) v2(152.5,127.26) v2(152.5,126.58) v2(153.32,127.26) v2(153.32,126.58) v2(153.53,128.88) v2(153.84,128.3) v2(154.14,128.88) v2(154.45,128.3) v2(154.75,128.91) v2(161.18,127.26) v2(161.18,126.58) v2(161.99,127.26) v2(161.99,126.58) v2(162.47,129.11) v2(162.47,128.5) v2(162.93,128.1) v2(163.39,127.54) v2(171.11,125.81) v2(171.11,125.22) v2(171.57,124.84) v2(173.44,126.22) v2(173.44,125.61) v4(172.37,125.67)
CPU_DDI1_N0: length 225.5
  IN5 w0.104: v2(356.78,45.81) 356.87,45.81 357.06,45.62 357.06,45.54 356.9,45.38 356.41,45.38 355.73,46.06 354.43,46.06 354.06,45.68 352.65,45.68 351.46,46.88 338.08,46.88 336.51,45.31 326.55,45.31 326.02,45.84 325.99,45.84 323.92,47.91 316.28,47.91 309.67,54.52 307.86,54.52 305.22,57.17 301.84,57.17 301.03,57.98 299.34,57.98 293.24,64.07 289.66,64.07 288.14,65.6 272.68,65.6 267.22,71.06 251.75,71.06 250.86,71.94 224.04,71.94 223.53,71.44 206.06,71.44 205.8,71.18 201.69,71.18 197.13,75.73 197.13,76.99 192.27,81.86 192.27,85.84 190.74,87.37 190.74,99.14 183.16,106.71 182.65,106.71 181.11,108.24 178.87,108.24 176.74,106.11 176.74,104.71 175.42,103.39 175.32,103.39 174.92,103.78 v2(174.92,103.79)
  BOTTOM w0.076: v2(174.92,103.79) 174.55,104.16 UH1.K37
  BOTTOM w0.14: v2(356.78,45.81) 357.12,46.15 357.12,46.71 CT7.1
CPU_DDI1_N1: length 228.6
  IN5 w0.104: v2(175.73,101.83) 176.11,102.21 176.11,102.8 178.02,104.71 178.9,104.71 179.38,104.23 181.08,104.23 188.14,97.18 188.14,83.74 188.44,83.44 188.44,79.8 193.65,74.59 193.65,74.01 194.28,73.37 194.28,71.9 198.1,68.08 211.54,68.08 213.04,66.58 214.29,66.58 215.69,67.99 226.78,67.99 227.55,68.76 229.84,68.76 230.39,68.21 266.39,68.21 272.14,62.46 287.55,62.46 288.54,61.47 290.4,61.47 291.27,60.61 293.03,60.61 298.3,55.33 299.89,55.33 300.88,54.34 300.89,54.34 300.9,54.33 304.19,54.33 305.09,53.43 305.09,53.43 306.6,51.92 307.72,51.92 314.56,45.08 314.57,45.08 314.66,44.99 320.14,44.99 325.38,39.75 327.51,39.75 327.89,40.13 328.8,40.13 329.18,39.75 337.48,39.75 337.63,39.9 342.95,39.9 342.95,39.9 343.43,39.9 343.43,39.9 344.67,39.9 345.58,40.82 346.89,40.82 349.99,43.91 356.36,43.91 356.64,44.19 v2(356.91,44.19)
  BOTTOM w0.076: UH1.J34 175.71,101.83 v2(175.73,101.83)
  BOTTOM w0.14: CT9.1 355.83,45.44 355.97,45.3 355.97,44.62 356.3,44.29 356.81,44.29 v2(356.91,44.19)
CPU_DDI1_N2: length 227.2
  IN5 w0.104: v2(355.52,44.77) 355.42,44.88 355.42,45.24 355.2,45.45 354.74,45.45 354.12,44.83 350.1,44.83 349.38,45.55 343.88,45.55 343.44,45.12 342.31,45.12 341.16,43.97 337.46,43.97 336.06,42.57 327.38,42.57 324.83,45.13 323.82,45.13 323.62,44.93 322.3,44.93 320.65,46.57 315.82,46.57 309.08,53.32 307.18,53.32 305.67,54.83 305.67,54.83 304.63,55.86 303.89,55.86 303.87,55.88 301.4,55.88 300.86,56.42 300.86,56.42 300.51,56.77 298.84,56.77 293.61,62 291.85,62 290.98,62.87 289.16,62.87 288.17,63.86 272.72,63.86 266.76,69.81 257.18,69.81 257.16,69.81 256.51,69.81 250.98,69.81 250.57,70.23 227.04,70.23 226.31,69.49 198.67,69.49 196.86,71.3 196.86,73.35 195.89,74.32 195.89,75.23 189.83,81.28 189.83,84.02 189.53,84.32 189.53,98.64 183.39,104.78 182.55,104.78 181.95,105.37 181.95,105.67 180.59,107.04 v2(179.93,107.04)
  BOTTOM w0.076: UH1.H36 176,103.63 175.83,103.63 175.64,103.83 175.64,104.36 176.02,104.74 176.02,106.4 176.97,107.34 178.64,107.34 178.96,107.03 179.92,107.03 v2(179.93,107.04)
  BOTTOM w0.14: v2(355.52,44.77) 355.39,44.91 355.39,45.94 355.07,46.26 355.07,46.6 CT23.1
CPU_DDI1_N3: length 224
  IN5 w0.104: v2(353.92,46.13) 353.73,46.33 353.73,46.54 353.31,46.96 352.67,46.96 351.39,48.24 351.39,48.62 350.63,49.38 347.54,49.38 346.15,47.99 339.35,47.99 338.99,48.36 338.03,48.36 336.32,46.64 331.9,46.64 331.71,46.45 326.24,46.45 324.11,48.58 317.49,48.58 310.94,55.13 308.11,55.13 305.4,57.84 302.03,57.84 301.3,58.56 301.3,58.56 301.28,58.58 299.59,58.58 293.45,64.71 291.71,64.71 289.97,66.45 272.68,66.45 267.41,71.72 252.01,71.72 251.19,72.55 223.69,72.55 223.42,72.28 217.67,72.28 217.32,72.63 206.93,72.63 206.59,72.3 201.85,72.3 200.6,73.55 200.6,74.67 199.18,76.1 198.02,76.1 197.77,76.36 197.77,77.48 196.34,78.91 196.34,85.91 195.23,87.02 194.86,87.02 191.34,90.54 191.34,100.24 186.3,105.29 186.3,106.81 184.11,109 178.78,109 176.12,106.34 176.12,105.2 175.78,104.87 175.63,104.87 175.55,104.95 v2(175.55,105.31)
  BOTTOM w0.076: UH1.J38 175.59,105.28 v2(175.55,105.31)
  BOTTOM w0.14: v2(353.92,46.13) 353.73,46.32 353.73,46.54 CT24.1
CPU_DDI1_P0: length 225.5
  IN5 w0.104: v2(357.42,45.81) 357.25,45.64 357.25,45.46 356.98,45.19 356.33,45.19 355.65,45.86 354.51,45.86 354.14,45.49 352.57,45.49 351.38,46.68 338.16,46.68 336.59,45.11 326.47,45.11 325.94,45.65 325.91,45.65 323.84,47.72 316.2,47.72 309.59,54.33 307.78,54.33 305.14,56.97 301.76,56.97 300.95,57.78 299.26,57.78 293.16,63.88 289.58,63.88 288.06,65.41 272.6,65.41 267.14,70.87 251.67,70.87 250.78,71.75 224.12,71.75 223.61,71.24 206.14,71.24 205.88,70.98 201.61,70.98 196.94,75.65 196.94,76.91 192.07,81.78 192.07,85.76 190.54,87.29 190.54,99.06 183.08,106.52 182.57,106.52 181.03,108.05 178.95,108.05 176.94,106.03 176.94,104.63 175.5,103.2 v2(174.93,103.2)
  BOTTOM w0.076: UH1.K36 174.86,103.2 v2(174.93,103.2)
  BOTTOM w0.14: CT6.1 357.47,46.47 357.47,46.45 357.42,46.4 v2(357.42,45.81)
CPU_DDI1_P1: length 228.6
  IN5 w0.104: v2(356.91,44.78) 356.86,44.73 356.63,44.73 356.5,44.6 356.5,44.32 356.28,44.1 349.91,44.1 346.81,41.01 345.5,41.01 344.59,40.1 343.35,40.1 337.55,40.1 337.4,39.94 329.26,39.94 328.88,40.33 327.81,40.33 327.43,39.94 325.46,39.94 320.22,45.18 314.74,45.18 314.65,45.28 314.64,45.28 307.8,52.12 306.68,52.12 305.17,53.62 305.17,53.62 304.27,54.52 300.98,54.52 299.98,55.53 298.38,55.53 293.11,60.8 291.35,60.8 290.48,61.67 288.62,61.67 287.63,62.65 272.22,62.65 266.47,68.4 230.47,68.4 229.92,68.95 227.47,68.95 226.7,68.18 215.61,68.18 214.21,66.78 213.12,66.78 211.62,68.28 198.18,68.28 194.48,71.98 194.48,73.45 193.84,74.09 193.84,74.67 188.63,79.88 188.63,83.52 188.33,83.82 188.33,97.26 181.16,104.42 179.46,104.42 178.98,104.91 177.94,104.91 175.92,102.88 175.92,102.6 175.84,102.52 v2(175.68,102.52)
  BOTTOM w0.076: UH1.J35 175.25,102.78 175.25,102.63 175.36,102.52 v2(175.68,102.52)
  BOTTOM w0.14: CT8.1 356.46,46.38 356.37,46.29 356.22,46.29 356.08,46.15 356.08,45.55 356.27,45.36 356.27,44.74 356.46,44.56 356.69,44.56 v2(356.91,44.78)
CPU_DDI1_P2: length 227.2
  IN5 w0.104: v2(354.94,44.77) 354.95,44.77 355.23,45.05 355.23,45.16 355.12,45.26 354.82,45.26 354.2,44.64 350.02,44.64 349.3,45.36 343.96,45.36 343.52,44.92 342.39,44.92 341.24,43.78 337.54,43.78 336.14,42.38 327.3,42.38 324.75,44.94 323.9,44.94 323.7,44.73 322.22,44.73 320.57,46.38 315.74,46.38 309,53.13 307.1,53.13 305.59,54.64 305.59,54.64 304.55,55.67 303.81,55.67 303.79,55.68 301.32,55.68 300.67,56.34 300.43,56.58 298.76,56.58 293.53,61.81 291.77,61.81 290.9,62.68 289.08,62.68 288.09,63.67 272.64,63.67 266.68,69.62 257.21,69.62 257.17,69.62 256.51,69.62 250.9,69.62 250.49,70.03 227.12,70.03 226.39,69.3 198.59,69.3 196.67,71.22 196.67,73.27 195.69,74.24 195.69,75.15 189.64,81.2 189.64,83.94 189.34,84.24 189.34,98.56 183.31,104.59 182.47,104.59 181.76,105.29 181.76,105.59 180.51,106.85 180.34,106.85 180.25,106.75 180.25,106.56 180.14,106.45 v2(179.93,106.45)
  BOTTOM w0.076: v2(179.93,106.45) 179.87,106.45 179.68,106.64 179.68,106.75 179.57,106.86 178.89,106.86 178.58,107.18 177.04,107.18 176.19,106.33 176.19,104.68 175.81,104.3 175.81,103.89 175.9,103.8 176.04,103.8 176.12,103.88 UH1.H37
  BOTTOM w0.14: CT10.1 354.76,46.52 354.76,46.13 355.08,45.81 355.08,44.91 v2(354.94,44.77)
CPU_DDI1_P3: length 223.9
  IN5 w0.104: v2(353.29,46.13) 353.35,46.13 353.53,46.31 353.53,46.46 353.23,46.76 352.59,46.76 351.19,48.16 351.19,48.54 350.55,49.19 347.62,49.19 346.23,47.79 339.27,47.79 338.91,48.16 338.11,48.16 336.4,46.44 331.98,46.44 331.79,46.25 326.16,46.25 324.03,48.38 317.41,48.38 310.86,54.93 308.03,54.93 305.32,57.64 301.95,57.64 301.22,58.37 301.22,58.37 301.2,58.38 299.51,58.38 293.37,64.52 291.63,64.52 289.89,66.26 272.6,66.26 267.33,71.53 251.93,71.53 251.11,72.35 223.77,72.35 223.5,72.09 217.59,72.09 217.24,72.44 207.01,72.44 206.67,72.11 201.77,72.11 200.41,73.47 200.41,74.59 199.1,75.91 197.94,75.91 197.57,76.28 197.57,77.4 196.14,78.83 196.14,85.83 195.15,86.83 194.78,86.83 191.15,90.46 191.15,100.16 186.96,104.35 186.1,105.21 186.1,106.73 184.03,108.8 178.86,108.8 176.31,106.26 176.31,105.12 175.86,104.68 175.17,104.68 v2(175,104.5)
  BOTTOM w0.076: UH1.J37 v2(175,104.5)
  BOTTOM w0.14: CT11.1 353.43,46.59 353.43,46.27 v2(353.29,46.13)
CPU_DDI1HPD: length 87.1
  TOP w0.14: v2(360.94,50.04) 361.67,50.04 v1(362.04,50.41)
  IN1 w0.097: v2(349.9,37.62) 348.65,38.87 348.65,42.87 349.54,43.76 349.54,46.6 350.79,47.85 358.22,47.85 358.46,48.09 358.46,48.19 360.27,50 360.9,50 v2(360.94,50.04)
  IN3 w0.124: v2(342.93,38.52) 344.91,38.52 345.4,38.03 347.28,38.03 347.51,38.26 349.27,38.26 v2(349.9,37.62)
  IN4 w0.137: v2(342.93,38.52) 342.73,38.52 340.56,36.35 337.49,36.35 336.34,37.5 328.02,37.5 327.25,36.73 318.55,36.73 317.84,36.02 307.71,36.02 305.26,33.56 302.39,33.56 301.63,32.8 300.38,32.8 299.98,32.41 296.77,32.41 296.1,33.07 295.57,33.07 295.21,32.72 v2(295.21,32.35)
  BOTTOM w0.076: 361.23,50.04 v2(360.94,50.04) 360.63,50.04 360.55,50.12 360.19,50.12 360.04,50.27 359.63,50.27 UT1.AA2 ; v2(295.21,32.35) 295.21,32.82 UH2.AW4
  BOTTOM w0.14: 361.23,50.04 361.44,50.04 RT38.1
CPU_DDI2_N0: length 235.3
  IN5 w0.104: v2(176.51,101.25) 176.54,101.24 177.23,101.24 178.62,99.85 180.81,99.85 181.06,99.6 181.06,99.39 182.19,98.26 182.19,96.25 184.73,93.71 184.73,75.3 184.34,74.91 184.34,70.35 190.15,64.54 192.49,64.54 193.54,63.49 197.23,63.49 198.12,62.6 210.36,62.6 210.5,62.74 217.73,62.74 218.69,63.69 219.4,63.69 219.86,64.15 224.31,64.15 224.77,64.61 227.41,64.61 228.1,65.3 265.31,65.3 270.99,59.62 284.18,59.62 285.31,58.49 289.4,58.49 290.1,57.79 291.86,57.79 297.17,52.48 298.59,52.48 298.68,52.39 298.68,52.39 299.51,51.56 299.51,51.56 299.72,51.35 299.72,48.17 304.58,43.3 304.58,41.68 311.86,34.4 316.37,34.4 319.1,31.68 325.36,31.68 327.39,33.71 344.5,33.71 350.94,40.15 350.94,40.54 v2(351.07,40.67)
  BOTTOM w0.076: v2(176.51,101.25) 176.44,101.25 UH1.H33
  BOTTOM w0.14: v2(351.07,40.67) 350.86,40.87 350.86,43.64 352.46,45.24 352.46,46.54 CT28.1
CPU_DDI2_N1: length 219.6
  IN5 w0.104: v2(178.25,106.77) 178.3,106.71 178.93,106.71 179.11,106.88 179.11,107.19 179.55,107.64 180.86,107.64 182.4,106.11 182.91,106.11 190.14,98.89 190.14,84.59 191.11,83.62 191.11,82.16 196.5,76.78 196.5,74.57 197.47,73.6 197.47,71.62 198.52,70.56 206.19,70.56 206.46,70.83 223.78,70.83 224.29,71.34 250.61,71.34 251.5,70.45 266.98,70.45 272.95,64.48 288.41,64.48 289.41,63.47 292.99,63.47 299.09,57.37 300.78,57.37 301.63,56.52 301.64,56.52 301.67,56.49 304.86,56.49 307.43,53.92 309.38,53.92 316,47.31 323.6,47.31 326.24,44.67 327.57,44.67 328.91,43.34 330.81,43.34 331.57,44.1 336.18,44.1 338.34,46.26 350.91,46.26 351.12,46.04 v2(351.12,45.35)
  BOTTOM w0.076: v2(178.25,106.77) 178.04,106.56 177.82,106.56 177.72,106.45 177.16,106.45 176.92,106.22 176.92,104.69 176.91,104.69 176.91,104.66 176.87,104.63 176.8,104.6 176.7,104.64 UH1.G38
  BOTTOM w0.14: v2(351.12,45.35) 350.97,45.51 350.97,45.78 351.32,46.13 351.32,46.66 CT30.1
CPU_DDI2_N2: length 230.3
  IN5 w0.104: v2(176.52,102.52) 176.68,102.52 176.79,102.62 176.79,102.64 176.8,102.65 176.8,102.89 177.79,103.88 178.23,103.88 178.23,103.88 178.74,103.88 178.87,103.75 180.99,103.75 187.58,97.15 187.58,80.07 189.27,78.38 189.27,78.34 193.19,74.42 193.19,71.74 194.6,70.32 194.6,69.16 195.25,68.51 196.75,68.51 197.6,67.66 211.25,67.66 213.14,65.77 214.74,65.77 216.55,67.58 226.95,67.58 227.17,67.8 266.21,67.8 271.96,62.05 286.38,62.05 287.36,61.06 290.23,61.06 291.1,60.2 292.86,60.2 298.17,54.89 299.61,54.89 300.58,53.92 303.86,53.92 305.92,51.86 305.92,51.28 306.11,51.09 306.11,45.75 307.89,43.97 307.89,41.78 311.7,37.96 316.82,37.96 318.05,36.73 319.67,36.73 320.37,36.03 327.42,36.03 327.95,35.5 336.28,35.5 336.82,36.03 345.7,36.03 349.7,40.03 349.7,42.6 349.58,42.73 v2(349.48,42.73)
  BOTTOM w0.076: v2(176.52,102.52) 176.56,102.52 UH1.F35
  BOTTOM w0.14: v2(349.48,42.73) 349.48,42.83 349.62,42.97 349.62,46.59 CT32.1
CPU_DDI2_N3: length 216.8
  IN5 w0.104: v2(348.91,44.87) 348.73,44.7 348.73,44.12 348.51,43.9 343.15,43.9 342.75,43.51 342.75,42.84 341.21,41.3 340.73,41.3 340.73,41.3 331.02,41.3 330.83,41.11 326.03,41.11 323.01,44.13 321.97,44.13 320.42,45.68 314.81,45.68 307.97,52.52 306.85,52.52 305.34,54.03 305.34,54.03 304.3,55.07 301.09,55.07 300.2,55.96 298.53,55.96 293.28,61.21 291.52,61.21 290.65,62.08 288.84,62.08 287.84,63.07 272.39,63.07 266.47,68.99 250.66,68.99 250.21,69.43 227.37,69.43 226.64,68.69 198.34,68.69 195.05,71.99 195.05,73.56 194.28,74.33 194.28,75.64 189.04,80.89 189.04,83.69 188.74,83.99 188.74,98.31 183.06,103.99 182.21,103.99 181.16,105.03 181.16,105.3 181.09,105.37 v2(180.66,105.37)
  BOTTOM w0.076: UH1.E36 177.69,103.77 177.97,104.05 177.97,104.28 177.88,104.38 177.88,105.29 178.25,105.66 178.46,105.66 178.65,105.84 178.89,105.84 179.37,105.37 v2(180.66,105.37)
  BOTTOM w0.14: CT34.1 348.69,46.57 348.69,45.09 v2(348.91,44.87)
CPU_DDI2_P0: length 235.3
  IN5 w0.104: v2(350.43,40.73) 350.43,40.73 350.75,40.41 350.75,40.23 344.42,33.9 327.31,33.9 325.28,31.87 319.18,31.87 316.45,34.6 311.94,34.6 304.77,41.76 304.77,43.38 299.91,48.25 299.91,51.43 299.7,51.64 299.7,51.64 298.76,52.58 298.76,52.58 298.67,52.67 297.25,52.67 291.94,57.98 290.18,57.98 289.48,58.68 285.39,58.68 284.26,59.81 271.07,59.81 265.39,65.49 228.02,65.49 227.33,64.8 224.69,64.8 224.23,64.34 219.78,64.34 219.32,63.88 218.61,63.88 217.65,62.93 210.42,62.93 210.28,62.79 198.2,62.79 197.31,63.68 193.62,63.68 192.57,64.73 190.23,64.73 184.53,70.43 184.53,74.83 184.93,75.22 184.93,93.79 182.39,96.33 182.39,98.34 181.26,99.47 181.26,99.68 180.89,100.04 178.7,100.04 177.31,101.44 176.89,101.44 176.63,101.7 176.63,101.8 v2(176.54,101.91)
  BOTTOM w0.076: UH1.H34 176.43,101.9 176.54,101.9 v2(176.54,101.91)
  BOTTOM w0.14: v2(350.43,40.73) 350.56,40.86 350.56,43.77 352.16,45.37 v3(352.16,45.81) 352.16,46.59 CT27.1
CPU_DDI2_P1: length 219.5
  IN5 w0.104: v2(178.25,106.18) 178.58,106.52 179.01,106.52 179.3,106.8 179.3,107.11 179.63,107.45 180.78,107.45 182.32,105.91 182.83,105.91 189.94,98.81 189.94,84.51 190.92,83.54 190.92,82.08 196.3,76.7 196.3,74.49 197.27,73.52 197.27,71.54 198.44,70.37 206.27,70.37 206.54,70.64 223.86,70.64 224.37,71.15 250.53,71.15 251.42,70.26 266.9,70.26 272.87,64.29 288.33,64.29 289.33,63.28 292.91,63.28 299.01,57.18 300.7,57.18 301.5,56.38 301.58,56.29 304.78,56.29 307.35,53.73 309.3,53.73 315.92,47.12 323.52,47.12 326.16,44.48 327.49,44.48 328.83,43.14 330.89,43.14 331.65,43.9 336.26,43.9 338.42,46.07 350.83,46.07 350.93,45.96 350.93,45.78 350.53,45.39 v2(350.53,45.35)
  BOTTOM w0.076: v2(178.25,106.18) 178.04,106.39 177.89,106.39 177.79,106.29 177.22,106.29 177.08,106.15 177.08,104.62 177.08,104.62 177.08,104.59 176.97,104.49 176.87,104.44 176.83,104.34 UH1.F37
  BOTTOM w0.14: CT29.1 351.01,46.47 351.01,46.25 350.64,45.87 350.64,45.46 v2(350.53,45.35)
CPU_DDI2_P2: length 230.2
  IN5 w0.104: v2(177.25,102.54) 177.09,102.54 176.99,102.65 176.99,102.81 177.87,103.69 178.15,103.69 178.15,103.68 178.66,103.68 178.79,103.56 180.91,103.56 187.39,97.07 187.39,79.99 189.07,78.31 189.07,78.26 193,74.34 193,74.33 193,71.66 194.41,70.24 194.41,69.08 195.17,68.32 196.67,68.32 197.52,67.47 211.17,67.47 213.06,65.57 214.82,65.57 216.63,67.38 227.03,67.38 227.25,67.61 266.13,67.61 271.88,61.86 286.3,61.86 287.28,60.87 290.15,60.87 291.02,60 292.78,60 298.09,54.69 299.53,54.69 300.5,53.73 303.78,53.73 305.73,51.78 305.73,51.2 305.91,51.01 305.91,45.67 307.69,43.89 307.69,41.7 311.62,37.77 316.74,37.77 317.97,36.54 319.59,36.54 320.29,35.84 327.34,35.84 327.87,35.31 336.36,35.31 336.9,35.84 345.78,35.84 349.9,39.95 349.9,42.61 v2(350.11,42.83)
  BOTTOM w0.076: v2(177.25,102.54) 176.93,102.21 UH1.F34
  BOTTOM w0.14: CT31.1 349.92,46.54 v3(349.92,45.77) 349.92,43.02 v2(350.11,42.83)
CPU_DDI2_P3: length 216.7
  IN5 w0.104: v2(180.66,105.95) 180.66,105.94 181.04,105.56 181.17,105.56 181.35,105.38 181.35,105.11 182.29,104.18 183.14,104.18 188.93,98.39 188.93,84.07 189.23,83.77 189.23,80.97 194.48,75.72 194.48,74.41 195.24,73.64 195.24,72.07 198.42,68.89 226.56,68.89 227.29,69.62 250.29,69.62 250.74,69.18 266.55,69.18 272.47,63.26 287.92,63.26 288.92,62.27 290.73,62.27 291.6,61.4 293.36,61.4 298.61,56.15 300.28,56.15 301.17,55.26 304.38,55.26 305.42,54.23 305.42,54.23 306.93,52.72 308.05,52.72 314.89,45.88 320.5,45.88 322.05,44.32 323.09,44.32 326.11,41.3 330.75,41.3 330.94,41.49 340.81,41.49 340.81,41.49 341.13,41.49 342.56,42.92 342.56,43.59 343.07,44.1 348.43,44.1 348.54,44.2 348.54,44.7 348.37,44.87 v2(348.27,44.87)
  BOTTOM w0.076: UH1.E37 177.71,104.18 177.71,105.36 178.18,105.83 178.39,105.83 178.58,106.01 178.96,106.01 179.44,105.53 180.18,105.53 180.25,105.61 180.25,106 180.35,106.1 180.51,106.1 v2(180.66,105.95)
  BOTTOM w0.14: CT33.1 348.43,46.5 348.43,45.03 v2(348.27,44.87)
CPU_DDI2HPD: length 87
  TOP w0.14: v2(357.1,50.62) 357.71,50 RT39.1 ; v1(348.82,37.51) 349.15,37.18 v2(349.48,37.18)
  IN1 w0.097: v2(349.48,37.18) 347.68,38.97 347.68,46.25 347.13,46.8 347.13,47.59 348.9,49.36 355.84,49.36 v2(357.1,50.62)
  IN4 w0.137: v2(349.48,37.18) 349.48,36.54 349.12,36.19 346.11,36.19 344.07,34.14 329.27,34.14 328.43,33.3 323.74,33.3 322.54,32.11 315.85,32.11 314.2,33.76 312.27,33.76 311.94,33.43 308.24,33.43 305.73,30.92 305.73,30.7 305.51,30.48 305.26,30.23 299.78,30.23 v2(298.58,29.02)
  BOTTOM w0.076: UH2.AY2 296.53,33.02 296.88,33.02 296.89,33.01 297.22,33.01 298.04,32.18 298.04,30.32 298.11,30.25
  BOTTOM w0.14: v2(357.1,50.62) UT1.Y6 ; 298.11,30.25 298.58,29.78 v2(298.58,29.02)
