# Allegro board Dell_Inspiron_15_7577_Compal_CKA50_CKF50_LA_E992P_Rev_1_0_BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FBA_EDC0: length 21.6
  IN2 w0.112: 228.53,128.46 228.53,128.39
  IN2 w0.145: 228.53,128.39 228.53,127.78 225.47,124.72 225.47,114.73 226.05,114.15 226.05,113.25 v2(225.65,112.85) ; 228.53,128.46 228.53,131.17 v2(228.13,131.58)
  BOTTOM w0.089: UG1.R2 v2(228.13,131.58)
  BOTTOM w0.17: v2(225.65,112.85) UG9.R48
FBA_EDC1: length 21
  IN2 w0.102: v2(220.13,130.78) 219.74,130.4 219.74,127.99 219.66,127.91
  IN2 w0.145: v2(223.54,112.85) 223.52,112.85 223.15,113.22 222.7,113.22 222.29,113.63 222.29,114.33 221.15,115.48 221.15,122.58 219.66,124.06 219.66,127.91
  BOTTOM w0.089: UG1.R13 v2(220.13,130.78)
  BOTTOM w0.178: v2(223.54,112.85) 223.83,112.55 UG9.V48
FBA_EDC2: length 36.2
  IN2 w0.145: v2(218.55,110.05) 218.11,110.49 218.11,114.56 216.76,115.92 216.76,120.5 215.56,121.69 215.56,138.84 216.66,139.94 217.74,139.94 217.76,139.97 219.72,139.97 v2(220.12,140.38)
  BOTTOM w0.089: v2(220.12,140.38) 219.73,140.78 UG1.C13
  BOTTOM w0.102: UG9.AF44 v2(218.55,110.05)
FBA_EDC3: length 42.2
  IN2 w0.096: 217.84,127.92 217.84,127.91
  IN2 w0.145: v2(221.4,112.86) 221.84,113.3 221.84,114.21 220.52,115.53 220.52,122.07 218.64,123.95 218.64,127.12 217.84,127.91 ; v2(228.13,140.38) 228.52,140.78 229.11,140.78 229.33,140.55 229.33,137.25 228.87,136.78 226.84,136.78 226.37,136.32 221.99,136.32 221.65,135.98 218.86,135.98 217.84,134.96 217.84,134.05 217.83,134.04 217.83,133.72 217.84,133.71 217.84,133.46 217.83,133.46 217.83,133.13 217.84,133.13 217.84,127.92
  BOTTOM w0.089: UG1.C2 v2(228.13,140.38)
  BOTTOM w0.178: UG9.AA48 221.71,112.55 v2(221.4,112.86)
FBA_EDC4: length 20.2
  IN2 w0.145: v2(206.25,115.53) 206.13,115.41 205.36,115.41 200.44,120.33 200.44,129.12 201.06,129.74 201.06,130.38 v2(201.46,130.78)
  BOTTOM w0.089: v2(201.46,130.78) 201.06,131.18 UG2.C2
  BOTTOM w0.102: UG9.BB52 206.93,115.47 206.31,115.47 v2(206.25,115.53)
FBA_EDC5: length 22.8
  IN2 w0.145: v2(206.95,117.83) 207.3,118.19 207.3,120.68 206.82,121.16 206.82,129.79 207.41,130.38 209.06,130.38 v2(209.46,130.78)
  BOTTOM w0.089: UG2.C13 v2(209.46,130.78)
  BOTTOM w0.102: 210.9,114.85 210.9,114.45 211.25,114.1 UG9.AT50
  BOTTOM w0.178: 210.9,114.85 210.68,115.07 210.68,116.17 209.72,117.12
  BOTTOM w0.213: 209.72,117.12 209.59,117.25 207.53,117.25 v2(206.95,117.83)
FBA_EDC6: length 33.9
  IN2 w0.145: v2(209.46,141.18) 209.87,140.77 213.24,140.77 214.14,139.87 214.14,121.46 214.16,121.44 214.16,121.19 214.29,121.06 214.29,115.47 215.45,114.31 215.45,113.23 v2(215.11,112.88)
  BOTTOM w0.089: UG2.R13 209.86,140.78 v2(209.46,141.18)
  BOTTOM w0.178: v2(215.11,112.88) 215.44,112.55 UG9.AK48
FBA_EDC7: length 34.6
  IN2 w0.145: v2(211.96,117.02) 211.57,117.42 211.57,117.79 211.59,117.81 211.59,119.44 211.56,119.47 211.56,132.99 211.45,133.1 211.45,135.06 210.53,135.98 207.87,135.98 207.27,136.58 206.12,136.58 205.27,137.44 205.27,138.9 204.19,139.98 201.86,139.98 v2(201.46,140.38)
  BOTTOM w0.089: UG2.R2 v2(201.46,140.38)
  BOTTOM w0.142: UG9.AR51 211.95,114.84 212.29,115.18 212.29,116.11 212.31,116.13 212.31,116.67 v2(211.96,117.02)
FBA_WCK01: length 25.9
  IN2 w0.119: v2(224.85,110.15) 224.67,109.97 224.34,109.97 224.17,110.13 224.17,115.26 222.94,116.49 222.94,124.66 224.89,126.6 224.89,129.72 226.33,131.17 226.91,131.17 v2(227.32,131.58)
  BOTTOM w0.089: UG1.P4 226.93,131.97 v2(227.32,131.58)
  BOTTOM w0.119: UG9.U45 v2(224.85,110.15)
FBA_WCK01#: length 25.9
  IN2 w0.119: v2(226.53,131.58) 226.45,131.58 224.68,129.81 224.68,126.69 222.74,124.74 222.74,116.4 223.96,115.18 223.96,110.05 224.25,109.76 224.72,109.76 224.85,109.63 v2(224.85,109.45)
  BOTTOM w0.089: UG1.P5 226.13,131.98 v2(226.53,131.58)
  BOTTOM w0.119: UG9.U44 v2(224.85,109.45)
FBA_WCK23: length 40.4
  IN2 w0.119: v2(220.65,110.15) 220.49,109.99 220.29,109.99 220.14,110.15 220.14,114.24 219.07,115.31 219.07,120 216.54,122.53 216.54,135.99 217.86,137.31 223.29,137.31 225.16,139.18 226.13,139.18 v2(226.53,139.58)
  BOTTOM w0.089: UG1.D4 v2(226.53,139.58)
  BOTTOM w0.119: UG9.AC45 v2(220.65,110.15)
FBA_WCK23#: length 40.4
  IN2 w0.119: v2(220.65,109.45) 220.65,109.66 220.52,109.79 220.21,109.79 219.93,110.06 219.93,114.15 218.86,115.23 218.86,119.92 216.33,122.44 216.33,136.08 217.77,137.52 223.2,137.52 225.07,139.39 225.54,139.39 v2(225.73,139.58)
  BOTTOM w0.089: UG1.D5 v2(225.73,139.58)
  BOTTOM w0.119: UG9.AC44 v2(220.65,109.45)
FBA_WCK45: length 29.8
  IN2 w0.119: v2(210.15,111.55) 210.03,111.43 209.82,111.43 209.54,111.71 209.54,116.02 209.04,116.51 206.07,116.51 205.99,116.51 205.32,117.18 205.32,117.38 205.1,117.61 205.1,118.19 204.76,118.52 204.76,118.94 202.72,120.99 202.72,128.71 204.03,130.02 204.03,132.52 203.63,132.92 202.9,132.92 202.35,132.36 v2(202.35,132.36)
  BOTTOM w0.089: v2(202.35,132.36) 202.35,132.28 UG2.D4
  BOTTOM w0.119: UG9.AV47 v2(210.15,111.55)
FBA_WCK45#: length 29.9
  IN2 w0.119: v2(203.05,132.26) 202.88,132.44 202.88,132.6 202.99,132.71 203.55,132.71 203.82,132.43 203.82,130.11 202.51,128.79 202.51,120.9 204.55,118.85 204.55,118.44 204.89,118.1 204.89,117.52 205.11,117.3 205.11,117.09 205.9,116.31 206.16,116.31 208.95,116.31 209.33,115.93 209.33,111.62 209.73,111.22 209.97,111.22 210.16,111.03 210.16,110.84 v2(210.16,110.84)
  BOTTOM w0.089: v2(203.05,132.26) 203.05,132.1 203.18,131.98 UG2.D5
  BOTTOM w0.119: v2(210.16,110.84) 210.16,111.02 210.03,111.15 UG9.AV46
FBA_WCK67: length 40
  IN2 w0.119: v2(212.25,110.15) 212.07,109.97 211.95,109.97 211.72,110.2 211.72,114.5 212.76,115.53 212.76,115.53 212.89,115.66 212.89,117.88 212.59,118.18 212.59,134.83 210.11,137.31 207.19,137.31 206.43,138.07 206.43,138.89 204.13,141.19 203.72,141.19 203.41,140.91 203.39,140.66 v2(203.12,140.43)
  BOTTOM w0.089: UG2.P4 202.67,139.98 v2(203.12,140.43)
  BOTTOM w0.119: UG9.AR45 v2(212.25,110.15)
FBA_WCK67#: length 40
  IN2 w0.119: v2(212.25,109.45) 212.25,109.63 212.12,109.76 211.86,109.76 211.52,110.11 211.52,114.59 212.67,115.74 212.68,115.74 212.68,115.75 212.68,117.8 212.38,118.1 212.38,134.75 210.02,137.1 207.1,137.1 206.22,137.98 206.22,138.8 204.05,140.98 203.8,140.98 203.61,140.81 203.6,140.66 v2(203.85,140.37)
  BOTTOM w0.089: v2(203.85,140.37) 203.58,140.37 203.46,140.24 UG2.P5
  BOTTOM w0.119: UG9.AR44 212.12,109.75 212.25,109.62 v2(212.25,109.45)
FBB_CLK0: length 42.1
  TOP w0.137: RG113.1 257.12,121.48 257.12,120.88 v2(256.97,120.74)
  IN5 w0.102: 257.05,120.65 257.15,120.56 257.15,119.6 258.23,118.52 258.23,118.17 v2(258.03,117.97)
  IN5 w0.114: 237.92,111.34 235.44,108.87 235.44,108.86 235.42,108.85 234.6,108.03 231.17,108.03 v2(230.55,108.65)
  IN5 w0.119: 257.05,120.65 v2(256.97,120.74) 257.1,120.86 257.1,121.33 256.86,121.56 251.24,121.56 251.12,121.44 251.12,120.28 250.88,120.04 250.35,120.04 250.11,120.28 250.11,121.44 249.99,121.56 249.41,121.56 249.28,121.44 249.28,120.35 248.97,120.04 246.61,120.04 237.92,111.34
  BOTTOM w0.119: UG3.J12 v2(258.03,117.97) ; UG9.H42 v2(230.55,108.65)
FBB_CLK0#: length 42
  TOP w0.137: v2(257.56,120.74) 257.34,120.95 257.34,121.43 RG525.1
  IN5 w0.102: v2(258.83,117.97) 258.44,118.36 258.44,118.61 257.34,119.7 257.34,120.52 257.47,120.65
  IN5 w0.114: v2(231.25,108.65) 231.25,108.36 231.38,108.23 234.52,108.23 235.24,108.95 235.24,108.95 237.71,111.43 237.71,111.43 237.75,111.47 237.75,111.47 237.77,111.49
  IN5 w0.119: 257.47,120.65 v2(257.56,120.74) 257.3,120.99 257.3,121.41 256.95,121.77 251.16,121.77 250.91,121.53 250.91,120.37 250.8,120.25 250.44,120.25 250.32,120.37 250.32,121.53 250.08,121.77 249.33,121.77 249.08,121.52 249.08,120.44 248.89,120.25 246.53,120.25 237.77,111.49
  BOTTOM w0.119: UG9.G42 v2(231.25,108.65) ; UG3.J11 v2(258.83,117.97)
FBB_CLK1: length 38.1
  IN1 w0.119: v2(232.55,111.55) 232.81,111.55 233.06,111.81 233.51,111.81 234,112.29 235.44,112.29 236.69,113.54 236.69,119.8 246.72,129.83 246.72,130.8 247.73,131.81 247.73,133.25 247.5,133.49 247.44,133.49 247.32,133.5 v2(247.08,133.28) 246.86,133.52 246.75,133.53 246.62,133.53 246.34,133.81 246.34,135.49 245.99,135.84 244,135.84 243.89,135.73 243.89,135.57 244,135.46 v2(244.13,135.46)
  BOTTOM w0.089: v2(244.13,135.46) 243.88,135.46 243.73,135.62 UG4.J12
  BOTTOM w0.119: UG9.F47 v2(232.55,111.55)
  BOTTOM w0.137: RG114.1 247.68,133.45 247.24,133.45 v2(247.08,133.28)
FBB_CLK1#: length 38.3
  IN1 w0.119: v2(243.33,135.58) 243.44,135.58 243.91,136.05 246.08,136.05 246.55,135.58 246.55,133.9 246.7,133.74 246.75,133.74 246.87,133.73 v2(247.11,133.95) 247.33,133.71 247.45,133.7 247.58,133.7 247.94,133.34 247.94,131.73 246.93,130.71 246.93,129.75 236.89,119.72 236.89,113.45 235.53,112.08 234.08,112.08 233.6,111.6 233.39,111.6 v2(233.22,111.43)
  BOTTOM w0.089: v2(243.33,135.58) 242.93,135.98 UG4.J11
  BOTTOM w0.119: UG9.E47 232.95,111.69 v2(233.22,111.43)
  BOTTOM w0.137: RG526.1 247.54,133.67 247.39,133.67 v2(247.11,133.95)
FBB_CMD0: length 30
  BOTTOM w0.089: UG3.G3 260.03,111.16
  BOTTOM w0.142: 260.03,111.16 259.65,110.78 259.65,109.42 259.8,109.27 259.8,108.8 259.42,108.42 259.17,108.42 259.12,108.38 ; 242.87,102.98 v1(240.48,102.98) 239.9,102.98 239.77,103.1 235.55,103.1 235.2,103.45 UG9.B35
  BOTTOM w0.173: 242.87,102.98 244.62,102.98 248.76,107.12 257.87,107.12 259.12,108.38
FBB_CMD1: length 28.7
  TOP w0.089: RG49.2 258.83,110.16 v2(258.83,110.77)
  BOTTOM w0.089: UG3.J3 258.43,111.17
  BOTTOM w0.142: 239.97,103.4 239.92,103.45 UG9.A35 ; 258.43,111.17 v2(258.83,110.77) 258.83,108.82 258.39,108.38
  BOTTOM w0.173: 239.97,103.4 v1(242.74,103.4) 244.23,103.4 248.47,107.64 257.65,107.64 258.39,108.38
FBB_CMD2: length 29.1
  TOP w0.089: v2(258.03,109.97) 257.52,109.97 257.41,109.86
  TOP w0.178: RG56.1 257.41,109.86
  BOTTOM w0.142: 243.84,103.8 234,103.8 UG9.D35 ; UG3.J2 v2(258.03,109.97) 258.03,108.91
  BOTTOM w0.173: 258.03,108.91 257.29,108.17 248.21,108.17 v1(246.75,106.71) 243.84,103.8
FBB_CMD3: length 25.9
  BOTTOM w0.142: UG3.L3 257.18,110.81 257.18,109.36 256.78,108.95 256.78,108.86 ; UG9.A36 243.36,104.15
  BOTTOM w0.173: 243.36,104.15 248.19,108.98 v1(249.31,108.98) 251.2,108.98 251.51,108.67 256.59,108.67 256.78,108.86
FBB_CMD4: length 26.4
  BOTTOM w0.089: UG3.K5 257.62,112.77
  BOTTOM w0.142: UG9.B36 235.25,104.15 235.6,104.5 242.13,104.5 ; 257.62,112.77 257.27,113.12 251.89,113.12 250.99,112.22
  BOTTOM w0.173: 250.99,112.22 249.33,110.56 248.86,110.56 v1(247.21,108.91) 242.8,104.5 242.13,104.5
FBB_CMD5: length 28.9
  BOTTOM w0.089: 250.94,112.67 250.9,112.67
  BOTTOM w0.102: 235.25,104.5 234.93,104.5 234.58,104.15 UG9.C36
  BOTTOM w0.142: 242.35,104.89 238.23,104.89 238.07,104.73 235.48,104.73 235.25,104.5 ; UG3.K4 257.63,112.13 258.05,112.55 258.05,113.05 257.71,113.4 251.66,113.4 250.94,112.67
  BOTTOM w0.173: 250.9,112.67 250.68,112.45 250.49,112.45 250.18,112.14 249.61,112.14 v1(243.76,106.3) 242.35,104.89
FBB_CMD6: length 28.5
  BOTTOM w0.142: 242.25,105.54 242.03,105.31 238.23,105.31 237.89,104.97 235.43,104.97 235.2,105.2 234.7,105.2 UG9.C38 ; UG3.J5 258.43,113.18 257.93,113.68 251.39,113.68 250.74,113.03
  BOTTOM w0.173: 242.25,105.54 v1(244.93,108.21) 249.75,113.03 250.74,113.03
FBB_CMD7: length 29.4
  BOTTOM w0.142: 251.74,113.97 251.75,113.96 258.1,113.96 258.87,113.18 258.87,112.42 258.43,111.98 UG3.J4 ; 241.87,106.05 241.48,105.66 238.17,105.66 237.72,105.21 235.54,105.21 235.2,105.55 UG9.B38
  BOTTOM w0.173: 251.74,113.97 251.22,113.97 250.96,113.72 249.36,113.72 248.65,113 248.65,112.83 v1(248.02,112.2) 241.87,106.05
FBB_CMD8: length 28.2
  BOTTOM w0.142: UG9.A38 237.58,105.55 238.06,106.03 v1(239.73,106.03) 241.12,106.03 241.51,106.42 ; 252.14,114.28 258.22,114.28 259.23,113.27 UG3.H5
  BOTTOM w0.173: 241.51,106.42 248.13,113.05 248.13,113.38 249.03,114.28 252.14,114.28
FBB_CMD9: length 32.3
  BOTTOM w0.142: 250.43,114.8 250.65,114.58 258.49,114.58 259.64,113.44 259.64,112.42 259.23,112.01 UG3.H4 ; 241.12,106.75 240.74,106.37 237.82,106.37 237.65,106.2 237.35,105.9 234,105.9 UG9.D38
  BOTTOM w0.173: 250.43,114.8 248.67,114.8 247.62,113.75 247.62,113.26 v1(244.9,110.54) 241.12,106.76 241.12,106.75
FBB_CMD10: length 31.4
  BOTTOM w0.142: 240.72,107.09 240.4,106.76 237.76,106.76 237.25,106.25 UG9.A39 ; 250.32,115.32 250.78,114.86 258.84,114.86 259.64,115.66 259.64,117.88 260.03,118.27 UG3.G12
  BOTTOM w0.173: 240.72,107.09 240.72,107.09 v1(241.55,107.92) 247.1,113.47 247.1,114.07 248.35,115.32 250.32,115.32
FBB_CMD11: length 30.1
  BOTTOM w0.142: 250.38,115.84 251.06,115.15 258.49,115.15 259.23,115.89 UG3.H10 ; 240.41,107.51 240.09,107.19 239.43,107.19 239.3,107.06 237.43,107.06 236.96,106.6 235.6,106.6 235.25,106.25 UG9.B39
  BOTTOM w0.173: 240.41,107.51 v1(242.82,109.92) 246.59,113.69 246.59,114.42 248.01,115.84 250.38,115.84
FBB_CMD12: length 31.6
  BOTTOM w0.142: UG3.H11 259.23,117.47 258.87,117.12 258.87,115.98 258.34,115.44 251.34,115.44 250.43,116.36 ; 240.33,108.16 239.71,107.54 239.35,107.54 239.24,107.43 237.03,107.43 236.44,106.85 235.5,106.85 235.25,106.6 234.88,106.6 234.53,106.25 UG9.C39
  BOTTOM w0.173: 250.43,116.36 247.66,116.36 246.07,114.77 246.07,113.9 v1(245.04,112.87) 240.33,108.16
FBB_CMD13: length 30.7
  BOTTOM w0.142: 239.72,108.28 239.39,107.95 239.25,107.95 239,107.7 236.81,107.7 236.19,107.08 235.42,107.08 235.2,107.3 234.7,107.3 UG9.C41 ; UG3.K11 257.63,117.54 258.05,117.12 258.05,116.42 257.35,115.72 251.57,115.72 250.41,116.88
  BOTTOM w0.173: 239.72,108.28 245.56,114.11 245.56,115.12 v1(245.67,115.23) 247.32,116.88 250.41,116.88
FBB_CMD14: length 28.8
  BOTTOM w0.142: UG9.B41 235.26,107.65 235.6,107.31 235.96,107.31 236.66,108.01 238.9,108.01 239.37,108.48 ; 250.4,117.4 251.76,116.04 257.29,116.04 257.63,116.38 UG3.K10
  BOTTOM w0.173: 239.37,108.48 245.02,114.14 245.02,115.47 v1(246.57,117.02) 246.95,117.4 250.4,117.4
FBB_CMD15: length 29.4
  BOTTOM w0.142: 238.65,108.3 238.6,108.25 236.35,108.25 UG9.A41 ; UG3.L12 256.83,118.15 257.29,117.69 257.29,116.72 256.93,116.36 251.95,116.36 250.57,117.74
  BOTTOM w0.173: 238.65,108.3 244.46,114.11 244.46,115.75 246.63,117.92 v1(248.63,117.92) 250.39,117.92
  BOTTOM w0.178: 250.57,117.74 250.39,117.92
FBB_CMD16: length 30.7
  BOTTOM w0.142: 236.61,116.75 236.61,113.72 236.34,113.45 236.1,113.45 235.95,113.6 235.4,113.6 UG9.B49
  BOTTOM w0.173: UG4.L3 236.26,137.32 236.07,137.32 235.99,137.23 235.87,137.23 235.87,137.23 235.58,137.23 235.58,137.23 235.07,137.23 235.07,137.23 234.78,137.23 234.78,137.23 234.53,137.23 234.45,137.32 233.72,137.32 232.5,136.1 232.5,126.98 232.83,126.64 v1(232.83,126.06) 232.83,120.52 236.61,116.75
FBB_CMD17: length 32.2
  TOP w0.178: RG50.2 233.77,137.25 235.26,137.25 v2(236.13,136.38)
  BOTTOM w0.089: UG4.J3 236.53,135.98
  BOTTOM w0.142: 236.53,135.98 v2(236.13,136.38) ; UG9.A49 236,113 236.44,113 236.95,113.51 236.95,115.16
  BOTTOM w0.173: 236.95,115.16 236.95,117.27 233.47,120.75 v1(233.47,123.07) 233.47,127.03 233.08,127.41 233.08,135.66 233.8,136.38 v2(236.13,136.38)
FBB_CMD18: length 29.6
  TOP w0.178: RG55.1 233.84,134.98 233.84,135.09 234.22,135.47 234.29,135.47 234.3,135.48 234.93,135.48 235.11,135.66 v2(235.31,135.66)
  BOTTOM w0.142: UG9.A48 235.9,112.7 236.58,112.7 237.23,113.35 ; v2(235.31,135.66) 235.41,135.66 UG4.J2
  BOTTOM w0.173: 237.23,113.35 237.23,117.77 v1(234.93,120.08) 234.05,120.96 234.05,127.46 233.67,127.84 233.67,134.98 234.21,135.52 234.78,135.52 234.78,135.53 235.22,135.53 235.31,135.61 v2(235.31,135.66)
FBB_CMD19: length 29.8
  BOTTOM w0.142: UG9.D47 234,112.2 236.56,112.2
  BOTTOM w0.173: UG4.G3 236.53,134.5 236.23,134.8 234.76,134.8 234.12,134.16 234.12,129.95 234.12,129.94 234.12,129.2 234.66,128.65 v1(234.66,124.82) 234.66,121.14 237.63,118.17 237.63,113.27 236.56,112.2
FBB_CMD20: length 27
  BOTTOM w0.142: UG9.A47 236.73,111.85 ; UG4.H5 238.13,134.93 238.55,134.51 238.55,129.48 238.14,129.06 237.36,129.06 237.09,128.79 237.03,128.79 236.39,128.15
  BOTTOM w0.173: 236.73,111.85 237.96,113.08 237.96,118.21 237.25,118.91 v1(237.25,122.82) 237.25,124.41 236.39,125.28 236.39,128.15
FBB_CMD21: length 30
  BOTTOM w0.142: 236.82,111.51 235.54,111.51 235.2,111.85 UG9.B47 ; 236.97,128.29 237.47,128.79 238.25,128.79 238.26,128.81 238.28,128.81 238.83,129.36 238.83,135.11 238.4,135.55 237.59,135.55 237.33,135.29 UG4.H4
  BOTTOM w0.173: 236.82,111.51 238.48,113.17 238.48,118.06 237.91,118.62 237.91,124.72 v1(237.41,125.22) 236.97,125.66 236.97,128.29
FBB_CMD22: length 30.7
  BOTTOM w0.142: UG9.C47 234.7,111.5 235.2,111.5 235.42,111.28 236.29,111.28 236.38,111.2 236.89,111.2 236.95,111.26 ; 237.59,128.35 237.76,128.52 238.36,128.52 238.38,128.54 238.39,128.54 238.4,128.55 238.42,128.55 239.11,129.25 239.11,135.34 238.48,135.98 UG4.J5
  BOTTOM w0.173: 236.95,111.26 239,113.31 239,117.55 238.74,117.81 238.74,118.17 238.49,118.41 v1(238.49,120.79) 238.49,125 237.59,125.9 237.59,128.35
FBB_CMD23: length 32.4
  BOTTOM w0.142: UG9.C45 234.5,110.45 234.85,110.8 235.25,110.8 235.49,111.04 236.2,111.04 236.31,110.93 237.04,110.93 237.13,111.02 ; UG4.J4 237.73,136.38 238.53,136.38 239.39,135.52 239.39,129.12 238.58,128.31 238.55,128.31 238.53,128.28 238.52,128.28 238.5,128.27 238.49,128.27 238.47,128.25 238.32,128.25 238.15,128.08
  BOTTOM w0.173: 238.15,128.08 238.15,128.05 238.1,128 238.1,126.22 239.1,125.22 v1(239.1,123.74) 239.1,118.17 239.52,117.76 239.52,113.41 237.13,111.02
FBB_CMD24: length 31.6
  BOTTOM w0.142: 237.42,110.8 237.31,110.69 236.2,110.69 236.09,110.8 235.6,110.8 235.25,110.45 UG9.B45 ; 238.62,127.92 239.67,128.97 239.67,135.74 238.63,136.78 UG4.K5
  BOTTOM w0.173: 238.62,127.92 238.62,126.57 239.74,125.45 v1(239.74,119.13) 239.74,118.26 240.04,117.96 240.04,113.42 237.42,110.8
FBB_CMD25: length 33
  BOTTOM w0.089: UG4.K4 237.33,136.8
  BOTTOM w0.142: 237.33,136.8 237.72,137.18 239.3,137.18 239.95,136.54 239.95,128.82 239.43,128.3 ; UG9.A45 237.51,110.45
  BOTTOM w0.173: 237.51,110.45 240.56,113.5 240.56,118.17 240.35,118.38 v1(240.35,121.67) 240.35,125.68 239.26,126.77 239.26,128.11 239.43,128.29 239.43,128.3
FBB_CMD26: length 36.6
  BOTTOM w0.142: UG4.L12 243.73,137.55 243.37,137.18 240.85,137.18 240.23,136.56 240.23,128.61 239.92,128.3 239.92,128.27 ; 237.63,110.1 234,110.1 UG9.D44
  BOTTOM w0.173: 237.63,110.1 241.08,113.55 v1(241.08,115.36) 241.08,118.38 240.93,118.53 240.93,125.99 239.87,127.05 239.87,128.22 239.92,128.27
FBB_CMD27: length 32.5
  BOTTOM w0.142: UG9.A44 237.82,109.75 ; 240.48,128.45 240.52,128.5 240.52,136.41 240.89,136.78 UG4.K10
  BOTTOM w0.173: 240.48,128.45 240.48,127.23 241.54,126.16 v1(241.54,124.54) 241.54,118.65 241.6,118.6 241.6,114.11 241.49,114.01 241.49,113.42 237.82,109.75
FBB_CMD28: length 34.5
  BOTTOM w0.142: UG4.K11 242.57,136.42 240.95,136.42 240.8,136.26 240.8,128.34 ; 238,109.45 236.41,109.45 236.37,109.41 235.54,109.41 235.2,109.75 UG9.B44
  BOTTOM w0.173: 240.8,128.34 240.8,128.21 240.99,128.01 240.99,127.58 242.15,126.42 v1(242.15,117.66) 242.15,113.6 238,109.45
FBB_CMD29: length 34.8
  BOTTOM w0.142: 241.44,128.29 241.12,128.61 241.12,135.32 241.33,135.53 242.57,135.53 UG4.H11 ; 238.12,109.17 235.43,109.17 235.2,109.4 234.7,109.4 UG9.C44
  BOTTOM w0.173: 238.12,109.17 242.76,113.81 v1(242.76,120.26) 242.76,126.67 241.51,127.93 241.51,128.23 241.44,128.29
FBB_CMD30: length 33.9
  BOTTOM w0.142: 238.29,108.9 236.3,108.9 236.27,108.93 235.48,108.93 235.25,108.7 234.9,108.7 234.55,108.35 UG9.C42 ; 241.84,128.43 241.84,128.69 241.4,129.13 241.4,134.87 241.7,135.18 UG4.H10
  BOTTOM w0.173: 241.84,128.43 243.35,126.93 v1(243.35,122.62) 243.35,113.96 238.29,108.9
FBB_CMD31: length 35
  BOTTOM w0.142: UG4.G12 243.35,134.76 242.02,134.76 241.68,134.42 241.68,129.48 242.36,128.8 ; UG9.B42 235.25,108.35 235.59,108.69 235.97,108.69 236.08,108.57 238.39,108.57
  BOTTOM w0.173: 242.36,128.8 243.93,127.22 v1(243.93,125.82) 243.93,115.4 243.87,115.34 243.87,114.05 238.39,108.57
FBB_D0: length 27.1
  IN5 w0.145: v2(231.15,101.05) 232.07,101.97 233.78,101.97 233.79,101.96 234.11,101.96 234.12,101.97 234.45,101.97 235.06,102.59 235.06,104.23 243.13,112.29 251.21,112.29 v2(251.48,112.02)
  BOTTOM w0.089: UG3.U4 251.53,111.97 v2(251.48,112.02)
  BOTTOM w0.178: UG9.H32 v2(231.15,101.05)
FBB_D1: length 23.8
  IN5 w0.145: v2(251.63,109.97) 251.09,109.44 244.4,109.44 239.19,104.23 239.19,102.07 238.87,101.75 237.82,101.75 237.77,101.7 237.56,101.7 237.32,101.45 v2(237.32,101.3)
  BOTTOM w0.089: UG3.U2 252.03,110.37 v2(251.63,109.97)
  BOTTOM w0.142: UG9.D32 234,101.7 236.92,101.7 v2(237.32,101.3)
FBB_D2: length 21.9
  IN5 w0.145: v2(252.43,111.57) 252.02,111.16 251.35,111.16 251.08,110.9 243.82,110.9 236.2,103.27 v2(236.2,102.1)
  BOTTOM w0.089: UG3.T4 v2(252.43,111.57)
  BOTTOM w0.142: v2(236.2,102.1) 236.15,102.05 UG9.A33
FBB_D3: length 23.1
  IN5 w0.145: v2(236.76,101.3) 236.76,101.42 237.19,101.84 237.19,103.24 244.05,110.11 251.22,110.11 251.47,110.36 252.04,110.36 v2(252.43,109.97)
  BOTTOM w0.089: v2(252.43,109.97) 252.83,110.37 UG3.T2
  BOTTOM w0.142: v2(236.76,101.3) 236.36,100.91 235.72,100.91 235.27,101.35 UG9.B32
FBB_D4: length 32.4
  IN5 w0.145: v2(255.63,111.57) 256.02,111.18 256.02,108.89 254.69,107.56 245.82,107.56 243.38,105.12 243.38,101.91 241.8,100.33 235.48,100.33 234.87,100.95 234.14,100.95 v2(234.1,100.91)
  BOTTOM w0.089: UG3.N4 v2(255.63,111.57)
  BOTTOM w0.1: v2(234.1,100.91) 234.02,100.99 233.51,100.99 233.15,101.35 UG9.E32
FBB_D5: length 30.9
  IN5 w0.145: v2(231.86,100.97) 232.5,101.61 234.95,101.61 235.63,102.29 235.63,103.72 243.51,111.59 251.75,111.59 252.12,111.97 253.87,111.97 254.42,111.41 254.42,110.37 v2(254.83,109.97)
  BOTTOM w0.089: v2(254.83,109.97) 255.23,110.37 UG3.N2
  BOTTOM w0.178: UG9.G32 231.55,101.28 v2(231.86,100.97)
FBB_D6: length 36.5
  IN5 w0.145: v2(256.43,111.57) 256.82,111.18 256.82,108.76 254.96,106.91 246.18,106.91 244.14,104.86 244.14,102.14 241.87,99.87 234.93,99.87 234.77,99.71 230.39,99.71 v2(229.85,100.25)
  BOTTOM w0.089: UG3.M4 256.03,111.97 v2(256.43,111.57)
  BOTTOM w0.178: UG9.J30 v2(229.85,100.25)
FBB_D7: length 30.6
  IN5 w0.145: v2(255.63,109.97) 255.23,109.57 255.23,109.02 254.42,108.21 245.52,108.21 242.68,105.37 242.68,101.8 241.68,100.8 235.73,100.8 235.4,101.12 235.22,101.3 232.8,101.3 v2(232.55,101.05)
  BOTTOM w0.089: v2(255.63,109.97) 256.03,110.37 UG3.M2
  BOTTOM w0.17: v2(232.55,101.05) 232.48,101.12 UG9.F32
FBB_D8: length 28.7
  IN1 w0.145: v2(251.63,117.97) 251.28,117.63 250.24,117.63 246.11,113.5 246.11,112.59 244.08,110.56 243.1,110.56 237.99,105.45 236.56,105.45 234.66,103.55 230.85,103.55 v2(230.55,103.85)
  BOTTOM w0.089: UG3.U11 v2(251.63,117.97)
  BOTTOM w0.178: UG9.H36 v2(230.55,103.85)
FBB_D9: length 28.9
  IN1 w0.1: 231.54,105.7 231.54,104.74
  IN1 w0.129: 231.54,104.74 v2(231.25,104.45)
  IN1 w0.145: v2(251.63,119.57) 251.32,119.88 249.26,119.88 243.44,114.07 243.44,113.33 237.12,107.01 235.31,107.01 234.46,106.16 232,106.16 231.54,105.7
  BOTTOM w0.089: UG3.U13 v2(251.63,119.57)
  BOTTOM w0.178: UG9.G36 v2(231.25,104.45)
FBB_D10: length 30.5
  IN1 w0.145: v2(229.85,104.45) 230.01,104.29 230.75,104.29 231.11,103.94 234.44,103.94 236.51,106.01 237.75,106.01 243.03,111.29 243.76,111.29 245.16,112.69 245.16,113.63 249.89,118.36 252.04,118.36 v2(252.43,117.97)
  BOTTOM w0.089: UG3.T11 v2(252.43,117.97)
  BOTTOM w0.178: UG9.J36 v2(229.85,104.45)
FBB_D11: length 28.4
  IN1 w0.1: 232.3,104.82 232.3,105.5
  IN1 w0.129: v2(231.95,104.45) 231.95,104.47 232.3,104.82
  IN1 w0.145: v2(252.43,119.57) 252.03,119.17 249.56,119.17 244.2,113.82 244.2,113.31 242.76,111.86 237.36,106.46 235.35,106.46 234.64,105.75 232.56,105.75 232.3,105.5
  BOTTOM w0.089: UG3.T13 v2(252.43,119.57)
  BOTTOM w0.17: UG9.F36 v2(231.95,104.45)
FBB_D12: length 31.9
  IN1 w0.1: 234.45,101.96 233.18,101.96 232.93,102.21 232.09,102.21
  IN1 w0.129: 232.09,102.21 v2(231.85,102.45)
  IN1 w0.145: 234.45,101.96 236.78,104.29 238.62,104.29 243.51,109.18 245.12,109.18 250.45,114.52 252.97,114.52 254.43,115.98 254.43,117.37 254.83,117.77 v2(254.83,117.97)
  BOTTOM w0.089: UG3.N11 v2(254.83,117.97)
  BOTTOM w0.17: UG9.F33 v2(231.85,102.45)
FBB_D13: length 30.6
  IN1 w0.145: v2(233.95,102.35) 233.95,102.86 234.25,103.16 234.97,103.16 236.68,104.87 238.36,104.87 243.19,109.7 243.37,109.88 244.83,109.88 250.16,115.21 252.4,115.21 253.62,116.44 253.62,117.32 253.86,117.56 254.2,117.56 254.43,117.79 254.43,119.17 v2(254.83,119.57)
  BOTTOM w0.089: UG3.N13 v2(254.83,119.57)
  BOTTOM w0.17: UG9.D33 v2(233.95,102.35)
FBB_D14: length 35.9
  IN1 w0.1: 230.58,101.78 232.72,101.78 233,101.5 234.91,101.5
  IN1 w0.129: v2(229.85,101.05) 230.58,101.78 ; 234.91,101.5 236.38,102.97
  IN1 w0.145: v2(255.63,117.97) UG3.M11 256.03,115.67 253.54,113.18 251,113.18 245.6,107.78 243.7,107.78 238.89,102.97 236.38,102.97
  BOTTOM w0.089: UG3.M11 v2(255.63,117.97)
  BOTTOM w0.178: UG9.J32 v2(229.85,101.05)
FBB_D15: length 35
  IN1 w0.1: v2(231.25,102.35) 231.61,101.99 232.84,101.99 233.14,101.69 234.6,101.69 234.66,101.75
  IN1 w0.145: v2(255.63,119.57) 255.23,119.17 255.23,115.82 253.27,113.86 250.72,113.86 245.34,108.48 243.59,108.48 238.77,103.66 236.57,103.66 234.66,101.75
  BOTTOM w0.089: UG3.M13 v2(255.63,119.57)
  BOTTOM w0.178: UG9.G33 v2(231.25,102.35)
FBB_D16: length 50
  IN1 w0.145: v2(233.25,110.75) 233.75,111.25 234.15,111.25 234.35,111.45 235.53,111.45 237.52,113.44 237.52,116.08 247.37,125.93 263.72,125.93 266.84,122.81 266.84,118.78 v2(265.23,117.17)
  BOTTOM w0.089: v2(265.23,117.17) 264.83,117.57 UG3.A11
  BOTTOM w0.178: v2(233.25,110.75) UG9.E45
FBB_D17: length 46.2
  IN1 w0.145: v2(233.95,110.75) 234.1,110.6 235.4,110.6 238.14,113.34 238.14,115.75 247.77,125.38 263.35,125.38 266.18,122.54 266.18,119.73 v2(265.23,118.77)
  BOTTOM w0.089: v2(265.23,118.77) 264.83,119.17 UG3.A13
  BOTTOM w0.17: UG9.D45 v2(233.95,110.75)
FBB_D18: length 48.6
  IN1 w0.145: v2(231.95,110.75) 232.42,110.28 235.7,110.28 238.81,113.39 238.81,115.4 248.23,124.83 262.98,124.83 265.53,122.27 265.53,120 264.83,119.29 264.83,117.57 v2(264.43,117.17)
  BOTTOM w0.089: UG3.B11 264.03,117.57 v2(264.43,117.17)
  BOTTOM w0.178: v2(231.95,110.75) UG9.F45
FBB_D19: length 45.6
  IN1 w0.145: v2(231.08,110.37) 231.1,110.39 231.5,110.39 232.02,109.87 235.95,109.87 239.51,113.43 239.51,115.15 248.63,124.28 262.6,124.28 264.88,122 264.88,120.02 v2(264.43,119.57)
  BOTTOM w0.089: v2(264.43,119.57) 264.03,119.17 UG3.B13
  BOTTOM w0.178: UG9.G45 231.16,110.45 v2(231.08,110.37)
FBB_D20: length 39.5
  IN1 w0.145: v2(233.95,108.65) 234.14,108.46 234.68,108.46 235.04,108.82 236.53,108.82 241.16,113.45 241.16,114.77 248.96,122.57 260.5,122.57 261.63,121.44 261.63,118.37 v2(262.03,117.97)
  BOTTOM w0.089: v2(262.03,117.97) 261.63,117.57 UG3.E11
  BOTTOM w0.178: UG9.D42 v2(233.95,108.65)
FBB_D21: length 40
  IN1 w0.145: v2(262.03,119.57) 262.43,119.97 262.43,121.68 260.89,123.22 248.53,123.22 240.27,114.96 240.27,113.46 236.18,109.37 233.97,109.37 v2(233.25,108.65)
  BOTTOM w0.089: UG3.E13 261.63,119.17 v2(262.03,119.57)
  BOTTOM w0.178: UG9.E42 v2(233.25,108.65)
FBB_D22: length 40.1
  IN1 w0.145: v2(231.95,108.65) 232.53,108.07 236.69,108.07 241.92,113.3 241.92,114.52 249.32,121.92 259.92,121.92 260.84,121 260.84,118.36 v2(261.23,117.97)
  BOTTOM w0.089: v2(261.23,117.97) 260.83,117.57 UG3.F11
  BOTTOM w0.178: UG9.F42 v2(231.95,108.65)
FBB_D23: length 38.7
  IN1 w0.145: v2(260.43,119.57) 259.93,120.07 259.93,120.98 259.65,121.26 249.62,121.26 242.68,114.32 242.68,113.32 236.84,107.48 233.99,107.48 233.7,107.77 230.97,107.77 v2(230.55,107.35)
  BOTTOM w0.089: v2(260.43,119.57) 260.83,119.17 UG3.F13
  BOTTOM w0.178: UG9.H41 v2(230.55,107.35)
FBB_D24: length 39.4
  IN3 w0.14: v2(233.25,107.35) 233.25,107.36 233.39,107.5 235.5,107.5 235.66,107.66 235.68,107.66 240.7,112.68 245.15,112.68 248.26,115.79 260.31,115.79 260.69,115.4 263.08,115.4 265.05,113.43 265.05,112.19 v2(264.43,111.57)
  BOTTOM w0.089: UG3.A4 264.83,111.97 v2(264.43,111.57)
  BOTTOM w0.178: UG9.E41 v2(233.25,107.35)
FBB_D25: length 43.5
  IN3 w0.14: v2(265.23,110.77) 265.62,111.16 265.62,113.53 262.43,116.72 246.91,116.72 243.88,113.69 240.58,113.69 234.67,107.78 232.5,107.78 232.28,107.56 232.28,107.09 231.95,106.76 v2(231.95,106.55)
  BOTTOM w0.089: v2(265.23,110.77) 264.83,110.37 UG3.A2
  BOTTOM w0.17: UG9.F39 v2(231.95,106.55)
FBB_D26: length 38
  IN3 w0.14: v2(264.43,112.37) 264.82,112.76 264.82,113.33 263.15,115 260.52,115 260.38,115.15 250.52,115.15 250.5,115.13 248.53,115.13 245.42,112.02 241.32,112.02 236.5,107.2 233.9,107.2 v2(233.25,106.55)
  BOTTOM w0.089: v2(264.43,112.37) 264.03,111.97 UG3.B4
  BOTTOM w0.17: v2(233.25,106.55) UG9.E39
FBB_D27: length 37.6
  IN3 w0.14: v2(264.43,110.77) 264.03,111.17 264.03,113.32 262.96,114.39 248.71,114.39 245.69,111.37 241.68,111.37 236.83,106.51 235.93,106.51 235.82,106.4 234.1,106.4 v2(233.95,106.55)
  BOTTOM w0.089: UG3.B2 264.03,110.37 v2(264.43,110.77)
  BOTTOM w0.17: UG9.D39 v2(233.95,106.55)
FBB_D28: length 36.2
  IN3 w0.14: v2(261.23,111.57) 261.62,111.96 261.62,113.33 261.27,113.68 248.93,113.68 245.96,110.71 241.95,110.71 238.19,106.95 238.15,106.95 237.02,105.82 234.68,105.82 234.54,105.96 233.07,105.96 232.68,105.57 232.68,105.12 v2(232.71,105.09)
  BOTTOM w0.089: v2(261.23,111.57) 261.63,111.97 UG3.E4
  BOTTOM w0.17: v2(232.71,105.09) UG9.F38
FBB_D29: length 34.2
  IN3 w0.14: v2(261.23,110.77) 260.83,111.17 260.83,112.52 260.56,112.79 248.97,112.79 246.24,110.06 246.21,110.06 245.78,109.63 241.85,109.63 237.36,105.14 234.71,105.14 234.24,105.61 233.69,105.61 v2(233.27,105.19)
  BOTTOM w0.089: UG3.E2 v2(261.23,110.77)
  BOTTOM w0.17: UG9.E38 232.95,105.51 v2(233.27,105.19)
FBB_D30: length 32.2
  IN3 w0.14: v2(233.95,104.45) 234.36,104.04 237.4,104.04 241.47,108.11 258.11,108.11 258.87,108.86 258.87,109.82 260.02,110.96 260.02,111.96 v2(260.43,112.37)
  BOTTOM w0.089: v2(260.43,112.37) 260.83,111.97 UG3.F4
  BOTTOM w0.17: UG9.D36 v2(233.95,104.45)
FBB_D31: length 32.6
  IN3 w0.14: v2(260.43,110.77) 259.89,110.23 259.89,108.48 258.62,107.22 241.85,107.22 238.16,103.53 234.17,103.53 v2(233.25,104.45)
  BOTTOM w0.089: UG3.F2 v2(260.43,110.77)
  BOTTOM w0.17: v2(233.25,104.45) UG9.E36
FBB_D32: length 20.1
  IN1 w0.145: v2(228.04,117.6) 228.52,118.08 228.52,120.92 236.77,129.18 v2(236.93,129.18)
  BOTTOM w0.089: UG4.A4 v2(236.93,129.18)
  BOTTOM w0.142: UG9.M50 228.05,114.1 227.7,114.45 227.7,114.85 227.43,115.12 227.43,116.99
  BOTTOM w0.178: 227.43,116.99 v2(228.04,117.6)
FBB_D33: length 21.2
  IN1 w0.145: v2(227.05,112.8) 227.15,112.9 227.15,113.72 226.98,113.89 226.98,119.2 227.12,119.34 227.12,121.22 235.08,129.18 v2(235.33,129.18)
  BOTTOM w0.089: UG4.A2 v2(235.33,129.18)
  BOTTOM w0.17: v2(227.05,112.8) 226.9,112.8 UG9.P48
FBB_D34: length 20.2
  IN1 w0.145: v2(236.93,129.98) 237.32,129.59 237.32,128.94 229.1,120.72 229.1,117.46 v2(228.06,116.42)
  BOTTOM w0.089: UG4.B4 v2(236.93,129.98)
  BOTTOM w0.142: UG9.M51 228.05,114.85 227.66,115.24 227.66,115.96 228.06,116.36 v2(228.06,116.42)
FBB_D35: length 21.2
  IN1 w0.145: v2(236.13,129.98) 235.73,129.58 235.73,128.91 227.82,121 227.82,118.57 227.6,118.35 227.6,115.2 227.88,114.92 227.88,113.89 v2(227.65,113.66)
  BOTTOM w0.089: UG4.B2 v2(236.13,129.98)
  BOTTOM w0.17: UG9.M49 v2(227.65,113.66)
FBB_D36: length 29.3
  IN1 w0.145: v2(236.93,133.18) 236.53,132.78 233.37,132.78 232.51,131.91 232.51,130.35 225.41,123.26 225.41,115.69 226.62,114.48 226.62,112.48 v2(226.95,112.15)
  BOTTOM w0.089: UG4.E4 v2(236.93,133.18)
  BOTTOM w0.17: UG9.P47 v2(226.95,112.15)
FBB_D37: length 22.3
  IN1 w0.145: v2(225.95,116.95) 225.97,116.95 226.42,117.4 226.42,123.49 233.27,130.34 233.27,131.28 233.97,131.98 234.93,131.98 v2(235.33,132.38)
  BOTTOM w0.089: UG4.E2 v2(235.33,132.38)
  BOTTOM w0.142: v2(225.95,116.95) 226.65,116.25 UG9.P52
FBB_D38: length 34.3
  IN1 w0.145: v2(236.93,133.98) 236.43,134.48 232.66,134.48 231.05,132.87 231.05,130.45 223.36,122.77 223.36,116.59 225.17,114.78 225.29,114.78 226.04,114.03 226.04,111.24 v2(225.65,110.85)
  BOTTOM w0.089: UG4.F4 v2(236.93,133.98)
  BOTTOM w0.17: UG9.R46 v2(225.65,110.85)
FBB_D39: length 30.3
  IN1 w0.145: v2(235.33,133.18) 234.93,133.58 232.9,133.58 231.75,132.42 231.75,130.37 224.71,123.34 224.71,115.85 226.35,114.21 226.35,112 v2(227.05,111.3)
  BOTTOM w0.089: UG4.F2 v2(235.33,133.18)
  BOTTOM w0.17: v2(227.05,111.3) 226.8,111.3 UG9.P46
FBB_D40: length 27.5
  IN3 w0.14: v2(229.65,116) 228.77,116.88 228.77,118.96 229.15,119.34 229.15,123.47 230.78,125.1 232.21,125.1 234.33,127.22 241.37,127.22 v2(243.33,129.18)
  BOTTOM w0.089: UG4.A11 242.93,129.58 v2(243.33,129.18)
  BOTTOM w0.102: 229.1,114.8 229.1,114.53 228.75,114.18 UG9.L50
  BOTTOM w0.142: v2(229.65,116) 229.35,115.7 229.35,115.05 229.1,114.8
FBB_D41: length 28.2
  IN3 w0.14: v2(244.93,129.18) 245.28,128.83 245.28,127.09 242.93,124.74 235.15,124.74 233.55,123.14 232.35,123.14 231.56,122.35 231.56,118.58 231.31,118.34 231.31,117.32 230.44,116.45 229.85,116.45 v2(229.7,116.6)
  BOTTOM w0.089: UG4.A13 244.53,129.58 v2(244.93,129.18)
  BOTTOM w0.142: UG9.L51 228.75,114.81 229.09,115.15 229.09,116.34 229.35,116.6 v2(229.7,116.6)
FBB_D42: length 27.1
  IN3 w0.089: 243.75,128.39 243.75,129.56 v2(243.33,129.98)
  IN3 w0.14: 243.75,128.39 241.92,126.56 234.77,126.56 232.66,124.45 231.29,124.45 229.8,122.96 229.8,119.54 229.09,118.83 229.09,117.67 v2(229.6,117.16)
  BOTTOM w0.089: UG4.B11 242.93,130.38 v2(243.33,129.98)
  BOTTOM w0.142: v2(229.6,117.16) 229.34,117.16 228.75,116.57 UG9.L52
FBB_D43: length 30.5
  IN3 w0.089: v2(244.93,129.98) 244.51,129.56 244.51,128.39
  IN3 w0.14: v2(229.61,118.43) 230,118.05 230.4,118.05 230.67,118.32 230.67,122.58 231.88,123.79 233.28,123.79 235.24,125.76 242.74,125.76 244.51,127.53 244.51,128.39
  BOTTOM w0.089: v2(244.93,129.98) 244.53,130.38 UG4.B13
  BOTTOM w0.142: v2(229.61,118.43) 228.47,117.29 228.47,115.57 228.41,115.51 228.41,113.59 UG9.L49
FBB_D44: length 37.6
  IN3 w0.14: v2(227.63,110.03) 228.41,110.81 228.41,114.69 227.57,115.53 227.57,118.13 227.82,118.39 227.82,121.25 227.37,121.7 227.37,124.03 231.23,127.9 232.87,127.9 233.65,128.68 237.46,128.68 239.56,130.77 239.56,131.33 241,132.77 242.94,132.77 v2(243.33,132.38)
  BOTTOM w0.089: v2(243.33,132.38) 242.93,132.78 UG4.E11
  BOTTOM w0.1: v2(227.63,110.03) 227.7,110.1 228.32,110.1 228.42,110.2 228.42,110.78 UG9.M46
FBB_D45: length 34.1
  IN3 w0.14: v2(244.93,133.18) UG4.E13 244.53,132.23 244.27,131.97 241.64,131.97 237.72,128.04 234.22,128.04 231.94,125.76 230.16,125.76 228.39,123.98 228.39,121.64 228.52,121.5 228.52,116.57 229.12,115.97 229.12,114.88 228.76,114.52 228.76,112.44 v2(229.05,112.15)
  BOTTOM w0.089: UG4.E13 v2(244.93,133.18)
  BOTTOM w0.17: UG9.L47 v2(229.05,112.15)
FBB_D46: length 35.4
  IN3 w0.14: v2(227.64,112.82) 228.05,113.23 228.05,114.2 227,115.25 227,121.12 226.61,121.51 226.61,124.2 230.96,128.55 231.69,128.55 234.14,131 234.14,133.34 234.37,133.57 242.94,133.57 v2(243.33,133.18)
  BOTTOM w0.089: UG4.F11 242.93,133.58 v2(243.33,133.18)
  BOTTOM w0.17: UG9.M48 227.78,112.82 v2(227.64,112.82)
FBB_D47: length 39.5
  IN3 w0.14: v2(227.75,111.55) 227.55,111.75 226.79,111.75 226.42,112.12 226.42,120.87 225.85,121.45 225.85,124.36 233.08,131.6 233.08,133.38 234.08,134.38 244.53,134.38 v2(244.93,133.98)
  BOTTOM w0.089: UG4.F13 v2(244.93,133.98)
  BOTTOM w0.17: UG9.M47 v2(227.75,111.55)
FBB_D48: length 48.8
  IN5 w0.145: v2(243.33,142.78) 243.29,142.82 243.29,143.41 244.41,144.53 247.14,144.53 250.44,141.23 250.44,132.14 249.69,131.39 249.69,125.7 238.16,114.17 238.16,113.95 236.07,111.85 234.95,111.85 234.55,112.25 v2(233.35,112.25)
  BOTTOM w0.089: UG4.U11 242.93,142.38 v2(243.33,142.78)
  BOTTOM w0.11: UG9.D48 v2(233.35,112.25)
FBB_D49: length 38.3
  IN5 w0.145: v2(244.93,142.78) 245.33,142.38 246.43,142.38 247.24,141.57 247.24,141.02 248.79,139.47 248.79,132.83 247.35,131.39 247.35,125.7 235.9,114.25 v2(234.65,114.25)
  BOTTOM w0.089: UG4.U13 v2(244.93,142.78)
  BOTTOM w0.178: UG9.C50 v2(234.65,114.25)
FBB_D50: length 45.4
  IN5 w0.145: v2(234.65,112.85) 235.15,112.35 235.56,112.35 249.14,125.93 249.14,131.62 249.89,132.37 249.89,140.8 246.8,143.88 244.68,143.88 243.73,142.93 243.73,142.38 v2(243.33,141.98)
  BOTTOM w0.089: UG4.T11 242.93,141.58 v2(243.33,141.98)
  BOTTOM w0.17: UG9.C48 v2(234.65,112.85)
FBB_D51: length 42.2
  IN5 w0.145: v2(234.65,113.55) 234.66,113.56 236.36,113.56 237.06,114.26 237.06,114.63 248.59,126.16 248.59,131.85 249.34,132.6 249.34,140.42 246.53,143.23 244.73,143.23 244.53,143.03 244.53,142.38 v2(244.93,141.98)
  BOTTOM w0.089: UG4.T13 v2(244.93,141.98)
  BOTTOM w0.17: UG9.C49 v2(234.65,113.55)
FBB_D52: length 39.1
  IN5 w0.145: v2(233.25,112.95) 232.79,113.41 232.79,114.25 232.52,114.52 232.52,115.72 232.87,116.07 232.87,116.64 235.01,118.77 235.57,118.77 240.58,123.78 240.58,125.76 242.92,128.1 245.14,128.1 246.32,129.28 246.32,131.92 247.68,133.29 247.68,137.12 246.42,138.39 243.97,138.39 243.74,138.62 243.74,139.17 v2(243.33,139.58)
  BOTTOM w0.089: UG4.N11 v2(243.33,139.58)
  BOTTOM w0.11: UG9.E49 v2(233.25,112.95)
FBB_D53: length 36.3
  IN5 w0.145: v2(233.25,114.25) 232.77,114.73 232.77,115.08 233.51,115.82 233.51,116.5 235.23,118.22 236.61,118.22 246.8,128.41 246.8,131.62 248.24,133.06 248.24,138.35 247.42,139.17 245.34,139.17 v2(244.93,139.58)
  BOTTOM w0.089: UG4.N13 v2(244.93,139.58)
  BOTTOM w0.178: UG9.E50 v2(233.25,114.25)
FBB_D54: length 35.9
  IN5 w0.145: v2(243.33,138.78) 242.93,139.18 240.15,139.18 239.11,138.14 239.11,126.22 236.24,123.35 235.37,123.35 230.74,118.71 230.74,113.57 231.06,113.25 231.45,113.25 v2(231.85,112.85)
  BOTTOM w0.089: UG4.M11 v2(243.33,138.78)
  BOTTOM w0.17: UG9.F49 v2(231.85,112.85)
FBB_D55: length 34.5
  IN5 w0.145: v2(244.93,137.98) 244.39,137.44 240.95,137.44 239.87,136.36 239.87,124.42 231.79,116.34 231.79,114.74 232.25,114.28 UG9.F48 v2(231.95,112.25)
  BOTTOM w0.089: UG4.M13 244.53,138.38 v2(244.93,137.98)
  BOTTOM w0.17: v2(231.95,112.25) UG9.F48
FBB_D56: length 38.6
  IN1 w0.145: v2(237.73,141.98) 238.14,142.39 241.87,142.39 242.14,142.12 242.14,135.51 241.5,134.88 241.5,127.67 235.33,121.5 235.33,118.26 234.42,117.35 234.29,117.35 233.5,116.56 233.5,115.8 232.69,114.99 232.69,114.39 231.95,113.65 v2(231.85,113.65)
  BOTTOM w0.089: UG4.U4 v2(237.73,141.98)
  BOTTOM w0.178: UG9.F50 232.15,113.95 v2(231.85,113.65)
FBB_D57: length 40.7
  IN1 w0.145: v2(236.13,141.98) 237.37,143.22 243.44,143.22 243.72,142.94 243.72,138.14 242.67,137.09 242.67,135.15 242.06,134.54 242.06,127.44 235.88,121.27 235.88,118.03 234.97,117.12 234.78,117.12 v2(234.11,116.45)
  BOTTOM w0.089: UG4.U2 v2(236.13,141.98)
  BOTTOM w0.142: v2(234.11,116.45) 234.07,116.45 233.6,115.98 233.6,115.4 UG9.D52
FBB_D58: length 34.6
  IN1 w0.145: v2(229.85,114.25) 234.23,118.63 234.23,121.95 240.38,128.11 240.38,140.57 240.17,140.78 238.13,140.78 v2(237.73,141.18)
  BOTTOM w0.089: UG4.T4 v2(237.73,141.18)
  BOTTOM w0.178: UG9.J50 v2(229.85,114.25)
FBB_D59: length 39.5
  IN1 w0.145: v2(235.33,141.98) UG4.T2 240.12,141.58 240.95,140.74 240.95,127.9 234.78,121.72 234.78,118.49 232.76,116.47 232.76,115.82 232.04,115.1 231.9,115.1 230.8,114 230.8,113.2 v2(231.15,112.85)
  BOTTOM w0.089: UG4.T2 235.73,141.58 v2(235.33,141.98)
  BOTTOM w0.178: UG9.H48 v2(231.15,112.85)
FBB_D60: length 31.7
  IN1 w0.145: v2(236.93,138.78) 237.18,138.78 237.62,139.22 238.75,139.22 239.22,138.75 239.22,136.31 239.81,135.71 239.81,128.32 233.67,122.18 233.67,118.56 232.52,117.41 231.78,117.41 v2(231.77,117.42)
  BOTTOM w0.089: UG4.N4 v2(236.93,138.78)
  BOTTOM w0.142: UG9.H51 230.85,114.8 231.49,115.44 231.49,116.3 231.6,116.41 231.6,117.25 v2(231.77,117.42)
FBB_D61: length 31.2
  IN1 w0.129: 230.86,116.8 230.73,116.67 230.73,115.83 229.95,115.05 v2(229.75,115.05)
  IN1 w0.145: v2(236.13,138.78) 236.13,138.48 236.23,138.38 237.9,138.38 238.13,138.15 238.13,137.58 238.55,137.16 238.55,135.99 239.28,135.26 239.28,128.56 233.12,122.4 233.12,120.17 231.31,118.36 231.31,117.25 230.86,116.8
  BOTTOM w0.089: UG4.N2 v2(236.13,138.78)
  BOTTOM w0.178: UG9.J51 v2(229.75,115.05)
FBB_D62: length 30
  IN1 w0.145: v2(230.28,117.63) 230.83,118.18 230.83,120.16 232.57,121.89 232.57,122.63 238.8,128.86 238.8,134.57 237.68,135.69 237.68,137.08 236.93,137.83 v2(236.93,137.98)
  BOTTOM w0.089: UG4.M4 v2(236.93,137.98)
  BOTTOM w0.142: UG9.H49 230.5,113.6 230.5,115.6 230.75,115.85 230.75,117.16 v1(230.63,117.28) v2(230.28,117.63)
FBB_D63: length 29.8
  IN1 w0.145: v2(235.33,138.78) UG4.M2 235.73,135.33 235.88,135.18 237.18,135.18 238.29,134.06 238.29,129.13 230.28,121.13 230.28,118.51 v2(230.23,118.46)
  BOTTOM w0.089: v2(235.33,138.78) 235.73,138.38 UG4.M2
  BOTTOM w0.142: v2(230.23,118.46) 230.25,118.46 231.09,117.62 231.09,115.59 UG9.H52
FBB_DBI0: length 25.3
  IN2 w0.145: v2(254.03,109.97) 253.63,109.57 253.63,108.4 252.54,107.32 243.99,107.32 239.23,102.56 239.23,102.08 v2(238.45,101.3)
  BOTTOM w0.089: UG3.P2 254.43,110.37 v2(254.03,109.97)
  BOTTOM w0.102: 236.77,100.85 236.59,100.67 235.56,100.67 235.23,101 234.7,101 UG9.C32
  BOTTOM w0.142: v2(238.45,101.3) 238.45,101.3 238,100.85 236.77,100.85
FBB_DBI1: length 30.8
  IN2 w0.145: v2(233.25,102.45) 233.92,103.12 235.62,103.12 246.51,114.01 251.57,114.01 253.64,116.07 253.64,119.18 v2(254.03,119.57)
  BOTTOM w0.089: UG3.P13 v2(254.03,119.57)
  BOTTOM w0.1: v2(233.25,102.45) 232.95,102.15 UG9.E33
FBB_DBI2: length 40.3
  IN2 w0.145: v2(233.25,109.45) 233.39,109.59 235.14,109.59 238.8,113.25 238.8,113.69 249.53,124.42 260.14,124.42 262.43,122.14 262.43,119.97 v2(262.83,119.57)
  BOTTOM w0.089: UG3.D13 262.43,119.17 v2(262.83,119.57)
  BOTTOM w0.178: UG9.E44 v2(233.25,109.45)
FBB_DBI3: length 51.8
  IN2 w0.145: v2(231.73,107.18) 232.78,108.23 235.18,108.23 250.04,123.09 259.19,123.09 260.83,121.45 260.83,116.11 261.98,114.96 262.43,114.96 263.23,114.16 263.23,110.17 263.03,109.97 v2(262.03,109.97)
  BOTTOM w0.089: v2(262.03,109.97) 262.43,110.37 UG3.D2
  BOTTOM w0.102: v2(231.73,107.18) 231.55,107 UG9.G39
FBB_DBI4: length 23.9
  IN2 w0.145: v2(236.13,131.58) 236.11,131.58 235.74,131.21 235.74,130.57 235.54,130.37 235.09,130.37 227.53,122.82 227.53,117.93 v2(225.95,116.35)
  BOTTOM w0.089: UG4.D2 v2(236.13,131.58)
  BOTTOM w0.142: UG9.P49 226.3,113.6 226.3,115.48 226.4,115.58 226.4,116.13 226.18,116.35 v2(225.95,116.35)
FBB_DBI5: length 28.8
  IN2 w0.145: v2(244.93,131.58) 244.52,131.17 241.86,131.17 241.08,130.39 241.08,126.58 233.72,119.22 233.72,118.56 232.14,116.98 231.54,116.98 230.66,116.1 230.66,115.81 230.31,115.46 229.6,115.46 228.88,114.74 228.88,113.92 v2(229.15,113.65)
  BOTTOM w0.089: v2(244.93,131.58) 244.53,131.98 UG4.D13
  BOTTOM w0.1: v2(229.15,113.65) 229.08,113.58 229.08,113.12 228.75,112.79 UG9.L48
FBB_DBI6: length 36.5
  IN2 w0.145: v2(244.93,140.38) 245.33,139.98 246.16,139.98 247.56,138.58 247.56,128.46 234.47,115.38 233.11,115.38 232.78,115.05 232.78,114.13 233.26,113.65 v2(233.35,113.65)
  BOTTOM w0.089: UG4.P13 v2(244.93,140.38)
  BOTTOM w0.178: UG9.D50 v2(233.35,113.65)
FBB_DBI7: length 33.2
  IN2 w0.145: v2(235.33,139.58) 235.74,139.17 238.84,139.17 239.11,138.9 239.11,126.64 231.94,119.47 231.94,118.71 v2(232.14,118.51)
  BOTTOM w0.089: UG4.P2 v2(235.33,139.58)
  BOTTOM w0.142: UG9.H50 231.2,114.3 231.2,114.8 231.85,115.45 231.85,116.24 232.2,116.59 232.2,118.45 v2(232.14,118.51)
FBB_EDC0: length 23.6
  IN2 w0.145: v2(238.11,102.32) 238.11,102.58 243.8,108.27 252.35,108.27 252.83,108.75 252.83,110.38 v2(253.22,110.77)
  BOTTOM w0.089: v2(253.22,110.77) 253.62,110.37 UG3.R2
  BOTTOM w0.142: v2(238.11,102.32) 237.92,102.51 235.51,102.51 UG9.B33
FBB_EDC1: length 29.3
  IN2 w0.145: v2(232.65,103.15) 233.04,103.54 234.83,103.54 246.12,114.83 251.44,114.83 252.83,116.22 252.83,118.38 v2(253.23,118.77)
  BOTTOM w0.089: UG3.R13 v2(253.23,118.77)
  BOTTOM w0.1: UG9.E35 v2(232.65,103.15)
FBB_EDC2: length 45.9
  IN2 w0.145: v2(230.66,109.56) 230.84,109.74 231.42,109.74 231.74,110.06 234.22,110.06 238.04,113.88 238.04,114.52 248.64,125.12 260.65,125.12 263.23,122.54 263.23,119.16 v2(263.63,118.77)
  BOTTOM w0.089: UG3.C13 263.23,119.17 v2(263.63,118.77)
  BOTTOM w0.178: v2(230.66,109.56) 230.85,109.75 UG9.G44
FBB_EDC3: length 50.2
  IN2 w0.145: v2(262.83,110.77) 262.43,111.16 261.02,111.16 260.83,111.35 260.83,113.57 259.22,115.18 259.22,119.81 257.79,121.25 250.87,121.25 235.08,105.46 235.08,104.6 234.53,104.05 230.96,104.05 230.76,104.25 230.76,104.89 230.55,105.1 v2(230.55,105.25)
  BOTTOM w0.089: UG3.C2 v2(262.83,110.77)
  BOTTOM w0.178: UG9.H38 v2(230.55,105.25)
FBB_EDC4: length 22.9
  IN2 w0.145: v2(235.33,130.78) 235.12,130.78 234.67,130.33 233.91,130.33 226.64,123.06 226.64,118.35 226.51,118.22 v2(225.95,118.22)
  BOTTOM w0.089: UG4.C2 v2(235.33,130.78)
  BOTTOM w0.142: UG9.P50 227.01,114.31 227.01,114.86 227.19,115.04 227.19,115.72 227.16,115.75 227.16,117.01
  BOTTOM w0.178: 227.16,117.01 v2(225.95,118.22)
FBB_EDC5: length 25.9
  IN2 w0.145: v2(244.13,130.78) 243.72,130.37 242.14,130.37 241.78,130.01 241.78,126.12 234.27,118.61 234.27,118.33 232.37,116.43 232.09,116.43 231.44,115.78 231.44,115.6 230.31,114.47 230.31,114.08 230.12,113.89 230.12,113.12 v2(229.85,112.85)
  BOTTOM w0.089: UG4.C13 v2(244.13,130.78)
  BOTTOM w0.178: UG9.J48 v2(229.85,112.85)
FBB_EDC6: length 38.5
  IN2 w0.145: v2(233.95,114.95) 234.1,114.95 234.41,114.64 235.63,114.64 235.74,114.53 236.52,114.53 237.03,115.04 237.03,116.43 248.59,127.99 248.59,138.83 246.64,140.78 244.52,140.78 v2(244.13,141.18)
  BOTTOM w0.089: UG4.R13 244.53,140.78 v2(244.13,141.18)
  BOTTOM w0.178: UG9.D51 v2(233.95,114.95)
FBB_EDC7: length 32.2
  IN2 w0.145: v2(236.13,140.38) 236.13,140.36 236.51,139.98 237.21,139.98 237.66,139.53 239.25,139.53 239.68,139.09 239.68,126.26 233.09,119.67 v2(233.09,118.55)
  BOTTOM w0.089: UG4.R2 v2(236.13,140.38)
  BOTTOM w0.142: UG9.F51 232.6,115 232.6,115.65
  BOTTOM w0.178: v2(233.09,118.55) 233.09,118 232.79,117.7 232.79,115.84 232.6,115.65
FBB_WCK01: length 31.5
  IN2 w0.119: v2(254.04,112.35) 254.29,112.6 254.29,112.81 254.1,113 247.27,113 236.8,102.53 235.77,102.53 234.76,101.52 230.51,101.52 230.14,101.89 230.14,102.2 229.99,102.35 v2(229.85,102.35)
  BOTTOM w0.089: v2(254.04,112.35) 254.11,112.35 254.43,112.04 UG3.P4
  BOTTOM w0.119: v2(229.85,102.35) 230.02,102.35 230.15,102.22 UG9.J33
FBB_WCK01#: length 31.3
  IN2 w0.119: v2(230.55,102.35) 230.35,102.16 230.35,101.97 230.6,101.73 234.68,101.73 235.68,102.74 236.71,102.74 247.19,113.21 254.19,113.21 254.5,112.9 254.5,112.6 254.69,112.4 v2(254.79,112.4)
  BOTTOM w0.089: v2(254.79,112.4) 254.64,112.4 254.43,112.61 UG3.P5
  BOTTOM w0.119: UG9.H33 v2(230.55,102.35)
FBB_WCK23: length 48.2
  IN2 w0.102: 261.6,113.49 261.6,112.79 262.02,112.38 v2(262.07,112.38)
  IN2 w0.119: v2(229.85,106.55) 230.01,106.55 230.14,106.42 230.14,106.15 230.5,105.79 234.35,105.79 250.41,121.86 259.16,121.86 259.82,121.21 259.82,115.28 261.6,113.49
  BOTTOM w0.089: UG3.D4 262.43,111.97 262.07,112.33 v2(262.07,112.38)
  BOTTOM w0.119: v2(229.85,106.55) 230.02,106.55 230.15,106.42 UG9.J39
FBB_WCK23#: length 48.3
  IN2 w0.102: 261.75,113.64 261.76,113.63 261.76,113.62 261.8,113.58 261.8,113.41 261.79,113.4 261.79,112.87 261.91,112.76 262.03,112.76 262.17,112.9 262.17,113.17 v2(262.25,113.24)
  IN2 w0.119: v2(230.55,106.55) 230.35,106.35 230.35,106.24 230.59,106 234.26,106 250.33,122.07 259.25,122.07 260.03,121.29 260.03,115.37 261.75,113.64
  BOTTOM w0.089: UG3.D5 262.29,112.77 262.18,112.88 262.18,113.17 v2(262.25,113.24)
  BOTTOM w0.119: UG9.H39 v2(230.55,106.55)
FBB_WCK45: length 29
  IN2 w0.119: v2(229.05,110.85) 228.64,110.85 228.51,110.98 228.51,115.04 228.97,115.5 228.97,120.06 238.51,129.59 238.51,132.54 238.25,132.8 237.74,132.8 237.31,132.38 v2(237.05,132.38)
  BOTTOM w0.089: UG4.D4 237.33,132.1 v2(237.05,132.38)
  BOTTOM w0.119: UG9.L46 v2(229.05,110.85)
FBB_WCK45#: length 28.9
  IN2 w0.119: v2(237.73,132.26) 237.73,132.47 237.85,132.59 238.16,132.59 238.3,132.46 238.3,129.68 228.77,120.15 228.77,115.58 228.3,115.12 228.3,110.89 228.55,110.64 228.72,110.64 229.05,110.32 v2(229.05,110.15)
  BOTTOM w0.089: v2(237.73,132.26) 237.73,132.1 237.85,131.98 UG4.D5
  BOTTOM w0.119: v2(229.05,110.15) 229.05,110.31 228.91,110.45 UG9.L45
FBB_WCK67: length 44.5
  IN2 w0.119: v2(237.85,140.38) 238.27,140.8 239.69,140.8 240.4,140.09 240.4,138.22 241.17,137.46 244.62,137.46 246.51,135.56 246.51,128.8 245.5,127.79 244.82,127.79 233.34,116.3 233.34,116.03 232.52,115.21 232.16,115.21 230.68,113.74 230.68,112.3 230.9,112.09 231.09,112.09 v2(231.25,112.25)
  BOTTOM w0.089: UG4.P4 237.45,139.98 v2(237.84,140.38)
  BOTTOM w0.119: UG9.H47 v2(231.25,112.25)
FBB_WCK67#: length 44.4
  IN2 w0.119: v2(238.6,140.18) 238.41,140.18 238.29,140.3 238.29,140.48 238.4,140.59 239.6,140.59 240.19,140 240.19,138.14 241.08,137.25 244.53,137.25 246.3,135.48 246.3,128.88 245.42,128 244.73,128 233.13,116.39 233.13,116.11 232.43,115.42 232.07,115.42 230.47,113.83 230.47,112.22 230.81,111.88 231.02,111.88 231.15,111.75 v2(231.15,111.45)
  BOTTOM w0.089: UG4.P5 238.4,139.98 v2(238.6,140.18)
  BOTTOM w0.119: UG9.H46 v2(231.15,111.45)
FBC_CLK0: length 37.3
  TOP w0.119: v2(256.47,86.08) 256.66,86.08 256.9,86.32 256.9,86.38
  TOP w0.137: RG124.1 256.9,86.71 256.9,86.38
  IN5 w0.119: v2(231.25,89.75) 231.42,89.75 231.82,89.35 234.47,89.35 234.8,89.68 240.91,89.68 243.06,87.53 245.37,87.53 246.24,86.65 247.53,86.65 247.65,86.53 247.65,85.59 247.89,85.35 248.42,85.35 248.66,85.59 248.66,86.53 248.78,86.65 250.6,86.65 250.72,86.53 250.72,86.16 250.96,85.92 251.49,85.92 251.73,86.16 251.73,86.53 251.85,86.65 256.9,86.65 257.03,86.53 257.03,86.35 256.9,86.22 256.61,86.22 v2(256.47,86.08) 256.61,85.94 256.84,85.94 257.02,85.76 257.02,85.14 256.21,84.33 256.21,84.01 256.11,83.91 v2(255.88,83.91)
  BOTTOM w0.089: UG5.J12 256.01,83.51 255.88,83.64 v2(255.88,83.91)
  BOTTOM w0.119: UG9.G15 v2(231.25,89.75)
FBC_CLK0#: length 36.9
  TOP w0.119: v2(257.43,86.08) 257.21,86.3 257.21,86.38
  TOP w0.137: 257.21,86.38 257.21,86.82 RG527.1
  IN5 w0.119: v2(256.11,83.11) 256.11,83.61 256.42,83.92 256.42,84.25 257.23,85.06 257.23,85.87 v2(257.43,86.08) 257.24,86.27 257.24,86.61 256.99,86.86 251.76,86.86 251.52,86.62 251.52,86.25 251.4,86.13 251.04,86.13 250.92,86.25 250.92,86.62 250.68,86.86 248.7,86.86 248.46,86.62 248.46,85.68 248.34,85.56 247.98,85.56 247.86,85.68 247.86,86.62 247.62,86.86 246.33,86.86 245.46,87.74 243.14,87.74 241,89.88 234.71,89.88 234.38,89.56 231.93,89.56 231.8,89.68 v2(231.8,89.9)
  BOTTOM w0.089: v2(256.11,83.11) 256.4,82.82 UG5.J11
  BOTTOM w0.119: UG9.F15 v2(231.8,89.9)
