# Allegro board Dell_Inspiron_15_7577_Compal_CKA50_CKF50_LA_E992P_Rev_1_0_BoardView.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
NL17SZ08DFT2G_SC70-5
  oval 0.406x0.508 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0,1.9)
NPCT650JB2YX_QFN32_5X5
  oval 0.889x0.254 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 5(0,-2) 6(0,-2.5) 7(0,-3) 8(0,-3.5) 17(5.1,-3.5) 18(5.1,-3) 19(5.1,-2.5) 20(5.1,-2) 21(5.1,-1.5) 22(5.1,-1) 23(5.1,-0.5) 24(5.1,0)
  oval 0.254x0.889 smd: 9(0.8,-4.3) 10(1.3,-4.3) 11(1.8,-4.3) 12(2.3,-4.3) 13(2.8,-4.3) 14(3.3,-4.3) 15(3.8,-4.3) 16(4.3,-4.3) 25(4.3,0.8) 26(3.8,0.8) 27(3.3,0.8) 28(2.8,0.8) 29(2.3,0.8) 30(1.8,0.8) 31(1.3,0.8) 32(0.8,0.8)
  rect 3.505x3.505 smd: 33(2.55,-1.75)
PESD5V0U2BT_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
PESD24VS2UT_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
PS8409QFN48GTR2-A0_QFN48_6X6-S
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 9(0,-3.2) 10(0,-3.6) 11(0,-4) 12(0,-4.4) 25(6.1,-4.4) 26(6.1,-4) 27(6.1,-3.6) 28(6.1,-3.2) 29(6.1,-2.8) 30(6.1,-2.4) 31(6.1,-2) 32(6.1,-1.6) 33(6.1,-1.2) 34(6.1,-0.8) 35(6.1,-0.4) 36(6.1,0)
  oval 0.203x0.889 smd: 13(0.85,-5.25) 14(1.25,-5.25) 15(1.65,-5.25) 16(2.05,-5.25) 17(2.45,-5.25) 18(2.85,-5.25) 19(3.25,-5.25) 20(3.65,-5.25) 21(4.05,-5.25) 22(4.45,-5.25) 23(4.85,-5.25) 24(5.25,-5.25) 37(5.25,0.85) 38(4.85,0.85) 39(4.45,0.85) 40(4.05,0.85) 41(3.65,0.85) 42(3.25,0.85) 43(2.85,0.85) 44(2.45,0.85) 45(2.05,0.85) 46(1.65,0.85) 47(1.25,0.85) 48(0.85,0.85)
  rect 4.496x4.496 smd: 49(3.05,-2.2)
R0201_0OHM
  rect 0.381x0.356 smd: 1(0,0) 2(0.584,0)
R0402_0OHM
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
R0603_0OHM
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
R0805_0OHM
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
R_0201
  rect 0.381x0.356 smd: 1(0,0) 2(0.584,0)
R_0402
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
R_0402-NPM
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
R_0603
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
R_0805
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
R_1206
  rect 1.016x1.651 smd: 1(0,0) 2(2.667,0)
R_1206_4P-D
  custom 0.371x0.371 smd: 1(0,0) 4(3.327,0)
  custom 0.114x0.114 smd: 2(0.775,0) 3(2.553,0)
RHU002N06_SOT323-3
  oval 0.813x0.914 smd: 1(0,0) 2(0.65,1.6) 3(-0.65,1.6)
RL-3264-9W-R005-FNH_2512_2512
  rect 2.108x2.489 smd: 1(0,0) 4(1.35,-4.3)
  rect 1.041x2.489 smd: 2(1.875,0) 3(-0.525,-4.3)
RP_0804_8P4R
  oval 0.66x0.254 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 5(1.15,-1.5) 6(1.15,-1) 7(1.15,-0.5) 8(1.15,0)
RT8061AZQW_WDFN10_3X3
  oval 0.254x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2,3.1) 7(1.5,3.1) 8(1,3.1) 9(0.5,3.1) 10(0,3.1)
  rect 2.464x1.626 smd: 11(1,1.55)
RT8207PGQW_WQFN20_3X3-S
  oval 0.203x0.889 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 11(1.6,3.1) 12(1.2,3.1) 13(0.8,3.1) 14(0.4,3.1) 15(0,3.1)
  oval 0.889x0.203 smd: 6(2.35,0.75) 7(2.35,1.15) 8(2.35,1.55) 9(2.35,1.95) 10(2.35,2.35) 16(-0.75,2.35) 17(-0.75,1.95) 18(-0.75,1.55) 19(-0.75,1.15) 20(-0.75,0.75)
  rect 1.702x1.702 smd: 21(0.8,1.55)
RT9059GSP_SO8
  oval 0.635x1.854 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,5.157) 6(2.54,5.157) 7(1.27,5.157) 8(0,5.157)
  rect 2.311x2.311 smd: 9(1.905,2.579)
RTD2166-CG_QFN32_4X4-S
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 17(4.1,-2.8) 18(4.1,-2.4) 19(4.1,-2) 20(4.1,-1.6) 21(4.1,-1.2) 22(4.1,-0.8) 23(4.1,-0.4) 24(4.1,0)
  oval 0.203x0.889 smd: 9(0.65,-3.45) 10(1.05,-3.45) 11(1.45,-3.45) 12(1.85,-3.45) 13(2.25,-3.45) 14(2.65,-3.45) 15(3.05,-3.45) 16(3.45,-3.45) 25(3.45,0.65) 26(3.05,0.65) 27(2.65,0.65) 28(2.25,0.65) 29(1.85,0.65) 30(1.45,0.65) 31(1.05,0.65) 32(0.65,0.65)
  rect 2.692x2.692 smd: 33(2.05,-1.4)
RTL8111H-CG_QFN32_4X4-S
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 17(4.1,-2.8) 18(4.1,-2.4) 19(4.1,-2) 20(4.1,-1.6) 21(4.1,-1.2) 22(4.1,-0.8) 23(4.1,-0.4) 24(4.1,0)
  oval 0.203x0.889 smd: 9(0.65,-3.45) 10(1.05,-3.45) 11(1.45,-3.45) 12(1.85,-3.45) 13(2.25,-3.45) 14(2.65,-3.45) 15(3.05,-3.45) 16(3.45,-3.45) 25(3.45,0.65) 26(3.05,0.65) 27(2.65,0.65) 28(2.25,0.65) 29(1.85,0.65) 30(1.45,0.65) 31(1.05,0.65) 32(0.65,0.65)
  rect 2.692x2.692 smd: 33(2.05,-1.4)
RTS5176E-GR_QFN24_4X4-S
  oval 0.254x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 13(2.5,4.1) 14(2,4.1) 15(1.5,4.1) 16(1,4.1) 17(0.5,4.1) 18(0,4.1)
  oval 0.889x0.254 smd: 7(3.3,0.8) 8(3.3,1.3) 9(3.3,1.8) 10(3.3,2.3) 11(3.3,2.8) 12(3.3,3.3) 19(-0.8,3.3) 20(-0.8,2.8) 21(-0.8,2.3) 22(-0.8,1.8) 23(-0.8,1.3) 24(-0.8,0.8)
  rect 2.261x2.261 smd: 25(1.25,2.05)
SAMTE_BSH-030-01-L-D-A-TR_60P
  round 1.016 hole 1.016 unplated: (-2.81,5.53) (17.316,5.53)
  oval 0.279x2.769 smd: 1(0,0) 2(0,5.728) 3(0.5,0) 4(0.5,5.728) 5(1,0) 6(1,5.728) 7(1.5,0) 8(1.5,5.728) 9(2,0) 10(2,5.728) 11(2.5,0) 12(2.5,5.728) 13(3,0) 14(3,5.728) 15(3.5,0) 16(3.5,5.728) 17(4,0) 18(4,5.728) 19(4.5,0) 20(4.5,5.728) 21(5,0) 22(5,5.728) 23(5.5,0) 24(5.5,5.728) 25(6,0) 26(6,5.728) 27(6.5,0) 28(6.5,5.728) 29(7,0) 30(7,5.728) 31(7.5,0) 32(7.5,5.728) 33(8,0) 34(8,5.728) 35(8.5,0) 36(8.5,5.728) 37(9,0) 38(9,5.728) 39(9.5,0) 40(9.5,5.728) 41(10,0) 42(10,5.728) 43(10.5,0) 44(10.5,5.728) 45(11,0) 46(11,5.728) 47(11.5,0) 48(11.5,5.728) 49(12,0) 50(12,5.728) 51(12.5,0) 52(12.5,5.728) 53(13,0) 54(13,5.728) 55(13.5,0) 56(13.5,5.728) 57(14,0) 58(14,5.728) 59(14.5,0) 60(14.5,5.728)
SANTA_130460-N_8P
  round 1.295 hole 0.889: 1(0,0) 2(-1.02,1.1) 3(-2.04,0) 4(-3.06,1.1) 5(-4.08,0) 6(-5.1,1.1) 7(-6.12,0) 8(-7.14,1.1)
  oval 0.991x2.007 hole 0.61x1.6: 9(-11.97,-2.3) 10(-11.97,-10.1) 11(4.83,-10.1) 12(4.83,-2.3)
SHORTPADS
  custom 0.19x0.19 smd: 1(-0.483,0) 2(0.483,0)
SI3457BDV-T1-E3_TSOP6
  oval 0.508x1.448 smd: 1(0,0) 2(1,0) 3(2,0) 4(2,2.425) 5(1,2.425) 6(0,2.425)
SIC531CDT1GE3_POWERPAK22_4X3
  oval 0.889x0.279 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 5(0,-2)
  custom 0.322x0.322 smd: 6(1.25,-2.303)
  custom 0.439x0.439 smd: 7(3.018,-1)
  custom 0.225x0.225 smd: 8(4.425,-1)
  oval 0.279x0.889 smd: 9(2.25,0.75) 10(1.75,0.75) 11(1.25,0.75) 12(0.75,0.75)
  rect 1.168x1.194 smd: 13(1.31,-0.588)
SIC632CDT1GE3_POWERPAK31_5X5
  oval 0.889x0.305 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 5(0,-2) 6(0,-2.5) 7(0,-3) 8(0,-3.5) 11(5,-3.5) 12(5,-3) 13(5,-2.5) 14(5,-2) 15(5,-1.5) 16(5,-1) 17(5,-0.5) 18(5,0)
  custom 0.337x0.337 smd: 9(1.25,-3.185)
  custom 0.549x0.549 smd: 10(3.327,-2.275)
  oval 0.305x0.889 smd: 19(4.25,0.75) 20(3.75,0.75) 21(3.25,0.75) 22(2.75,0.75) 23(2.25,0.75) 24(1.75,0.75) 25(1.25,0.75) 26(0.75,0.75)
  rect 0.406x0.559 smd: 27(2.6,-0.275)
  rect 1.118x1.422 smd: 28(1.315,-0.71)
SINGA_2SJ3095-106111F_6P
  oval 0.991x1.803 hole 0.61x1.397: 1(0,0) 2(-9.5,5.5) 3(-9.5,8.6) 4(0,7.8) 5(-9.5,0) 6(-9.5,2.75) 7(0,2.65)
SKL-H_BGA_1440P-T
  round 0.406 smd: A3(-1.254,0) A37(-26.054,0) B2(-0.66,0.66) B38(-26.628,0.553) BR1(0,40.062) BR38(-26.628,40.036) BT2(-0.571,40.628) BT37(-26.037,40.628) C1(0,1.267)
  round 0.381 smd: A4(-1.971,0) A34(-24.46,0) A36(-25.272,0) AA13(-7.813,14.548) AA14(-8.463,14.548) AA29(-20.725,14.415) AA30(-21.376,14.415) AB29(-20.725,15.203) AB30(-21.376,15.203) AC13(-7.813,15.463) AC14(-8.463,15.463) AC29(-20.725,15.99) AC30(-21.376,15.99) AD13(-7.813,16.377) AD14(-8.463,16.377) AD29(-20.725,16.777) AD30(-21.376,16.777) AE13(-7.813,17.291) AE14(-8.463,17.291) AE29(-20.725,17.565) AE30(-21.376,17.565) AF13(-7.813,18.206) AF14(-8.463,18.206) AF29(-20.725,18.352) AF30(-21.376,18.352) AG13(-7.813,19.12) AG14(-8.463,19.12) AG29(-20.725,19.14) AG30(-21.376,19.14) AH13(-7.813,20.035) AH14(-8.463,20.035) AH29(-20.725,19.927) AH30(-21.376,19.927) AJ13(-7.813,20.949) AJ14(-8.463,20.949) AJ29(-20.725,20.714) AJ30(-21.376,20.714) AK29(-20.725,21.502) AK30(-21.376,21.502) AL13(-7.813,21.863) AL14(-8.463,21.863) AL29(-20.725,22.289) AL30(-21.376,22.289) AM13(-7.813,22.778) AM14(-8.463,22.778) AM29(-20.725,23.077) AM30(-21.376,23.077) AN13(-7.813,23.692) AN14(-8.463,23.692) AN29(-20.725,23.864) AN30(-21.376,23.864) AP13(-7.813,24.607) AP14(-8.463,24.607) AP29(-20.725,24.651) AP30(-21.376,24.651) AR13(-7.813,25.521) AR14(-8.463,25.521) AR29(-20.725,25.439) AR30(-21.376,25.439) AT13(-7.813,26.435) AT14(-8.463,26.435) AT29(-20.725,26.226) AT30(-21.376,26.226) AU13(-7.813,27.35) AU14(-8.463,27.35) AU29(-20.725,27.014) AU30(-21.376,27.014) AV29(-20.725,27.801) AV30(-21.376,27.801) AW13(-7.813,28.264) AW14(-8.463,28.264) AW29(-20.725,28.588) AW30(-21.376,28.588) AY13(-7.813,29.179) AY14(-8.463,29.179) AY29(-20.725,29.376) AY30(-21.376,29.376) B3(-1.382,0.699) B37(-25.909,0.703) BA13(-7.813,30.093) BA14(-8.463,30.093) BA29(-20.725,30.163) BA30(-21.376,30.163) BB13(-7.813,31.007) BB14(-8.463,31.007) BB29(-20.725,30.951) BB30(-21.376,30.951) BC13(-7.813,31.922) BC14(-8.463,31.922) BC29(-20.725,31.738) BC30(-21.376,31.738) BD13(-7.813,32.836) BD14(-8.463,32.836) BD29(-20.725,32.525) BD30(-21.376,32.525) BE29(-20.725,33.313) BE30(-21.376,33.313) BF13(-7.813,33.751) BF14(-8.463,33.751) BF29(-20.725,34.1) BF30(-21.376,34.1) BG13(-7.813,34.665) BG14(-8.463,34.665) BG29(-20.725,34.888) BG30(-21.376,34.888) BH13(-7.813,35.579) BH14(-8.463,35.541) BH29(-20.725,35.548) BH30(-21.376,35.675) BJ13(-8.171,36.126) BJ14(-8.851,36.077) BJ15(-9.601,36.077) BJ16(-10.388,36.077) BJ17(-11.175,36.077) BJ18(-11.963,36.077) BJ19(-12.75,36.077) BJ20(-13.538,36.077) BJ21(-14.325,36.077) BJ22(-15.112,36.077) BJ23(-15.9,36.077) BJ24(-16.687,36.077) BJ25(-17.475,36.077) BJ26(-18.262,36.077) BJ27(-19.049,36.077) BJ28(-19.837,36.077) BJ29(-20.497,36.158) BJ30(-21.353,36.329) BK14(-8.813,36.727) BK15(-9.601,36.727) BK16(-10.388,36.727) BK17(-11.175,36.727) BK18(-11.963,36.727) BK19(-12.75,36.727) BK20(-13.538,36.727) BK21(-14.325,36.727) BK22(-15.112,36.727) BK23(-15.9,36.727) BK24(-16.687,36.727) BK25(-17.475,36.727) BK26(-18.262,36.727) BK27(-19.049,36.727) BK28(-19.837,36.727) BK29(-20.833,36.735) BN1(0,38.614) BN38(-26.628,38.599) BP1(0,39.338) BP38(-26.628,39.31) BR2(-0.719,39.934) BR37(-25.904,39.927) BT3(-1.295,40.628) BT4(-2.019,40.628) BT35(-24.498,40.628) BT36(-25.311,40.628) C2(-0.699,1.361) C38(-26.628,1.334) D1(0,1.991) D38(-26.628,2.097) H13(-8.255,4.602) H14(-9.042,4.602) H15(-9.83,4.602) H16(-10.617,4.602) H17(-11.405,4.602) H18(-12.192,4.602) H19(-12.979,4.602) H20(-13.767,4.602) H21(-14.554,4.602) H22(-15.342,4.602) H23(-16.129,4.602) H24(-16.916,4.602) H25(-17.704,4.602) H26(-18.491,4.602) H27(-19.279,4.602) H28(-20.066,4.602) H29(-20.853,4.552) J14(-9.042,5.253) J15(-9.83,5.253) J16(-10.617,5.253) J17(-11.405,5.253) J18(-12.192,5.253) J19(-12.979,5.253) J20(-13.767,5.253) J21(-14.554,5.253) J22(-15.342,5.253) J23(-16.129,5.253) J24(-16.916,5.253) J25(-17.704,5.253) J26(-18.491,5.253) J27(-19.279,5.253) J28(-20.066,5.253) J30(-21.061,5.168) K13(-7.879,5.176) K14(-8.463,5.658) K29(-20.725,5.754) K30(-21.376,5.754) L13(-7.813,6.319) L14(-8.463,6.319) L29(-20.725,6.541) L30(-21.376,6.541) M13(-7.813,7.233) M14(-8.463,7.233) M29(-20.725,7.329) M30(-21.376,7.329) N13(-7.813,8.147) N14(-8.463,8.147) N29(-20.725,8.116) N30(-21.376,8.116) P13(-7.813,9.062) P14(-8.463,9.062) P29(-20.725,8.903) P30(-21.376,8.903) R13(-7.813,9.976) R14(-8.463,9.976) R29(-20.725,9.691) R30(-21.376,9.691) T13(-7.813,10.891) T14(-8.463,10.891) T29(-20.725,10.478) T30(-21.376,10.478) U29(-20.725,11.266) U30(-21.376,11.266) V13(-7.813,11.805) V14(-8.463,11.805) V29(-20.725,12.053) V30(-21.376,12.053) W13(-7.813,12.719) W14(-8.463,12.719) W29(-20.725,12.84) W30(-21.376,12.84) Y13(-7.813,13.634) Y14(-8.463,13.634) Y29(-20.725,13.628) Y30(-21.376,13.628)
  round 0.356 smd: A5(-2.771,0) A33(-23.66,0) B4(-2.031,0.971) B36(-25.198,0.701) BM1(0,37.814) BM38(-26.628,37.888) BP2(-0.828,39.28) BP37(-25.689,39.257) BR3(-1.387,39.978) BR36(-25.193,39.971) BT5(-2.819,40.628) BT34(-23.698,40.628) C37(-25.908,1.402) D3(-1.233,1.822) E1(0,2.779) E38(-26.628,2.897)
  round 0.33 smd: A6(-3.546,0) A32(-22.872,0) AA11(-6.512,14.548) AA12(-7.162,14.548) AC11(-6.512,15.463) AC12(-7.162,15.463) AD11(-6.512,16.377) AD12(-7.162,16.377) AE11(-6.512,17.291) AE12(-7.162,17.291) AF11(-6.512,18.206) AF12(-7.162,18.206) AG11(-6.512,19.12) AG12(-7.162,19.12) AH11(-6.512,20.035) AH12(-7.162,20.035) AJ11(-6.512,20.949) AJ12(-7.162,20.949) AL11(-6.512,21.863) AL12(-7.162,21.863) AM11(-6.512,22.778) AM12(-7.162,22.778) AN11(-6.512,23.692) AN12(-7.162,23.692) AP11(-6.512,24.607) AP12(-7.162,24.607) AR11(-6.512,25.521) AR12(-7.162,25.521) AT11(-6.512,26.435) AT12(-7.162,26.435) AU11(-6.512,27.35) AU12(-7.162,27.35) AW11(-6.512,28.264) AW12(-7.162,28.264) AY11(-6.512,29.179) AY12(-7.162,29.179) B5(-2.743,0.65) B34(-24.443,0.67) BA11(-6.512,30.093) BA12(-7.162,30.093) BB11(-6.512,31.007) BB12(-7.162,31.007) BC11(-6.512,31.922) BC12(-7.162,31.922) BD11(-6.512,32.836) BD12(-7.162,32.836) BF11(-6.512,33.751) BF12(-7.162,33.751) BG11(-6.512,34.665) BG12(-7.162,34.665) BH11(-6.512,35.579) BH12(-7.162,35.579) BJ11(-6.512,36.494) BJ12(-7.282,36.405) BK1(0,37.037) BK13(-7.899,36.727) BL38(-26.628,37.176) BN2(-0.65,38.642) BN37(-25.965,38.665) BR5(-2.166,39.984) BR35(-24.536,39.978) BT6(-3.594,40.628) BT32(-22.923,40.628) D37(-25.603,1.985) E2(-0.65,2.474) G1(0,3.581) G38(-26.628,3.671) K11(-6.512,5.48) K12(-7.162,5.48) L11(-6.512,6.319) L12(-7.162,6.319) M11(-6.512,7.233) M12(-7.162,7.233) N11(-6.512,8.147) N12(-7.162,8.147) P11(-6.512,9.062) P12(-7.162,9.062) R11(-6.512,9.976) R12(-7.162,9.976) T11(-6.512,10.891) T12(-7.162,10.891) V11(-6.512,11.805) V12(-7.162,11.805) W11(-6.512,12.719) W12(-7.162,12.719) Y11(-6.512,13.634) Y12(-7.162,13.634)
  round 0.305 smd: A8(-4.318,0) A9(-5.105,0) A10(-5.893,0) A11(-6.68,0) A12(-7.468,0) A13(-8.255,0) A14(-9.042,0) A15(-9.83,0) A16(-10.617,0) A17(-11.405,0) A18(-12.192,0) A19(-12.979,0) A20(-13.767,0) A21(-14.554,0) A22(-15.342,0) A23(-16.129,0) A24(-16.916,0) A25(-17.704,0) A26(-18.491,0) A27(-19.279,0) A28(-20.066,0) A29(-20.853,0) A30(-21.844,0) AA1(0,14.019) AA2(-0.65,14.019) AA3(-1.3,14.019) AA4(-1.951,14.019) AA5(-2.601,14.019) AA6(-3.251,13.968) AA7(-3.911,14.548) AA8(-4.561,14.548) AA9(-5.212,14.548) AA10(-5.862,14.548) AA31(-22.077,14.415) AA32(-22.727,14.415) AA33(-23.377,14.415) AA34(-24.027,14.415) AA35(-24.678,14.415) AA36(-25.328,14.415) AA37(-25.978,14.415) AA38(-26.628,14.415) AB1(0,14.756) AB2(-0.65,14.756) AB3(-1.3,14.756) AB4(-1.951,14.756) AB5(-2.601,14.756) AB6(-3.251,14.806) AB31(-22.077,15.203) AB32(-22.727,15.203) AB33(-23.377,15.203) AB34(-24.027,15.203) AB35(-24.678,15.203) AB36(-25.328,15.203) AB37(-25.978,15.203) AB38(-26.628,15.203) AC1(0,15.645) AC2(-0.65,15.645) AC3(-1.3,15.645) AC4(-1.951,15.645) AC5(-2.601,15.645) AC6(-3.251,15.645) AC7(-3.911,15.463) AC8(-4.561,15.463) AC9(-5.212,15.463) AC10(-5.862,15.463) AC31(-22.077,15.99) AC32(-22.727,15.99) AC33(-23.377,15.99) AC34(-24.027,15.99) AC35(-24.678,15.99) AC36(-25.328,15.99) AC37(-25.978,15.99) AC38(-26.628,15.99) AD1(0,16.534) AD2(-0.65,16.534) AD3(-1.3,16.534) AD4(-1.951,16.534) AD5(-2.601,16.534) AD6(-3.251,16.483) AD7(-3.911,16.377) AD8(-4.561,16.377) AD9(-5.212,16.377) AD10(-5.862,16.377) AD31(-22.077,16.777) AD32(-22.727,16.777) AD33(-23.377,16.777) AD34(-24.027,16.777) AD35(-24.678,16.777) AD36(-25.328,16.777) AD37(-25.978,16.777) AD38(-26.628,16.777) AE1(0,17.27) AE2(-0.65,17.27) AE3(-1.3,17.27) AE4(-1.951,17.27) AE5(-2.601,17.27) AE6(-3.251,17.321) AE7(-3.911,17.291) AE8(-4.561,17.291) AE9(-5.212,17.291) AE10(-5.862,17.291) AE31(-22.077,17.565) AE32(-22.727,17.565) AE33(-23.377,17.565) AE34(-24.027,17.565) AE35(-24.678,17.565) AE36(-25.328,17.565) AE37(-25.978,17.565) AE38(-26.628,17.565) AF1(0,18.159) AF2(-0.65,18.159) AF3(-1.3,18.159) AF4(-1.951,18.159) AF5(-2.601,18.159) AF6(-3.251,18.159) AF7(-3.911,18.206) AF8(-4.561,18.206) AF9(-5.212,18.206) AF10(-5.862,18.206) AF31(-22.077,18.352) AF32(-22.727,18.352) AF33(-23.377,18.352) AF34(-24.027,18.352) AF35(-24.678,18.352) AF36(-25.328,18.352) AF37(-25.978,18.352) AF38(-26.628,18.352) AG1(0,19.048) AG2(-0.65,19.048) AG3(-1.3,19.048) AG4(-1.951,19.048) AG5(-2.601,19.048) AG6(-3.251,18.997) AG7(-3.911,19.12) AG8(-4.561,19.12) AG9(-5.212,19.12) AG10(-5.862,19.12) AG31(-22.077,19.14) AG32(-22.727,19.14) AG33(-23.377,19.14) AG34(-24.027,19.14) AG35(-24.678,19.14) AG36(-25.328,19.14) AG37(-25.978,19.14) AG38(-26.628,19.14) AH1(0,19.785) AH2(-0.65,19.785) AH3(-1.3,19.785) AH4(-1.951,19.785) AH5(-2.601,19.785) AH6(-3.251,19.836) AH7(-3.911,20.035) AH8(-4.561,20.035) AH9(-5.212,20.035) AH10(-5.862,20.035) AH31(-22.077,19.927) AH32(-22.727,19.927) AH33(-23.377,19.927) AH34(-24.027,19.927) AH35(-24.678,19.927) AH36(-25.328,19.927) AH37(-25.978,19.927) AH38(-26.628,19.927) AJ1(0,20.674) AJ2(-0.65,20.674) AJ3(-1.3,20.674) AJ4(-1.951,20.674) AJ5(-2.601,20.674) AJ6(-3.251,20.674) AJ7(-3.911,20.949) AJ8(-4.561,20.949) AJ9(-5.212,20.949) AJ10(-5.862,20.949) AJ31(-22.077,20.714) AJ32(-22.727,20.714) AJ33(-23.377,20.714) AJ34(-24.027,20.714) AJ35(-24.678,20.714) AJ36(-25.328,20.714) AJ37(-25.978,20.714) AJ38(-26.628,20.714) AK1(0,21.563) AK2(-0.65,21.563) AK3(-1.3,21.563) AK4(-1.951,21.563) AK5(-2.601,21.563) AK6(-3.251,21.512) AK31(-22.077,21.502) AK32(-22.727,21.502) AK33(-23.377,21.502) AK34(-24.027,21.502) AK35(-24.678,21.502) AK36(-25.328,21.502) AK37(-25.978,21.502) AK38(-26.628,21.502) AL1(0,22.299) AL2(-0.65,22.299) AL3(-1.3,22.299) AL4(-1.951,22.299) AL5(-2.601,22.299) AL6(-3.251,22.35) AL7(-3.911,21.863) AL8(-4.561,21.863) AL9(-5.212,21.863) AL10(-5.862,21.863) AL31(-22.077,22.289) AL32(-22.727,22.289) AL33(-23.377,22.289) AL34(-24.027,22.289) AL35(-24.678,22.289) AL36(-25.328,22.289) AL37(-25.978,22.289) AL38(-26.628,22.289) AM1(0,23.188) AM2(-0.65,23.188) AM3(-1.3,23.188) AM4(-1.951,23.188) AM5(-2.601,23.188) AM6(-3.251,23.188) AM7(-3.911,22.778) AM8(-4.561,22.778) AM9(-5.212,22.778) AM10(-5.862,22.778) AM31(-22.077,23.077) AM32(-22.727,23.077) AM33(-23.377,23.077) AM34(-24.027,23.077) AM35(-24.678,23.077) AM36(-25.328,23.077) AM37(-25.978,23.077) AM38(-26.628,23.077) AN1(0,24.077) AN2(-0.65,24.077) AN3(-1.3,24.077) AN4(-1.951,24.077) AN5(-2.601,24.077) AN6(-3.251,24.027) AN7(-3.911,23.692) AN8(-4.561,23.692) AN9(-5.212,23.692) AN10(-5.862,23.692) AN31(-22.077,23.864) AN32(-22.727,23.864) AN33(-23.377,23.864) AN34(-24.027,23.864) AN35(-24.678,23.864) AN36(-25.328,23.864) AN37(-25.978,23.864) AN38(-26.628,23.864) AP1(0,24.814) AP2(-0.65,24.814) AP3(-1.3,24.814) AP4(-1.951,24.814) AP5(-2.601,24.814) AP6(-3.251,24.865) AP7(-3.911,24.607) AP8(-4.561,24.607) AP9(-5.212,24.607) AP10(-5.862,24.607) AP31(-22.077,24.651) AP32(-22.727,24.651) AP33(-23.377,24.651) AP34(-24.027,24.651) AP35(-24.678,24.651) AP36(-25.328,24.651) AP37(-25.978,24.651) AP38(-26.628,24.651) AR1(0,25.703) AR2(-0.65,25.703) AR3(-1.3,25.703) AR4(-1.951,25.703) AR5(-2.601,25.703) AR6(-3.251,25.703) AR7(-3.911,25.521) AR8(-4.561,25.521) AR9(-5.212,25.521) AR10(-5.862,25.521) AR31(-22.077,25.439) AR32(-22.727,25.439) AR33(-23.377,25.439) AR34(-24.027,25.439) AR35(-24.678,25.439) AR36(-25.328,25.439) AR37(-25.978,25.439) AR38(-26.628,25.439) AT1(0,26.592) AT2(-0.65,26.592) AT3(-1.3,26.592) AT4(-1.951,26.592) AT5(-2.601,26.592) AT6(-3.251,26.541) AT7(-3.911,26.435) AT8(-4.561,26.435) AT9(-5.212,26.435) AT10(-5.862,26.435) AT31(-22.077,26.226) AT32(-22.727,26.226) AT33(-23.377,26.226) AT34(-24.027,26.226) AT35(-24.678,26.226) AT36(-25.328,26.226) AT37(-25.978,26.226) AT38(-26.628,26.226) AU1(0,27.329) AU2(-0.65,27.329) AU3(-1.3,27.329) AU4(-1.951,27.329) AU5(-2.601,27.329) AU6(-3.251,27.379) AU7(-3.911,27.35) AU8(-4.561,27.35) AU9(-5.212,27.35) AU10(-5.862,27.35) AU31(-22.077,27.014) AU32(-22.727,27.014) AU33(-23.377,27.014) AU34(-24.027,27.014) AU35(-24.678,27.014) AU36(-25.328,27.014) AU37(-25.978,27.014) AU38(-26.628,27.014) AV31(-22.077,27.801) AV32(-22.727,27.801) AV33(-23.377,27.801) AV34(-24.027,27.801) AV35(-24.678,27.801) AV36(-25.328,27.801) AV37(-25.978,27.801) AV38(-26.628,27.801) AW1(0,28.218) AW2(-0.65,28.218) AW3(-1.3,28.218) AW4(-1.951,28.218) AW5(-2.601,28.218) AW6(-3.251,28.218) AW7(-3.911,28.264) AW8(-4.561,28.264) AW9(-5.212,28.264) AW10(-5.862,28.264) AW31(-22.077,28.588) AW32(-22.727,28.588) AW33(-23.377,28.588) AW34(-24.027,28.588) AW35(-24.678,28.588) AW36(-25.328,28.588) AW37(-25.978,28.588) AW38(-26.628,28.588) AY1(0,29.107) AY2(-0.65,29.107) AY3(-1.3,29.107) AY4(-1.951,29.107) AY5(-2.601,29.107) AY6(-3.251,29.056) AY7(-3.911,29.179) AY8(-4.561,29.179) AY9(-5.212,29.179) AY10(-5.862,29.179) AY31(-22.077,29.376) AY32(-22.727,29.376) AY33(-23.377,29.376) AY34(-24.027,29.376) AY35(-24.678,29.376) AY36(-25.328,29.376) AY37(-25.978,29.376) AY38(-26.628,29.376) B6(-3.531,0.65) B8(-4.318,0.65) B9(-5.105,0.65) B10(-5.893,0.65) B11(-6.68,0.65) B12(-7.468,0.65) B13(-8.255,0.65) B14(-9.042,0.65) B15(-9.83,0.65) B16(-10.617,0.65) B17(-11.405,0.65) B18(-12.192,0.65) B19(-12.979,0.65) B20(-13.767,0.65) B21(-14.554,0.65) B22(-15.342,0.65) B23(-16.129,0.65) B24(-16.916,0.65) B25(-17.704,0.65) B26(-18.491,0.65) B27(-19.279,0.65) B28(-20.066,0.65) B29(-20.853,0.65) B30(-21.641,0.65) B31(-22.428,0.65) B33(-23.216,0.65) BA1(0,29.843) BA2(-0.65,29.843) BA3(-1.3,29.843) BA4(-1.951,29.843) BA5(-2.601,29.843) BA6(-3.251,29.894) BA7(-3.911,30.093) BA8(-4.561,30.093) BA9(-5.212,30.093) BA10(-5.862,30.093) BA31(-22.077,30.163) BA32(-22.727,30.163) BA33(-23.377,30.163) BA34(-24.027,30.163) BA35(-24.678,30.163) BA36(-25.328,30.163) BA37(-25.978,30.163) BA38(-26.628,30.163) BB1(0,30.732) BB2(-0.65,30.732) BB3(-1.3,30.732) BB4(-1.951,30.732) BB5(-2.601,30.732) BB6(-3.251,30.732) BB7(-3.911,31.007) BB8(-4.561,31.007) BB9(-5.212,31.007) BB10(-5.862,31.007) BB31(-22.077,30.951) BB32(-22.727,30.951) BB33(-23.377,30.951) BB34(-24.027,30.951) BB35(-24.678,30.951) BB36(-25.328,30.951) BB37(-25.978,30.951) BB38(-26.628,30.951) BC1(0,31.621) BC2(-0.65,31.621) BC3(-1.3,31.621) BC4(-1.951,31.621) BC5(-2.601,31.621) BC6(-3.251,31.57) BC7(-3.911,31.922) BC8(-4.561,31.922) BC9(-5.212,31.922) BC10(-5.862,31.922) BC31(-22.077,31.738) BC32(-22.727,31.738) BC33(-23.377,31.738) BC34(-24.027,31.738) BC35(-24.678,31.738) BC36(-25.328,31.738) BC37(-25.978,31.738) BC38(-26.628,31.738) BD1(0,32.358) BD2(-0.65,32.358) BD3(-1.3,32.358) BD4(-1.951,32.358) BD5(-2.601,32.358) BD6(-3.251,32.409) BD7(-3.911,32.836) BD8(-4.561,32.836) BD9(-5.212,32.836) BD10(-5.862,32.836) BD31(-22.077,32.525) BD32(-22.727,32.525) BD33(-23.377,32.525) BD34(-24.027,32.525) BD35(-24.678,32.525) BD36(-25.328,32.525) BD37(-25.978,32.525) BD38(-26.628,32.525) BE1(0,33.247) BE2(-0.65,33.247) BE3(-1.3,33.247) BE4(-1.951,33.247) BE5(-2.601,33.247) BE6(-3.251,33.247) BE31(-22.077,33.313) BE32(-22.727,33.313) BE33(-23.377,33.313) BE34(-24.027,33.313) BE35(-24.678,33.313) BE36(-25.328,33.313) BE37(-25.978,33.313) BE38(-26.628,33.313) BF1(0,34.136) BF2(-0.65,34.136) BF3(-1.3,34.136) BF4(-1.951,34.136) BF5(-2.601,34.136) BF6(-3.251,34.085) BF7(-3.911,33.751) BF8(-4.561,33.751) BF9(-5.212,33.751) BF10(-5.862,33.751) BF31(-22.077,34.1) BF32(-22.727,34.1) BF33(-23.377,34.1) BF34(-24.027,34.1) BF35(-24.678,34.1) BF36(-25.328,34.1) BF37(-25.978,34.1) BF38(-26.628,34.1) BG1(0,34.872) BG2(-0.65,34.872) BG3(-1.3,34.872) BG4(-1.951,34.872) BG5(-2.601,34.872) BG6(-3.251,34.923) BG7(-3.911,34.665) BG8(-4.561,34.665) BG9(-5.212,34.665) BG10(-5.862,34.665) BG31(-22.077,34.888) BG32(-22.727,34.888) BG33(-23.377,34.888) BG34(-24.027,34.888) BG35(-24.678,34.888) BG36(-25.328,34.888) BG37(-25.978,34.888) BG38(-26.628,34.888) BH1(0,36.015) BH2(-0.65,35.761) BH3(-1.3,35.761) BH4(-1.951,35.761) BH5(-2.601,35.761) BH6(-3.251,35.761) BH7(-3.911,35.579) BH8(-4.561,35.579) BH9(-5.212,35.579) BH10(-5.862,35.579) BH31(-22.077,35.675) BH32(-22.727,35.675) BH33(-23.377,35.675) BH34(-24.027,35.675) BH35(-24.678,35.675) BH36(-25.328,35.675) BH37(-25.978,35.675) BH38(-26.628,35.675) BJ7(-3.911,36.494) BJ8(-4.561,36.494) BJ9(-5.212,36.494) BJ10(-5.862,36.494) BJ31(-22.077,36.462) BJ32(-22.727,36.462) BJ33(-23.377,36.462) BJ34(-24.027,36.462) BJ35(-24.678,36.462) BJ36(-25.328,36.462) BJ37(-25.978,36.462) BJ38(-26.628,36.412) BK2(-0.65,36.6) BK3(-1.3,36.6) BK4(-1.951,36.6) BK5(-2.601,36.6) BK6(-3.251,36.6) BL2(-0.65,37.438) BL3(-1.3,37.387) BL4(-1.951,37.387) BL5(-2.601,37.387) BL6(-3.251,37.438) BL7(-3.987,37.383) BL8(-4.876,37.377) BL9(-5.664,37.377) BL11(-6.451,37.377) BL12(-7.238,37.377) BL13(-8.026,37.377) BL14(-8.813,37.377) BL15(-9.601,37.377) BL16(-10.388,37.377) BL17(-11.175,37.377) BL18(-11.963,37.377) BL19(-12.75,37.377) BL20(-13.538,37.377) BL21(-14.325,37.377) BL22(-15.112,37.377) BL23(-15.9,37.377) BL24(-16.687,37.377) BL25(-17.475,37.377) BL26(-18.262,37.377) BL27(-19.049,37.377) BL28(-19.837,37.377) BL29(-20.624,37.377) BL30(-21.426,37.25) BL31(-22.077,37.25) BL32(-22.727,37.25) BL33(-23.377,37.25) BL34(-24.027,37.25) BL35(-24.678,37.25) BL36(-25.328,37.25) BL37(-25.978,37.25) BM2(-0.963,38.053) BM3(-1.613,38.129) BM5(-2.525,38.129) BM6(-3.169,38.231) BM7(-4.089,38.027) BM8(-4.876,38.027) BM9(-5.664,38.027) BM11(-6.451,38.027) BM12(-7.238,38.027) BM13(-8.026,38.027) BM14(-8.813,38.027) BM15(-9.601,38.027) BM16(-10.388,38.027) BM17(-11.175,38.027) BM18(-11.963,38.027) BM19(-12.75,38.027) BM20(-13.538,38.027) BM21(-14.325,38.027) BM22(-15.112,38.027) BM23(-15.9,38.027) BM24(-16.687,38.027) BM25(-17.475,38.027) BM26(-18.262,38.027) BM27(-19.049,38.027) BM28(-19.837,38.027) BM29(-20.624,38.027) BM30(-21.412,38.027) BM31(-22.199,38.027) BM33(-22.986,38.027) BM34(-23.774,38.027) BM35(-24.561,38.027) BM36(-25.328,37.986) BM37(-25.978,37.986) BN3(-1.3,38.701) BN4(-2.106,38.629) BN5(-2.748,38.793) BN7(-4.089,38.678) BN8(-4.876,38.678) BN9(-5.664,38.678) BN11(-6.451,38.678) BN12(-7.238,38.678) BN13(-8.026,38.678) BN14(-8.813,38.678) BN15(-9.601,38.678) BN16(-10.388,38.678) BN17(-11.175,38.678) BN18(-11.963,38.678) BN19(-12.75,38.678) BN20(-13.538,38.678) BN21(-14.325,38.678) BN22(-15.112,38.678) BN23(-15.9,38.678) BN24(-16.687,38.678) BN25(-17.475,38.678) BN26(-18.262,38.678) BN27(-19.049,38.678) BN28(-19.837,38.678) BN29(-20.624,38.678) BN30(-21.412,38.678) BN31(-22.199,38.678) BN33(-22.986,38.678) BN34(-23.774,38.678) BN35(-24.562,38.678) BN36(-25.314,38.638) BP3(-1.483,39.334) BP5(-2.374,39.351) BP6(-3.294,39.288) BP7(-4.089,39.328) BP8(-4.876,39.328) BP9(-5.664,39.328) BP11(-6.451,39.328) BP12(-7.238,39.328) BP13(-8.026,39.328) BP14(-8.813,39.328) BP15(-9.601,39.328) BP16(-10.388,39.328) BP17(-11.175,39.328) BP18(-11.963,39.328) BP19(-12.75,39.328) BP20(-13.538,39.328) BP21(-14.325,39.328) BP22(-15.112,39.328) BP23(-15.9,39.328) BP24(-16.687,39.328) BP25(-17.475,39.328) BP26(-18.262,39.328) BP27(-19.049,39.328) BP28(-19.837,39.328) BP29(-20.624,39.328) BP30(-21.412,39.328) BP31(-22.199,39.328) BP33(-22.986,39.328) BP34(-23.774,39.328) BP35(-24.561,39.328) BR6(-3.192,39.961) BR7(-4.089,39.978) BR8(-4.876,39.978) BR9(-5.664,39.978) BR11(-6.451,39.978) BR12(-7.238,39.978) BR13(-8.026,39.978) BR14(-8.813,39.978) BR15(-9.601,39.978) BR16(-10.388,39.978) BR17(-11.175,39.978) BR18(-11.963,39.978) BR19(-12.75,39.978) BR20(-13.538,39.978) BR21(-14.325,39.978) BR22(-15.112,39.978) BR23(-15.9,39.978) BR24(-16.687,39.978) BR25(-17.475,39.978) BR26(-18.262,39.978) BR27(-19.049,39.978) BR28(-19.837,39.978) BR29(-20.624,39.978) BR30(-21.412,39.978) BR31(-22.199,39.978) BR33(-22.986,39.978) BR34(-23.774,39.978) BT8(-4.648,40.628) BT9(-5.664,40.628) BT11(-6.451,40.628) BT12(-7.238,40.628) BT13(-8.026,40.628) BT14(-8.813,40.628) BT15(-9.601,40.628) BT16(-10.388,40.628) BT17(-11.175,40.628) BT18(-11.963,40.628) BT19(-12.75,40.628) BT20(-13.538,40.628) BT21(-14.325,40.628) BT22(-15.112,40.628) BT23(-15.9,40.628) BT24(-16.687,40.628) BT25(-17.475,40.628) BT26(-18.262,40.628) BT27(-19.049,40.628) BT28(-19.837,40.628) BT29(-20.624,40.628) BT30(-21.412,40.628) BT31(-22.174,40.628) C5(-2.743,1.3) C6(-3.531,1.3) C8(-4.318,1.3) C9(-5.105,1.3) C10(-5.893,1.3) C11(-6.68,1.3) C12(-7.468,1.3) C13(-8.255,1.3) C14(-9.042,1.3) C15(-9.83,1.3) C16(-10.617,1.3) C17(-11.405,1.3) C18(-12.192,1.3) C19(-12.979,1.3) C20(-13.767,1.3) C21(-14.554,1.3) C22(-15.342,1.3) C23(-16.129,1.3) C24(-16.916,1.3) C25(-17.704,1.3) C26(-18.491,1.3) C27(-19.279,1.3) C28(-20.066,1.3) C29(-20.853,1.3) C30(-21.641,1.3) C31(-22.428,1.3) C33(-23.216,1.3) C34(-24.011,1.29) C36(-25.145,1.388) D4(-1.894,1.655) D5(-2.743,1.951) D6(-3.531,1.951) D8(-4.318,1.951) D9(-5.105,1.951) D10(-5.893,1.951) D11(-6.68,1.951) D12(-7.468,1.951) D13(-8.255,1.951) D14(-9.042,1.951) D15(-9.83,1.951) D16(-10.617,1.951) D17(-11.405,1.951) D18(-12.192,1.951) D19(-12.979,1.951) D20(-13.767,1.951) D21(-14.554,1.951) D22(-15.342,1.951) D23(-16.129,1.951) D24(-16.916,1.951) D25(-17.704,1.951) D26(-18.491,1.951) D27(-19.279,1.951) D28(-20.066,1.951) D29(-20.853,1.951) D30(-21.641,1.951) D31(-22.428,1.951) D33(-23.216,1.951) D34(-24.003,1.951) D35(-24.655,1.861) E3(-1.3,2.474) E4(-1.951,2.575) E5(-2.743,2.601) E6(-3.531,2.601) E8(-4.318,2.601) E9(-5.105,2.601) E10(-5.893,2.601) E11(-6.68,2.601) E12(-7.468,2.601) E13(-8.255,2.601) E14(-9.042,2.601) E15(-9.83,2.601) E16(-10.617,2.601) E17(-11.405,2.601) E18(-12.192,2.601) E19(-12.979,2.601) E20(-13.767,2.601) E21(-14.554,2.601) E22(-15.342,2.601) E23(-16.129,2.601) E24(-16.916,2.601) E25(-17.704,2.601) E26(-18.491,2.601) E27(-19.279,2.601) E28(-20.066,2.601) E29(-20.853,2.601) E30(-21.641,2.601) E31(-22.428,2.601) E33(-23.216,2.601) E34(-24.003,2.601) E35(-24.678,2.604) E36(-25.328,2.604) E37(-25.978,2.604) F2(-0.65,3.16) F3(-1.3,3.16) F4(-1.951,3.261) F5(-2.743,3.273) F6(-3.531,3.273) F8(-4.318,3.251) F9(-5.105,3.251) F10(-5.893,3.251) F11(-6.68,3.251) F12(-7.468,3.251) F13(-8.255,3.251) F14(-9.042,3.251) F15(-9.83,3.251) F16(-10.617,3.251) F17(-11.405,3.251) F18(-12.192,3.251) F19(-12.979,3.251) F20(-13.767,3.251) F21(-14.554,3.251) F22(-15.342,3.251) F23(-16.129,3.251) F24(-16.916,3.251) F25(-17.704,3.251) F26(-18.491,3.251) F27(-19.279,3.251) F28(-20.066,3.251) F29(-20.853,3.251) F30(-21.641,3.251) F31(-22.428,3.251) F33(-23.216,3.251) F34(-24.027,3.392) F35(-24.678,3.392) F36(-25.328,3.392) F37(-25.978,3.392) G2(-0.65,3.947) G3(-1.3,3.947) G4(-1.951,3.947) G5(-2.601,3.947) G6(-3.251,3.947) G8(-4.318,3.901) G9(-5.105,3.901) G10(-5.893,3.901) G11(-6.68,3.901) G12(-7.468,3.901) G13(-8.255,3.901) G14(-9.042,3.901) G15(-9.83,3.901) G16(-10.617,3.901) G17(-11.405,3.901) G18(-12.192,3.901) G19(-12.979,3.901) G20(-13.767,3.901) G21(-14.554,3.901) G22(-15.342,3.901) G23(-16.129,3.901) G24(-16.916,3.901) G25(-17.704,3.901) G26(-18.491,3.901) G27(-19.279,3.901) G28(-20.066,3.901) G29(-20.853,3.901) G30(-21.641,3.901) H1(0,4.443) H11(-6.68,4.552) H12(-7.468,4.552) H30(-21.603,4.552) H32(-22.727,4.179) H33(-23.377,4.179) H34(-24.027,4.179) H35(-24.678,4.179) H36(-25.328,4.179) H37(-25.978,4.179) J2(-0.65,4.748) J3(-1.3,4.748) J4(-1.951,4.748) J5(-2.601,4.748) J6(-3.251,4.748) J7(-3.893,4.619) J8(-4.541,4.716) J9(-5.212,4.693) J10(-5.893,4.628) J31(-22.077,5.005) J32(-22.727,4.966) J33(-23.377,4.966) J34(-24.027,4.966) J35(-24.678,4.966) J36(-25.328,4.966) J37(-25.978,4.966) J38(-26.628,4.712) K1(0,5.586) K2(-0.65,5.586) K3(-1.3,5.586) K4(-1.951,5.586) K5(-2.601,5.586) K6(-3.251,5.586) K7(-3.911,5.557) K8(-4.561,5.48) K9(-5.212,5.48) K10(-5.862,5.48) K31(-22.077,5.754) K32(-22.727,5.754) K33(-23.377,5.754) K34(-24.027,5.754) K35(-24.678,5.754) K36(-25.328,5.754) K37(-25.978,5.754) K38(-26.628,5.754) L1(0,6.475) L2(-0.65,6.475) L3(-1.3,6.475) L4(-1.951,6.475) L5(-2.601,6.475) L6(-3.251,6.424) L7(-3.911,6.395) L8(-4.561,6.344) L9(-5.212,6.319) L10(-5.862,6.319) L31(-22.077,6.541) L32(-22.727,6.541) L33(-23.377,6.541) L34(-24.027,6.541) L35(-24.678,6.541) L36(-25.328,6.541) L37(-25.978,6.541) L38(-26.628,6.541) M1(0,7.212) M2(-0.65,7.212) M3(-1.3,7.212) M4(-1.951,7.212) M5(-2.601,7.212) M6(-3.251,7.263) M7(-3.911,7.233) M8(-4.561,7.233) M9(-5.212,7.233) M10(-5.862,7.233) M31(-22.077,7.329) M32(-22.727,7.329) M33(-23.377,7.329) M34(-24.027,7.329) M35(-24.678,7.329) M36(-25.328,7.329) M37(-25.978,7.329) M38(-26.628,7.329) N1(0,8.101) N2(-0.65,8.101) N3(-1.3,8.101) N4(-1.951,8.101) N5(-2.601,8.101) N6(-3.251,8.101) N7(-3.911,8.147) N8(-4.561,8.147) N9(-5.212,8.147) N10(-5.862,8.147) N31(-22.077,8.116) N32(-22.727,8.116) N33(-23.377,8.116) N34(-24.027,8.116) N35(-24.678,8.116) N36(-25.328,8.116) N37(-25.978,8.116) N38(-26.628,8.116) P1(0,8.99) P2(-0.65,8.99) P3(-1.3,8.99) P4(-1.951,8.99) P5(-2.601,8.99) P6(-3.251,8.939) P7(-3.911,9.062) P8(-4.561,9.062) P9(-5.212,9.062) P10(-5.862,9.062) P31(-22.077,8.903) P32(-22.727,8.903) P33(-23.377,8.903) P34(-24.027,8.903) P35(-24.678,8.903) P36(-25.328,8.903) P37(-25.978,8.903) P38(-26.628,8.903) R1(0,9.726) R2(-0.65,9.726) R3(-1.3,9.726) R4(-1.951,9.726) R5(-2.601,9.726) R6(-3.251,9.777) R7(-3.911,9.976) R8(-4.561,9.976) R9(-5.212,9.976) R10(-5.862,9.976) R31(-22.077,9.691) R32(-22.727,9.691) R33(-23.377,9.691) R34(-24.027,9.691) R35(-24.678,9.691) R36(-25.328,9.691) R37(-25.978,9.691) R38(-26.628,9.691) T1(0,10.615) T2(-0.65,10.615) T3(-1.3,10.615) T4(-1.951,10.615) T5(-2.601,10.615) T6(-3.251,10.615) T7(-3.911,10.891) T8(-4.561,10.891) T9(-5.212,10.891) T10(-5.862,10.891) T31(-22.077,10.478) T32(-22.727,10.478) T33(-23.377,10.478) T34(-24.027,10.478) T35(-24.678,10.478) T36(-25.328,10.478) T37(-25.978,10.478) T38(-26.628,10.478) U1(0,11.504) U2(-0.65,11.504) U3(-1.3,11.504) U4(-1.951,11.504) U5(-2.601,11.504) U6(-3.251,11.454) U31(-22.077,11.266) U32(-22.727,11.266) U33(-23.377,11.266) U34(-24.027,11.266) U35(-24.678,11.266) U36(-25.328,11.266) U37(-25.978,11.266) U38(-26.628,11.266) V1(0,12.241) V2(-0.65,12.241) V3(-1.3,12.241) V4(-1.951,12.241) V5(-2.601,12.241) V6(-3.251,12.292) V7(-3.911,11.805) V8(-4.561,11.805) V9(-5.212,11.805) V10(-5.862,11.805) V31(-22.077,12.053) V32(-22.727,12.053) V33(-23.377,12.053) V34(-24.027,12.053) V35(-24.678,12.053) V36(-25.328,12.053) V37(-25.978,12.053) V38(-26.628,12.053) W1(0,13.13) W2(-0.65,13.13) W3(-1.3,13.13) W4(-1.951,13.13) W5(-2.601,13.13) W6(-3.251,13.13) W7(-3.911,12.719) W8(-4.561,12.719) W9(-5.212,12.719) W10(-5.862,12.719) W31(-22.077,12.84) W32(-22.727,12.84) W33(-23.377,12.84) W34(-24.027,12.84) W35(-24.678,12.84) W36(-25.328,12.84) W37(-25.978,12.84) W38(-26.628,12.84) Y7(-3.911,13.634) Y8(-4.561,13.634) Y9(-5.212,13.634) Y10(-5.862,13.634) Y31(-22.077,13.628) Y32(-22.727,13.628) Y33(-23.377,13.628) Y34(-24.027,13.628) Y35(-24.678,13.628) Y36(-25.328,13.628) Y37(-25.978,13.628) Y38(-26.628,13.628)
SKY-S-PCH_BGA_837P-T
  round 0.305 smd: A2(-0.354,0) A3(-0.854,0) A4(-1.355,0) A42(-20.273,0) A43(-20.773,0) A44(-21.274,0) AA17(-7.715,10.039) AA18(-8.49,10.039) AA20(-9.264,10.039) AA21(-10.039,10.039) AA23(-10.814,10.039) AA25(-11.588,10.039) AA26(-12.363,10.039) AA28(-13.138,10.039) AA29(-13.913,10.039) AB7(-2.638,10.147) AB8(-3.4,10.147) AB10(-4.162,10.147) AB11(-4.924,10.147) AB13(-5.686,10.147) AB14(-6.448,10.147) AB15(-7.007,10.147) AB31(-14.62,10.147) AB32(-15.179,10.147) AB33(-15.941,10.147) AB35(-16.703,10.147) AB36(-17.465,10.147) AB38(-18.227,10.147) AB39(-18.989,10.147) AC17(-7.715,10.814) AC18(-8.49,10.814) AC20(-9.264,10.814) AC21(-10.039,10.814) AC23(-10.814,10.814) AC25(-11.588,10.814) AC26(-12.363,10.814) AC28(-13.138,10.814) AC29(-13.913,10.814) AD7(-2.638,11.481) AD8(-3.4,11.481) AD10(-4.162,11.481) AD11(-4.924,11.481) AD13(-5.686,11.481) AD14(-6.448,11.481) AD15(-7.007,11.481) AD31(-14.62,11.481) AD32(-15.179,11.481) AD33(-15.941,11.481) AD35(-16.703,11.481) AD36(-17.465,11.481) AD38(-18.227,11.481) AD39(-18.989,11.481) AE17(-7.715,11.588) AE18(-8.49,11.588) AE20(-9.264,11.588) AE21(-10.039,11.588) AE23(-10.814,11.588) AE25(-11.588,11.588) AE26(-12.363,11.588) AE28(-13.138,11.588) AE29(-13.913,11.588) AF17(-7.715,12.363) AF18(-8.49,12.363) AF20(-9.264,12.363) AF21(-10.039,12.363) AF23(-10.814,12.363) AF25(-11.588,12.363) AF26(-12.363,12.363) AF28(-13.138,12.363) AF29(-13.913,12.363) AG7(-2.638,12.586) AG8(-3.4,12.586) AG10(-4.162,12.586) AG11(-4.924,12.586) AG13(-5.686,12.586) AG14(-6.448,12.586) AG15(-7.007,12.586) AG31(-14.62,12.586) AG32(-15.179,12.586) AG33(-15.941,12.586) AG35(-16.703,12.586) AG36(-17.465,12.586) AG38(-18.227,12.586) AG39(-18.989,12.586) AH17(-7.715,13.138) AH18(-8.49,13.138) AH20(-9.264,13.138) AH21(-10.039,13.138) AH23(-10.814,13.138) AH25(-11.588,13.138) AH26(-12.363,13.138) AH28(-13.138,13.138) AH29(-13.913,13.138) AJ7(-2.74,13.767) AJ8(-3.502,13.767) AJ10(-4.264,13.767) AJ11(-5.026,13.767) AJ13(-5.788,13.767) AJ14(-6.499,13.767) AJ15(-7.007,13.767) AJ17(-7.715,13.913) AJ18(-8.49,13.913) AJ20(-9.264,13.913) AJ21(-10.039,13.913) AJ23(-10.814,13.913) AJ25(-11.588,13.913) AJ26(-12.363,13.913) AJ28(-13.138,13.913) AJ29(-13.913,13.913) AJ31(-14.62,13.767) AJ32(-15.179,13.767) AJ33(-15.941,13.767) AJ35(-16.703,13.767) AJ36(-17.465,13.767) AJ38(-18.227,13.767) AJ39(-18.989,13.767) AL7(-2.74,14.885) AL8(-3.502,14.885) AL10(-4.264,14.885) AL11(-5.026,14.885) AL13(-5.788,14.885) AL17(-7.861,14.62) AL19(-9.042,14.62) AL22(-10.147,14.62) AL24(-11.481,14.62) AL27(-12.586,14.62) AL29(-13.767,14.62) AL32(-15.154,14.91) AL33(-15.916,14.91) AL35(-16.678,14.91) AL36(-17.44,14.91) AL38(-18.202,14.91) AL39(-18.964,14.91) AM15(-6.718,15.154) AM17(-7.861,15.179) AM19(-9.042,15.179) AM22(-10.147,15.179) AM24(-11.481,15.179) AM27(-12.586,15.179) AM29(-13.767,15.128) AN7(-2.791,15.85) AN8(-3.553,15.799) AN10(-4.315,15.799) AN11(-5.061,15.84) AN15(-6.718,15.916) AN17(-7.861,15.941) AN19(-9.042,15.941) AN22(-10.147,15.941) AN24(-11.481,15.941) AN27(-12.586,15.941) AN29(-13.767,15.84) AN31(-14.885,15.84) AN36(-17.284,15.901) AN38(-18.046,15.901) AN39(-18.808,15.901) AP11(-4.774,16.365) AR7(-2.815,16.851) AR9(-3.73,16.891) AR15(-6.718,16.678) AR17(-7.861,16.703) AR19(-9.042,16.703) AR22(-10.147,16.703) AR24(-11.481,16.703) AR27(-12.586,16.703) AR29(-13.767,16.602) AR31(-14.885,16.602) AR33(-15.84,16.566) AR34(-16.365,16.854) AR38(-18.21,16.882) AR39(-18.972,16.882) AT9(-3.876,17.527) AT10(-4.503,17.477) AT13(-5.727,17.284) AT15(-6.718,17.44) AT17(-7.861,17.465) AT19(-9.042,17.465) AT22(-10.147,17.465) AT24(-11.481,17.465) AT27(-12.586,17.465) AT29(-13.767,17.364) AT31(-14.885,17.364) AT33(-15.799,17.313) AT36(-17.477,17.125) AU7(-2.878,17.808) AU35(-16.891,17.897) AU36(-17.527,17.751) AU39(-18.804,17.955) AV6(-2.577,18.459) AV11(-4.745,18.21) AV13(-5.727,18.046) AV15(-6.718,18.202) AV17(-7.861,18.227) AV19(-9.042,18.227) AV22(-10.147,18.227) AV24(-11.481,18.227) AV27(-12.586,18.227) AV29(-13.767,18.126) AV31(-14.885,18.126) AV33(-15.799,18.075) AW9(-3.673,18.804) AW11(-4.745,18.972) AW13(-5.727,18.808) AW15(-6.718,18.964) AW17(-7.861,18.989) AW19(-9.042,18.989) AW22(-10.147,18.989) AW24(-11.481,18.989) AW27(-12.586,18.989) AW29(-13.767,18.888) AW31(-14.885,18.888) AW33(-15.85,18.837) AW35(-16.851,18.813) AW37(-17.808,18.75) AY5(-2.05,19.399) AY38(-18.459,19.051) B1(0,0.354) B2(-0.484,0.484) B3(-0.99,0.488) B43(-20.614,0.51) B44(-21.144,0.484) B45(-21.628,0.354) BA40(-19.399,19.577) BB1(0,20.273) BB45(-21.628,20.273) BC1(0,20.773) BC2(-0.488,20.637) BC44(-21.118,20.614) BC45(-21.628,20.773) BD1(0,21.274) BD2(-0.484,21.144) BD3(-1.013,21.118) BD43(-20.637,21.139) BD44(-21.144,21.144) BD45(-21.628,21.274) BE2(-0.354,21.628) BE3(-0.854,21.628) BE4(-1.355,21.628) BE42(-20.273,21.628) BE43(-20.773,21.628) BE44(-21.274,21.628) C1(0,0.854) C2(-0.51,1.013) C42(-20.102,0.954) C44(-21.139,0.99) C45(-21.628,0.854) D1(0,1.355) D45(-21.628,1.355) F8(-3.169,2.577) G9(-3.819,2.878) G11(-4.777,2.815) G13(-5.778,2.791) G15(-6.743,2.74) G17(-7.861,2.74) G19(-9.042,2.638) G22(-10.147,2.638) G24(-11.481,2.638) G27(-12.586,2.638) G29(-13.767,2.638) G31(-14.91,2.664) G33(-15.901,2.82) G35(-16.882,2.656) G37(-17.955,2.823) H13(-5.829,3.553) H15(-6.743,3.502) H17(-7.861,3.502) H19(-9.042,3.4) H22(-10.147,3.4) H24(-11.481,3.4) H27(-12.586,3.4) H29(-13.767,3.4) H31(-14.91,3.426) H33(-15.901,3.582) H35(-16.882,3.418) J7(-2.823,3.673) J10(-4.101,3.876) J11(-4.737,3.73) J39(-18.75,3.819) K10(-4.151,4.503) K13(-5.829,4.315) K15(-6.743,4.264) K17(-7.861,4.264) K19(-9.042,4.162) K22(-10.147,4.162) K24(-11.481,4.162) K27(-12.586,4.162) K29(-13.767,4.162) K31(-14.91,4.188) K33(-15.901,4.344) K36(-17.125,4.151) K37(-17.751,4.101) L7(-2.656,4.745) L8(-3.418,4.745) L12(-5.263,4.774) L13(-5.788,5.061) L15(-6.743,5.026) L17(-7.861,5.026) L19(-9.042,4.924) L22(-10.147,4.924) L24(-11.481,4.924) L27(-12.586,4.924) L29(-13.767,4.924) L31(-14.91,4.95) L37(-17.897,4.737) L39(-18.813,4.777) M35(-16.854,5.263) N7(-2.82,5.727) N8(-3.582,5.727) N10(-4.344,5.727) N15(-6.743,5.788) N17(-7.861,5.788) N19(-9.042,5.686) N22(-10.147,5.686) N24(-11.481,5.686) N27(-12.586,5.686) N29(-13.767,5.686) N31(-14.91,5.712) N35(-16.566,5.788) N36(-17.313,5.829) N38(-18.075,5.829) N39(-18.837,5.778) P17(-7.861,6.499) P19(-9.042,6.448) P22(-10.147,6.448) P24(-11.481,6.448) P27(-12.586,6.448) P29(-13.767,6.448) P31(-14.91,6.474) R7(-2.664,6.718) R8(-3.426,6.718) R10(-4.188,6.718) R11(-4.95,6.718) R13(-5.712,6.718) R14(-6.474,6.718) R17(-7.861,7.007) R19(-9.042,7.007) R22(-10.147,7.007) R24(-11.481,7.007) R27(-12.586,7.007) R29(-13.767,7.007) R33(-15.84,6.743) R35(-16.602,6.743) R36(-17.364,6.743) R38(-18.126,6.743) R39(-18.888,6.743) U7(-2.638,7.861) U8(-3.4,7.861) U10(-4.162,7.861) U11(-4.924,7.861) U13(-5.686,7.861) U14(-6.448,7.861) U15(-7.007,7.861) U17(-7.715,7.715) U18(-8.49,7.715) U20(-9.264,7.715) U21(-10.039,7.715) U23(-10.814,7.715) U25(-11.588,7.715) U26(-12.363,7.715) U28(-13.138,7.715) U29(-13.913,7.715) U31(-14.62,7.861) U32(-15.128,7.861) U33(-15.84,7.861) U35(-16.602,7.861) U36(-17.364,7.861) U38(-18.126,7.861) U39(-18.888,7.861) V17(-7.715,8.49) V18(-8.49,8.49) V20(-9.264,8.49) V21(-10.039,8.49) V23(-10.814,8.49) V25(-11.588,8.49) V26(-12.363,8.49) V28(-13.138,8.49) V29(-13.913,8.49) W7(-2.638,9.042) W8(-3.4,9.042) W10(-4.162,9.042) W11(-4.924,9.042) W13(-5.686,9.042) W14(-6.448,9.042) W15(-7.007,9.042) W31(-14.62,9.042) W32(-15.179,9.042) W33(-15.941,9.042) W35(-16.703,9.042) W36(-17.465,9.042) W38(-18.227,9.042) W39(-18.989,9.042) Y17(-7.715,9.264) Y18(-8.49,9.264) Y20(-9.264,9.264) Y21(-10.039,9.264) Y23(-10.814,9.264) Y25(-11.588,9.264) Y26(-12.363,9.264) Y28(-13.138,9.264) Y29(-13.913,9.264)
  round 0.279 smd: A5(-1.855,0) A41(-19.772,0) BA1(0,19.772) BA45(-21.628,19.772) BE5(-1.855,21.628) BE41(-19.772,21.628) E1(0,1.855) E45(-21.628,1.855)
  round 0.254 smd: A6(-2.356,0) A40(-19.272,0) AB4(-1.411,10.331) AB5(-1.876,10.147) AB41(-19.751,10.147) AD4(-1.393,11.323) AD5(-1.876,11.481) AD41(-19.751,11.481) AF5(-1.929,12.535) AF41(-19.7,12.535) AG4(-1.411,12.605) AJ5(-1.978,13.767) AJ41(-19.751,13.767) AL4(-1.411,14.878) AL5(-1.978,14.885) AL41(-19.7,14.91) AN4(-1.393,15.87) AN5(-2.029,15.977) AN41(-19.57,15.901) AR5(-1.927,16.995) AR41(-19.734,16.882) AU41(-19.851,17.904) AV4(-1.585,18.134) AW4(-1.379,19.018) AW42(-20.054,18.629) AY1(0,19.272) AY45(-21.628,19.272) B6(-2.364,0.518) B25(-12.039,0.508) B40(-19.515,0.459) BA4(-1.212,19.933) BA5(-2.047,19.909) BA9(-3.723,19.851) BA11(-4.745,19.734) BA13(-5.727,19.57) BA15(-6.718,19.7) BA17(-7.861,19.751) BA20(-9.092,19.7) BA22(-10.147,19.751) BA24(-11.481,19.751) BA26(-12.535,19.699) BA29(-13.767,19.65) BA31(-14.885,19.65) BA33(-15.977,19.599) BA35(-16.995,19.7) BA41(-19.909,19.581) BB3(-0.652,20.158) BB7(-2.998,20.054) BB38(-18.134,20.043) BB39(-19.018,20.248) BB41(-19.933,20.416) BB43(-20.674,20.102) BC4(-1.526,20.674) BC42(-20.158,20.976) BE6(-2.356,21.628) BE40(-19.272,21.628) C10(-4.089,1.087) C28(-13.183,1.087) C37(-17.729,1.087) D3(-0.954,1.526) D5(-1.694,1.212) D7(-2.61,1.379) D8(-3.493,1.585) D10(-4.476,1.411) D15(-6.75,1.411) D17(-8.031,1.393) D19(-9.023,1.411) D24(-11.296,1.411) D27(-12.578,1.393) D29(-13.569,1.411) D31(-14.851,1.393) D33(-15.843,1.411) D36(-17.124,1.393) D39(-18.629,1.574) D43(-20.976,1.47) E5(-1.719,2.047) E6(-2.229,2.05) E11(-4.632,1.927) E13(-5.651,2.029) E15(-6.743,1.978) E17(-7.861,1.978) E20(-9.092,1.929) E22(-10.147,1.876) E24(-11.481,1.876) E26(-12.535,1.927) E29(-13.767,1.876) E31(-14.91,1.927) E33(-15.901,2.058) E35(-16.882,1.894) E37(-17.904,1.776) E41(-19.581,1.719) E42(-20.416,1.694) F1(0,2.356) F41(-19.577,2.229) F44(-21.11,2.364) F45(-21.628,2.356) G4(-1.574,2.998) G42(-20.248,2.61) H3(-0.926,3.423) H40(-19.051,3.169) H42(-20.043,3.493) J3(-1.087,3.898) J5(-1.776,3.723) K4(-1.393,4.503) K42(-20.217,4.476) K43(-20.54,4.089) L5(-1.894,4.745) L41(-19.7,4.632) N4(-1.411,5.785) N5(-2.058,5.727) N41(-19.599,5.651) R5(-1.927,6.718) R41(-19.65,6.743) U4(-1.411,8.058) U5(-1.876,7.861) U41(-19.65,7.861) V3(-1.087,8.445) W4(-1.393,9.05) Y5(-1.927,9.092) Y41(-19.699,9.092)
  oval 0.203x0.254 smd: A7(-2.92,0) A9(-3.962,0) A12(-5.219,0) A14(-6.261,0) A16(-7.492,0) A18(-8.534,0) A21(-9.766,0) A23(-10.807,0) A25(-12.039,0) A28(-13.08,0) A30(-14.312,0) A32(-15.354,0) A35(-16.586,0) A37(-17.652,0) A39(-18.707,0) AA4(-1.487,9.588) AA42(-20.138,9.766) AE4(-1.489,11.862) AE42(-20.14,12.039) AK4(-1.489,14.135) AK42(-20.14,14.312) AP4(-1.489,16.408) AR42(-20.14,16.586) B7(-2.87,0.508) B8(-3.555,0.386) B10(-4.089,0.579) B11(-4.603,0.418) B12(-5.219,0.508) B13(-5.88,0.386) B14(-6.363,0.579) B15(-6.877,0.418) B16(-7.492,0.508) B18(-8.153,0.386) B19(-8.636,0.579) B20(-9.15,0.418) B21(-9.766,0.508) B22(-10.426,0.386) B23(-10.909,0.579) B24(-11.423,0.418) B27(-12.699,0.386) B28(-13.183,0.579) B29(-13.696,0.418) B30(-14.312,0.508) B31(-14.973,0.386) B32(-15.456,0.579) B33(-15.97,0.418) B35(-16.586,0.508) B36(-17.246,0.386) B37(-17.729,0.579) B38(-18.205,0.418) B39(-18.757,0.508) BB10(-4.503,20.235) BB13(-5.785,20.217) BB15(-6.776,20.235) BB17(-8.058,20.217) BB19(-9.05,20.235) BB22(-10.331,20.217) BB24(-11.323,20.235) BB27(-12.605,20.217) BB29(-13.596,20.235) BB31(-14.878,20.217) BB33(-15.87,20.235) BB36(-17.151,20.217) BC8(-3.423,20.702) BC9(-3.898,20.54) BC10(-4.478,20.743) BC13(-5.658,20.702) BC14(-6.172,20.54) BC15(-6.751,20.743) BC17(-7.931,20.702) BC18(-8.445,20.54) BC19(-9.024,20.743) BC22(-10.204,20.702) BC23(-10.718,20.54) BC24(-11.298,20.743) BC26(-12.478,20.702) BC27(-12.992,20.54) BC29(-13.571,20.743) BC31(-14.751,20.702) BC32(-15.265,20.54) BC33(-15.844,20.743) BC35(-17.024,20.702) BC36(-17.538,20.54) BC38(-18.168,20.743) BD6(-2.113,21.168) BD7(-2.87,21.12) BD8(-3.423,21.21) BD9(-3.898,21.048) BD10(-4.381,21.242) BD11(-5.042,21.12) BD13(-5.658,21.21) BD14(-6.172,21.048) BD15(-6.655,21.242) BD16(-7.315,21.12) BD17(-7.931,21.21) BD18(-8.445,21.048) BD19(-8.928,21.242) BD21(-9.588,21.12) BD22(-10.204,21.21) BD23(-10.718,21.048) BD24(-11.201,21.242) BD25(-11.862,21.12) BD26(-12.478,21.21) BD27(-12.992,21.048) BD28(-13.475,21.242) BD30(-14.135,21.12) BD31(-14.751,21.21) BD32(-15.265,21.048) BD33(-15.748,21.242) BD34(-16.408,21.12) BD35(-17.024,21.21) BD36(-17.538,21.048) BD38(-18.072,21.242) BD39(-18.758,21.12) BE7(-2.92,21.628) BE9(-3.975,21.628) BE11(-5.042,21.628) BE14(-6.274,21.628) BE16(-7.315,21.628) BE18(-8.547,21.628) BE21(-9.588,21.628) BE23(-10.82,21.628) BE25(-11.862,21.628) BE28(-13.094,21.628) BE30(-14.135,21.628) BE32(-15.367,21.628) BE34(-16.408,21.628) BE37(-17.666,21.628) BE39(-18.707,21.628) C8(-3.459,0.885) C11(-4.603,0.926) C13(-5.783,0.885) C14(-6.363,1.087) C15(-6.877,0.926) C17(-8.057,0.885) C19(-8.636,1.087) C20(-9.15,0.926) C22(-10.33,0.885) C23(-10.909,1.087) C24(-11.423,0.926) C27(-12.603,0.885) C29(-13.696,0.926) C31(-14.877,0.885) C32(-15.456,1.087) C33(-15.97,0.926) C36(-17.15,0.885) C38(-18.205,0.926) D13(-5.758,1.393) D22(-10.305,1.393) L4(-1.487,5.042) M42(-20.138,5.219) T4(-1.487,7.315) T42(-20.138,7.492)
  oval 0.254x0.203 smd: AA1(0,9.588) AA2(-0.508,9.588) AA44(-21.12,9.766) AA45(-21.628,9.766) AB2(-0.418,10.204) AB3(-0.926,10.204) AB42(-20.235,10.305) AB43(-20.743,10.33) AB44(-21.242,10.426) AC1(0,10.82) AC2(-0.579,10.718) AC3(-1.087,10.718) AC43(-20.54,10.909) AC44(-21.048,10.909) AC45(-21.628,10.807) AD2(-0.386,11.201) AD3(-0.885,11.298) AD42(-20.217,11.296) AD43(-20.702,11.423) AD44(-21.21,11.423) AE1(0,11.862) AE2(-0.508,11.862) AE44(-21.12,12.039) AE45(-21.628,12.039) AF2(-0.418,12.478) AF3(-0.926,12.478) AG2(-0.579,12.992) AG3(-1.087,12.992) AG42(-20.235,12.578) AG43(-20.743,12.603) AG44(-21.242,12.699) AH1(0,13.094) AH2(-0.386,13.475) AH43(-20.54,13.183) AH44(-21.048,13.183) AH45(-21.628,13.08) AJ3(-0.885,13.571) AJ4(-1.393,13.596) AJ42(-20.217,13.569) AJ43(-20.702,13.696) AJ44(-21.21,13.696) AK1(0,14.135) AK2(-0.508,14.135) AK44(-21.12,14.312) AK45(-21.628,14.312) AL2(-0.418,14.751) AL3(-0.926,14.751) AL42(-20.235,14.851) AL43(-20.743,14.877) AL44(-21.242,14.973) AM1(0,15.367) AM2(-0.579,15.265) AM3(-1.087,15.265) AM43(-20.54,15.456) AM44(-21.048,15.456) AM45(-21.628,15.354) AN2(-0.386,15.748) AN3(-0.885,15.844) AN42(-20.217,15.843) AN43(-20.702,15.97) AN44(-21.21,15.97) AP1(0,16.408) AP2(-0.508,16.408) AR2(-0.418,17.024) AR3(-0.926,17.024) AR44(-21.12,16.586) AR45(-21.628,16.586) AT2(-0.579,17.538) AT3(-1.087,17.538) AT4(-1.411,17.151) AT42(-20.235,17.124) AT43(-20.743,17.15) AT44(-21.242,17.246) AU1(0,17.666) AU43(-20.54,17.729) AU44(-21.048,17.729) AU45(-21.628,17.652) AV2(-0.386,18.072) AV3(-0.885,18.168) AV43(-20.702,18.205) AV44(-21.21,18.205) AW1(0,18.707) AW2(-0.508,18.758) AW44(-21.12,18.757) AW45(-21.628,18.707) AY44(-21.168,19.515) BB11(-5.042,20.14) BB16(-7.315,20.14) BB21(-9.588,20.14) BB25(-11.862,20.138) BB30(-14.135,20.138) BB34(-16.408,20.138) D12(-5.219,1.489) D16(-7.492,1.489) D21(-9.766,1.489) D25(-12.039,1.487) D30(-14.312,1.487) D35(-16.586,1.487) F2(-0.459,2.113) G1(0,2.92) G2(-0.508,2.87) G44(-21.12,2.87) G45(-21.628,2.92) H2(-0.418,3.423) H43(-20.743,3.459) H44(-21.242,3.555) J1(0,3.975) J2(-0.579,3.898) J45(-21.628,3.962) K2(-0.386,4.381) K3(-0.885,4.478) K44(-21.048,4.089) L1(0,5.042) L2(-0.508,5.042) L43(-20.702,4.603) L44(-21.21,4.603) M44(-21.12,5.219) M45(-21.628,5.219) N2(-0.418,5.658) N3(-0.926,5.658) N42(-20.235,5.758) N43(-20.743,5.783) N44(-21.242,5.88) P1(0,6.274) P2(-0.579,6.172) P3(-1.087,6.172) P43(-20.54,6.363) P44(-21.048,6.363) P45(-21.628,6.261) R2(-0.386,6.655) R3(-0.885,6.751) R4(-1.393,6.776) R42(-20.217,6.75) R43(-20.702,6.877) R44(-21.21,6.877) T1(0,7.315) T2(-0.508,7.315) T44(-21.12,7.492) T45(-21.628,7.492) U2(-0.418,7.931) U3(-0.926,7.931) U42(-20.235,8.031) U43(-20.743,8.057) V1(0,8.547) V2(-0.579,8.445) V44(-21.242,8.153) V45(-21.628,8.534) W2(-0.386,8.928) W3(-0.885,9.024) W42(-20.217,9.023) W43(-20.54,8.636) W44(-21.048,8.636) Y43(-20.702,9.15) Y44(-21.21,9.15)
  round 0.368 smd: AY2(-0.518,19.263) BD40(-19.263,21.11) C4(-1.47,0.652)
