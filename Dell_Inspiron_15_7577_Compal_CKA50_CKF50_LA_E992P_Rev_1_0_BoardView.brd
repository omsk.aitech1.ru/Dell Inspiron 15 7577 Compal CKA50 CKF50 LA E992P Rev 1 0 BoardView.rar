# Allegro board Dell_Inspiron_15_7577_Compal_CKA50_CKF50_LA_E992P_Rev_1_0_BoardView.brd (continued)
## Nets (continued)
GND: C5235.2 CA3.2 CA4.2 CA7.2 CA8.2 CA9.2 CA10.1 CA11.2 CA12.2 CA13.2 CA14.2 CA15.1 CA25.2 CA26.2 CA27.2 CA28.2 CA30.2 CA36.2 CA37.2 CA38.2 CA39.2 CA62.2 CA66.2 CC4.1 CC27.2 CC298.2 CD1.2 CD2.2 CD3.2 CD4.2 CD5.2 CD6.2 CD7.2 CD8.2 CD9.2 CD10.2 CD12.2 CD13.2 CD14.2 CD15.2 CD16.2 CD17.2 CD19.2 CD20.2 CD21.2 CD22.2 CD23.2 CD24.2 CD25.2 CD26.2 CD27.2 CD28.2 CD29.2 CD30.2 CD31.2 CD32.2 CD33.2 CD34.2 CD35.2 CD36.2 CD38.2 CD39.2 CD40.2 CD41.2 CD69.2 CD70.2 CD71.2 CD72.2 CD73.2 CD74.2 CD75.2 CD76.2 CD77.2 CD78.2 CD79.2 CD80.2 CD81.2 CD82.2 CD83.2 CD84.2 CD85.2 CD86.2 CD87.2 CD88.2 CD89.2 CD90.2 CD96.2 CD97.2 CE1.2 CE2.2 CE4.2 CE5.2 CE6.2 CE8.2 CE9.2 CE10.2 CE12.2 CE17.2 CE18.2 CE62.2 CE63.1 CE64.1 CE65.2 CE66.2 CE67.2 CE68.2 CE69.2 CE71.2 CE73.2 CE76.2 CE77.2 CE79.2 CE80.2 CE82.2 CE84.1 CE85.2 CE86.2 CE89.2 CE91.2 CE99.2 CE100.2 CE101.2 CE102.2 CE103.2 CE105.2 CG34.2 CG40.2 CG42.2 CG43.2 CG47.2 CG48.2 CG51.2 CG53.2 CG54.2 CG55.2 CG56.2 CG57.2 CG58.2 CG59.2 CG60.2 CG61.2 CG64.2 CG65.2 CG66.2 CG75.1 CG76.1 CG78.2 CG79.2 CG80.2 CG81.2 CG82.2 CG83.2 CG84.2 CG85.2 CG86.2 CG87.2 CG88.2 CG89.2 CG90.2 CG91.2 CG97.2 CG98.2 CG99.2 CG100.2 CG101.2 CG102.2 CG103.2 CG104.2 CG105.2 CG106.2 CG113.2 CG114.2 CG115.2 CG116.2 CG117.2 CG118.2 CG119.2 CG120.2 CG121.2 CG122.2 CG123.2 CG124.2 CG125.2 CG126.2 CG132.2 CG133.2 CG134.2 CG135.2 CG136.2 CG137.2 CG138.2 CG139.2 CG140.2 CG141.2 CG148.2 CG149.2 CG150.2 CG151.2 CG152.2 CG153.2 CG154.2 CG155.2 CG156.2 CG157.2 CG158.2 CG159.2 CG160.2 CG161.2 CG167.2 CG168.2 CG169.2 CG170.2 CG171.2 CG172.2 CG173.2 CG174.2 CG175.2 CG176.2 CG184.2 CG185.2 CG186.2 CG187.2 CG188.2 CG189.2 CG190.2 CG191.2 CG192.2 CG193.2 CG194.2 CG195.2 CG196.2 CG197.2 CG198.2 CG199.2 CG200.2 CG201.2 CG202.2 CG203.2 CG204.2 CG205.2 CG206.2 CG207.2 CG208.2 CG209.2 CG210.2 CG211.2 CG212.2 CG213.2 CG214.2 CG215.2 CG216.2 CG217.2 CG218.2 CG219.2 CG220.2 CG221.2 CG222.2 CG223.2 CG224.2 CG225.2 CG226.2 CG227.2 CG228.2 CG230.2 CG231.2 CG232.2 CG233.2 CG234.2 CG235.2 CG236.2 CG237.2 CG238.2 CG239.2 CG240.2 CG242.2 CG243.2 CG244.2 CG245.2 CG246.2 CG288.2 CG289.2 CG290.2 CG291.2 CG292.2 CG293.2 CG294.2 CG295.2 CG296.2 CG297.2 CG298.2 CG299.2 CG300.2 CG301.2 CG302.2 CG303.2 CG304.2 CG305.2 CG306.2 CG307.2 CG308.2 CG309.2 CG310.2 CG311.2 CG313.2 CG314.2 CG315.2 CG316.2 CG317.2 CG318.2 CG320.2 CG322.2 CG323.2 CG324.2 CG325.2 CG326.2 CG327.2 CG328.2 CG329.2 CG330.2 CG331.2 CG332.2 CG333.2 CG334.2 CG335.2 CG336.2 CG337.2 CG338.2 CG339.2 CG340.2 CG341.2 CG342.2 CG343.2 CG344.2 CG345.2 CG346.2 CG347.2 CG348.2 CG349.2 CG350.2 CG351.2 CG352.2 CG353.2 CG354.2 CG355.2 CG356.2 CG357.2 CG358.2 CG359.2 CG360.2 CG361.2 CG362.2 CG363.2 CG364.2 CG365.2 CG366.2 CG367.2 CG368.2 CG369.2 CG370.2 CG371.2 CG372.2 CG373.2 CG374.2 CG375.2 CG376.2 CG377.2 CG378.2 CG379.2 CG380.2 CG381.2 CG382.2 CG383.2 CG384.2 CG385.2 CG386.2 CG388.2 CG389.2 CG390.2 CG391.2 CG392.2 CG393.2 CG394.2 CG395.2 CG396.2 CG397.2 CG398.2 CG399.2 CG400.2 CG401.2 CG402.2 CG403.2 CG404.2 CG405.2 CG406.2 CG407.2 CG408.2 CG409.2 CG410.2 CG411.2 CG412.2 CG413.2 CG414.2 CG415.2 CG416.2 CG417.2 CG418.2 CG419.2 CG420.2 CG421.2 CG422.2 CG423.2 CG424.2 CG425.2 CG426.2 CG427.2 CG428.2 CG429.2 CG430.2 CG431.2 CG432.2 CG433.2 CG434.2 CG435.2 CG438.2 CG439.2 CG440.2 CG442.2 CG482.2 CG483.2 CG487.2 CG504.2 CG505.2 CG507.2 CG508.2 CG509.2 CG510.2 CG511.1 CG512.2 CG514.1 CG515.1 CG517.2 CG520.2 CG521.2 CG522.2 CG523.2 CG524.2 CG525.2 CG526.2 CG527.2 CG528.2 CH45.2 CH46.2 CH47.2 CH48.2 CH50.1 CH51.1 CH52.2 CH53.2 CH70.2 CH80.2 CH82.2 CH102.2 CH103.2 CH104.2 CH106.2 CH110.2 CH111.2 CH112.2 CH113.2 CH114.2 CH115.2 CH116.2 CH117.2 CH118.2 CH119.2 CH120.2 CH121.2 CH122.2 CH123.2 CH124.2 CH125.2 CH126.2 CH127.2 CH128.2 CH129.2 CH130.2 CH131.2 CH132.2 CH133.2 CH134.2 CH135.2 CH136.2 CH173.2 CH176.2 CH177.2 CH178.2 CH179.2 CH180.2 CH181.2 CH182.2 CH183.2 CH184.2 CH185.2 CH186.2 CH187.2 CH188.2 CH189.2 CH190.2 CH191.2 CH192.2 CH197.2 CH200.2 CH201.2 CH202.2 CH203.2 CH204.2 CH205.2 CH206.2 CH207.2 CH208.2 CH209.2 CH210.2 CH211.2 CH212.2 CH213.2 CH214.2 CH215.2 CI3.2 CI4.2 CI11.2 CI12.2 CI13.2 CI17.2 CI18.2 CI19.2 CI21.2 CI23.2 CI24.2 CI25.2 CI26.2 CI27.2 CI30.2 CI31.2 CL15.2 CL19.2 CL20.2 CL21.2 CL22.2 CL24.2 CL32.2 CL33.2 CL34.2 CL35.2 CL36.2 CL37.2 CL39.2 CL41.2 CL42.2 CL43.2 CL44.2 CL49.2 CL52.2 CL53.2 CL54.2 CL55.2 CL56.2 CL57.2 CLP1.1 CLP2.1 CLP3.1 CLP4.1 CLRP1.2 CN1.2 CN2.2 CN6.2 CN7.2 CN9.2 CN19.2 CN22.2 CP3.2 CP4.2 CP5.2 CP6.2 CP7.2 CP8.2 CP9.2 CP10.2 CP11.2 CP12.2 CP13.2 CP14.2 CP24.2 CP25.2 CP26.2 CP27.2 CP28.2 CP29.2 CP47.2 CR4.2 CR5.2 CR6.2 CR7.1 CR8.1 CR9.2 CR10.2 CS12.2 CS13.2 CS14.2 CS15.2 CT37.2 CT38.2 CT45.2 CT46.2 CT47.2 CT48.2 CT49.2 CT50.2 CT51.2 CT52.2 CT53.2 CT54.2 CT55.2 CT56.2 CT57.2 CT58.2 CT59.2 CT60.2 CT61.2 CT62.2 CT63.2 CT64.2 CT65.2 CT66.2 CT67.2 CT68.2 CT69.2 CT70.2 CT71.2 CT72.2 CT73.2 CT74.2 CT75.2 CT77.2 CT78.2 CT79.2 CT80.2 CT81.2 CT82.2 CT83.2 CT84.2 CT85.2 CT86.2 CT88.2 CT90.2 CT91.2 CT92.2 CT93.2 CT94.1 CT95.1 CT96.2 CT97.2 CT98.2 CT99.2 CT100.2 CT101.2 CT102.2 CT103.2 CT104.2 CT106.2 CT112.2 CT113.2 CT115.2 CT116.2 CT117.2 CTH1.2 CTH2.2 CTPM1.2 CTPM2.2 CTPM3.2 CTPM4.2 CTPM5.2 CTPM6.2 CTPM7.2 CV576.2 CV577.2 CV579.2 CV582.2 CV583.2 CV584.2 CV597.2 CV598.2 CV599.1 CV600.1 CV601.1 CV922.2 CVGA1.1 CVGA2.1 CVGA3.2 CVGA5.2 CVGA6.1 CVGA7.2 CVGA8.2 CVGA14.2 CVGA15.2 CVGA16.2 CVGA17.2 CVGA18.2 CVGA19.2 CVGA20.2 CVGA21.2 CVGA22.2 CVGA23.2 CVGA24.2 CZ4.2 CZ6.2 CZ8.2 CZ9.2 CZ11.2 CZ12.2 CZ28.2 CZ41.2 CZ44.2 CZ47.2 CZ49.2 CZ57.2 CZ86.2 CZ88.2 CZ96.2 CZ97.2 CZ102.2 CZ108.2 D5223.1 D5225.1 D5226.1 DA1.1 DA2.1 DA3.1 DA4.1 DA5.1 DA6.1 DE4.2 DI3.1 DI7.3 DI8.1 DI9.3 DI10.1 DI11.1 DI12.3 DT1.2 DT2.2 DT3.2 DT4.2 DT5.2 DT6.2 DT7.2 DT8.2 DT9.2 DT10.3 DT11.1 DT13.2 DT14.2 DT15.1 DV12.1 EC5205.2 EC5206.2 H1.1(TP-1) H2.1(TP-1) H3.1(TP-1) H4.1(TP-1) H5.1(TP-1) H7.1(TP-1) H8.1(TP-1) H10.1(TP-1) H11.1(TP-1) H13.1(TP-1) H14.1(TP-1) H15.1(TP-1) H16.1(TP-1) H17.1(TP-1) H18.1(TP-1) H19.1(TP-1) HCPU1.1(TP-1) HCPU2.1(TP-1) HCPU3.1(TP-1) HCPU4.1(TP-1) HDA1.49 HGPU1.1(TP-1) HGPU2.1(TP-1) HT1.2 JBL1.5 JBL1.6 JCAM1.1 JCAM1.7 JCAM1.8 JCRT1.5 JCRT1.6 JCRT1.7 JCRT1.8 JCRT1.10 JCRT1.16 JCRT1.17 JDEG1.10 JDEG1.11 JDEG1.12 JDIMM1.1 JDIMM1.2 JDIMM1.5 JDIMM1.6 JDIMM1.9 JDIMM1.10 JDIMM1.14 JDIMM1.15 JDIMM1.18 JDIMM1.19 JDIMM1.22 JDIMM1.23 JDIMM1.26 JDIMM1.27 JDIMM1.30 JDIMM1.31 JDIMM1.35 JDIMM1.36 JDIMM1.39 JDIMM1.40 JDIMM1.43 JDIMM1.44 JDIMM1.47 JDIMM1.48 JDIMM1.51 JDIMM1.52 JDIMM1.56 JDIMM1.57 JDIMM1.60 JDIMM1.61 JDIMM1.64 JDIMM1.65 JDIMM1.68 JDIMM1.69 JDIMM1.72 JDIMM1.73 JDIMM1.77 JDIMM1.78 JDIMM1.81 JDIMM1.82 JDIMM1.85 JDIMM1.86 JDIMM1.89 JDIMM1.90 JDIMM1.93 JDIMM1.94 JDIMM1.98 JDIMM1.99 JDIMM1.102 JDIMM1.103 JDIMM1.106 JDIMM1.107 JDIMM1.166 JDIMM1.167 JDIMM1.168 JDIMM1.171 JDIMM1.172 JDIMM1.175 JDIMM1.176 JDIMM1.180 JDIMM1.181 JDIMM1.184 JDIMM1.185 JDIMM1.188 JDIMM1.189 JDIMM1.192 JDIMM1.193 JDIMM1.196 JDIMM1.197 JDIMM1.201 JDIMM1.202 JDIMM1.205 JDIMM1.206 JDIMM1.209 JDIMM1.210 JDIMM1.213 JDIMM1.214 JDIMM1.217 JDIMM1.218 JDIMM1.222 JDIMM1.223 JDIMM1.226 JDIMM1.227 JDIMM1.230 JDIMM1.231 JDIMM1.234 JDIMM1.235 JDIMM1.238 JDIMM1.239 JDIMM1.243 JDIMM1.244 JDIMM1.247 JDIMM1.248 JDIMM1.251 JDIMM1.252 JDIMM1.256 JDIMM1.260 JDIMM1.261 JDIMM1.262 JDIMM2.1 JDIMM2.2 JDIMM2.5 JDIMM2.6 JDIMM2.9 JDIMM2.10 JDIMM2.14 JDIMM2.15 JDIMM2.18 JDIMM2.19 JDIMM2.22 JDIMM2.23 JDIMM2.26 JDIMM2.27 JDIMM2.30 JDIMM2.31 JDIMM2.35 JDIMM2.36 JDIMM2.39 JDIMM2.40 JDIMM2.43 JDIMM2.44 JDIMM2.47 JDIMM2.48 JDIMM2.51 JDIMM2.52 JDIMM2.56 JDIMM2.57 JDIMM2.60 JDIMM2.61 JDIMM2.64 JDIMM2.65 JDIMM2.68 JDIMM2.69 JDIMM2.72 JDIMM2.73 JDIMM2.77 JDIMM2.78 JDIMM2.81 JDIMM2.82 JDIMM2.85 JDIMM2.86 JDIMM2.89 JDIMM2.90 JDIMM2.93 JDIMM2.94 JDIMM2.98 JDIMM2.99 JDIMM2.102 JDIMM2.103 JDIMM2.106 JDIMM2.107 JDIMM2.166 JDIMM2.167 JDIMM2.168 JDIMM2.171 JDIMM2.172 JDIMM2.175 JDIMM2.176 JDIMM2.180 JDIMM2.181 JDIMM2.184 JDIMM2.185 JDIMM2.188 JDIMM2.189 JDIMM2.192 JDIMM2.193 JDIMM2.196 JDIMM2.197 JDIMM2.201 JDIMM2.202 JDIMM2.205 JDIMM2.206 JDIMM2.209 JDIMM2.210 JDIMM2.213 JDIMM2.214 JDIMM2.217 JDIMM2.218 JDIMM2.222 JDIMM2.223 JDIMM2.226 JDIMM2.227 JDIMM2.230 JDIMM2.231 JDIMM2.234 JDIMM2.235 JDIMM2.238 JDIMM2.239 JDIMM2.243 JDIMM2.244 JDIMM2.247 JDIMM2.248 JDIMM2.251 JDIMM2.252 JDIMM2.256 JDIMM2.261 JDIMM2.262 JEDP1.6 JEDP1.7 JEDP1.8 JEDP1.11 JEDP1.13 JEDP1.14 JEDP1.24 JEDP1.27 JEDP1.30 JEDP1.33 JEDP1.36 JEDP1.39 JEDP1.40 JEDP1.41 JEDP1.42 JEDP1.43 JEDP1.44 JESPI1.9 JESPI1.11 JESPI1.12 JFAN1.4 JFAN1.5 JFAN1.6 JFAN2.4 JFAN2.5 JFAN2.6 JHDD1.1 JHDD1.4 JHDD1.7 JHDD1.13 JHDD1.14 JHDMI1.2 JHDMI1.5 JHDMI1.8 JHDMI1.11 JHDMI1.17 JHDMI1.20 JHDMI1.21 JHDMI1.22 JHDMI1.23 JKB1.1 JKB1.31 JKB1.32 JLAN.9 JLAN.10 JLAN.11 JLAN.12 JLED.1 JLED.5 JLED.6 JNGFF1.1 JNGFF1.7 JNGFF1.18 JNGFF1.25 JNGFF1.31 JNGFF1.37 JNGFF1.43 JNGFF1.49 JNGFF1.55 JNGFF1.61 JNGFF1.67 JNGFF1.68 JNGFF1.69 JNGFF2.1 JNGFF2.3 JNGFF2.9 JNGFF2.15 JNGFF2.21 JNGFF2.27 JNGFF2.33 JNGFF2.39 JNGFF2.45 JNGFF2.51 JNGFF2.57 JNGFF2.63 JNGFF2.65 JNGFF2.67 JNGFF2.68 JNGFF2.69 JPW.6 JPW.9 JPW.11 JPW.12 JREAD1.3 JREAD1.6 JREAD1.12 JREAD1.13 JREAD1.14 JREAD1.15 JRTC.2 JRTC.3 JRTC.4 JSPK1.5 JSPK1.6 JTP.5 JTP.9 JTP.10 JUSB1.4 JUSB1.7 JUSB1.10 JUSB1.11 JUSB1.12 JUSB1.13 JUSB2.4 JUSB2.7 JUSB2.10 JUSB2.11 JUSB2.12 JUSB2.13 JUSB3.4 JUSB3.7 JUSB3.10 JUSB3.11 JUSB3.12 JUSB3.13 JUSBC1.1 JUSBC1.2 JUSBC1.3 JUSBC1.4 JUSBC1.5 JUSBC1.6 JUSBC1.A1 JUSBC1.A12 JUSBC1.B1 JUSBC1.B12 JXDP1.2 JXDP1.7 JXDP1.8 JXDP1.13 JXDP1.14 JXDP1.19 JXDP1.20 JXDP1.25 JXDP1.26 JXDP1.31 JXDP1.32 JXDP1.37 JXDP1.38 JXDP1.49 JXDP1.50 JXDP1.59 PBATT1.7 PBATT1.8 PBATT1.9 PBATT1.10 PC1.2 PC2.2 PC3.2 PC4.2 PC5.2 PC6.2 PC7.2 PC8.2 PC10V0.1 PC10V1.1 PC10V2.2 PC10V3.2 PC10V4.2 PC10V5.2 PC10V7.2 PC13.2 PC14.2 PC17.2 PC18.2 PC18V00.1 PC18V02.1 PC18V04.2 PC18V05.2 PC18V06.2 PC18V07.2 PC18V08.2 PC18V09.2 PC18V10.2 PC18V11.2 PC19.2 PC20.2 PC25V00.2 PC25V01.2 PC25V02.2 PC25V04.2 PC25V05.2 PC25V06.2 PC100.2 PC101.2 PC102.2 PC103.2 PC104.2 PC105.2 PC107.2 PC108.2 PC109.2 PC110.2 PC111.2 PC112.2 PC113.2 PC115.2 PC200.2 PC201.2 PC202.2 PC203.2 PC204.2 PC205.2 PC207.2 PC208.2 PC209.1 PC212.2 PC213.2 PC214.2 PC215.2 PC216.2 PC217.2 PC218.2 PC219.2 PC220.2 PC221.2 PC222.2 PC223.2 PC224.2 PC300.2 PC301.2 PC302.2 PC303.2 PC304.2 PC305.2 PC306.2 PC307.2 PC308.2 PC311.2 PC312.2 PC313.2 PC314.2 PC315.2 PC316.2 PC704.2 PC705.2 PC706.2 PC707.2 PC708.2 PC709.2 PC710.1 PC712.2 PC714.2 PC715.1 PC716.2 PC717.2 PC718.2 PC719.2 PC720.1 PC722.2 PC723.1 PC724.2 PC725.1 PC800.2 PC801.2 PC802.2 PC803.2 PC804.2 PC805.2 PC806.2 PC807.2 PC809.2 PC810.2 PC811.2 PC812.2 PC813.2 PC4000.2 PC4001.2 PC4002.2 PC4003.2 PC4004.2 PC4006.2 PC4007.2 PC4008.2 PC4009.2 PC4011.2 PC4012.2 PC4013.2 PC4014.2 PC5000.2 PC5001.2 PC5002.2 PC5003.2 PC5004.1 PC5005.1 PC5006.1 PC5007.1 PC5008.2 PC5013.2 PC5014.2 PC5016.2 PC5020.2 PC5021.1 PC5022.2 PC5023.2 PC5024.2 PC5030.2 PC5035.2 PC5036.1 PC5037.1 PC5038.2 PC5039.2 PC5040.1 PC5100.1 PC5101.2 PC5103.2 PC5105.2 PC5106.2 PC5107.2 PC5108.2 PC5109.2 PC5110.2 PC5111.2 PC5112.2 PC5113.2 PC5114.1 PC5116.2 PC5117.2 PC5118.2 PC5119.2 PC5120.2 PC5121.2 PC5122.2 PC5123.2 PC5124.2 PC5125.1 PC5127.2 PC5128.2 PC5129.2 PC5130.2 PC5131.2 PC5132.2 PC5133.2 PC5134.2 PC5200.1 PC5201.2 PC5203.2 PC5204.2 PC5205.2 PC5206.2 PC5207.2 PC5208.2 PC5209.2 PC5210.2 PC5211.2 PC5212.1 PC5214.2 PC5215.2 PC5216.2 PC5217.2 PC5218.2 PC5219.2 PC5220.2 PC5221.2 PC5223.2 PC5224.2 PC5225.2 PC5226.2 PC5228.2 PC5229.2 PC5230.1 PC5231.1 PC5232.2 PC5500.2 PC5501.2 PC5502.2 PC5503.2 PC5504.2 PC5505.2 PC5506.2 PC5507.2 PC5508.2 PC5509.2 PC5510.2 PC5511.2 PC5512.2 PC5513.2 PC5514.2 PC5515.2 PC5516.2 PC5517.2 PC5518.2 PC5519.2 PC5520.2 PC5521.2 PC5522.2 PC5523.2 PC5524.2 PC5525.2 PC5526.2 PC5527.2 PC5528.2 PC5529.2 PC5530.2 PC5531.2 PC5532.2 PC5533.2 PC5534.2 PC5535.2 PC5536.2 PC5537.2 PC5538.2 PC5539.2 PC5540.2 PC5541.2 PC5542.2 PC5543.2 PC5544.2 PC5545.2 PC5546.2 PC5547.2 PC5548.2 PC5549.2 PC5550.2 PC5551.2 PC5552.2 PC5553.2 PC5554.2 PC5555.2 PC5556.2 PC5557.2 PC5558.2 PC5559.2 PC5560.2 PC5561.2 PC5562.2 PC5563.2 PC5564.2 PC5565.2 PC5566.2 PC5567.2 PC5568.2 PC5569.2 PC5570.2 PC5571.2 PC5572.2 PC5573.2 PC5574.2 PC5575.2 PC5576.2 PC5577.2 PC5578.2 PC5579.2 PC5580.2 PC5581.2 PC5582.2 PC5583.2 PC5584.2 PC5585.2 PC5586.2 PC5587.2 PC5588.2 PC5589.2 PC5590.2 PC5591.2 PC5592.2 PC5593.2 PC5594.2 PC5595.2 PC5596.2 PC5597.2 PC5598.2 PC5599.2 PC5600.2 PC5601.2 PC5602.2 PC5603.2 PC5604.2 PC5605.2 PC5606.2 PC5607.2 PC5608.2 PC5609.2 PC5610.2 PC6000.1 PC6009.2 PC6014.2 PC6016.1 PC6100.2 PC6101.2 PC6103.2 PC6104.2 PC6105.2 PC6106.2 PC6107.2 PC6108.2 PC6109.2 PC6110.2 PC6111.2 PC6112.2 PC6113.2 PC6114.2 PC6116.2 PC6117.2 PC6118.2 PC6119.2 PC6121.2 PC6122.2 PC6123.2 PC6124.2 PC6125.2 PC6126.2 PC6127.2 PC6128.2 PC6130.2 PC6131.2 PC6132.2 PC6133.2 PC6134.2 PC6135.2 PC6136.2 PC6137.2 PC6138.2 PC6140.2 PC6141.2 PC6500.2 PC6501.2 PC6502.2 PC6503.2 PC6504.2 PC6505.2 PC6506.2 PC6507.2 PC6508.2 PC6509.2 PC6510.2 PC6511.2 PC6512.2 PC6513.2 PC6514.2 PC6515.2 PC6516.2 PC6517.2 PC6518.2 PC6519.2 PC6520.2 PC6521.2 PC6522.2 PC6523.2 PC6524.2 PC6525.2 PC6526.2 PC6527.2 PC6528.2 PC6529.2 PC6530.2 PC6531.2 PC6532.2 PC6533.2 PC6534.2 PC6535.2 PC6536.2 PC6537.2 PC6538.2 PC6539.2 PC6540.2 PC6541.2 PC6542.2 PC6543.2 PC6544.2 PC6545.2 PC6546.2 PC6547.2 PC6548.2 PC6549.2 PC6550.2 PC6551.2 PC6552.2 PC6553.2 PC6554.2 PC6555.2 PC6556.2 PC6557.2 PC6558.2 PC6559.2 PC6560.2 PC6561.2 PC6562.2 PC6563.2 PC6564.2 PC6565.2 PC6566.2 PC6567.2 PC6568.2 PC6569.2 PC6570.2 PC6571.2 PC6572.2 PC6573.2 PC6574.2 PC6575.2 PC6576.2 PC6577.2 PC6578.2 PC6579.2 PC6580.2 PC6581.2 PC6582.2 PC6583.2 PC6584.2 PC6585.2 PC6586.2 PC6587.2 PC6588.2 PC6589.2 PD1.1 PD3.1 PD4.1 PH5000.1 PH5004.1 PJPDC1.2 PJPDC1.3 PJPDC1.4 PJPDC1.5 PQ2.3 PQ5.3 PQ6.1 PQ6.4 PQ7.1 PQ7.4 PQ8.3 PQ9.3 PQ202.1 PQ202.2 PQ202.3 PQ302.1 PQ302.2 PQ302.3 PQ304.1 PQ304.2 PQ304.3 PQ707.1 PQ707.2 PQ707.3 PQ708.3 PQ800.3 PQ800.4 PQ800.5 PQ801.3 PQ801.4 PQ801.5 PQ802.3 PQ6000.1 PQ6000.4 PR5.1 PR10V3.2 PR10V5.2 PR18V04.2 PR18V05.2 PR18V07.1 PR21.1 PR22.1 PR23.2 PR25V01.2 PR25V04.2 PR26.2 PR29.2 PR33.1 PR35.1 PR102.2 PR107.2 PR109.2 PR208.2 PR302.1 PR303.2 PR304.1 PR305.1 PR306.2 PR701.1 PR715.2 PR719.2 PR725.2 PR728.1 PR734.2 PR802.1 PR804.2 PR809.2 PR4005.2 PR4009.2 PR4010.1 PR4011.1 PR5010.1 PR5013.1 PR5016.2 PR5017.2 PR5018.2 PR5019.2 PR5026.2 PR5039.2 PR5047.2 PR5048.1 PR5110.1 PR5210.1 PR5231.1 PR6000.2 PR6013.1 PR6030.2 PR6036.2 PR6038.1 PR6054.1 PR6056.1 PR6057.1 PR6058.1 PR6059.1 PR6060.1 PR6063.1 PR6070.1 PR6105.1 PR6111.1 PR6119.1 PU10V0.11 PU18V00.7 PU18V00.8 PU18V00.18 PU18V00.21 PU25V00.8 PU25V00.9 PU100.7 PU100.8 PU100.18 PU100.21 PU200.1 PU200.3 PU200.14 PU200.21 PU300.21 PU700.22 PU700.29 PU800.11 PU4000.7 PU4000.8 PU4000.18 PU4000.21 PU5000.49 PU5101.4 PU5101.10 PU5101.23 PU5101.28 PU5102.4 PU5102.10 PU5102.23 PU5102.28 PU5103.4 PU5103.10 PU5103.23 PU5103.28 PU5201.4 PU5201.10 PU5201.23 PU5201.28 PU5202.4 PU5202.10 PU5202.23 PU5202.28 PU5203.3 PU5203.7 PU5203.10 PU5203.13 PU6000.41 PU6100.4 PU6100.10 PU6100.23 PU6100.28 PU6101.4 PU6101.10 PU6101.23 PU6101.28 PU6102.4 PU6102.10 PU6102.23 PU6102.28 QC5.1 QC5.4 QE5.3 QE20.1 QE20.4 QE21.1 QE21.4 QE23.1 QE23.4 QE24.1 QE24.4 QG2.3 QG3.3 QG4.3 QG9.3 QG23.1 QG23.4 QG502.1 QG503.1 QG503.4 QG504.1 QG504.4 QG505.1 QG505.4 QG509.1 QG509.4 QG513.1 QG513.4 QH6.3 QV2.3 QZ13.1 QZ13.4 R4.2 R5.2 RA9.2 RA12.2 RA13.2 RA14.2 RA15.2 RA16.2 RA33.2 RE4.1 RE21.2 RE22.2 RE23.2 RE27.1 RE35.2 RE67.1 RE114.1 RE151.1 RE152.2 RG22.2 RG23.1 RG24.2 RG26.2 RG37.2 RG53.2 RG54.2 RG55.2 RG56.2 RG57.2 RG58.2 RG65.1 RG68.2 RG69.2 RG87.1 RG88.1 RG89.1 RG90.1 RG91.1 RG92.1 RG93.1 RG94.1 RG95.1 RG98.2 RG101.2 RG105.2 RG106.2 RG107.2 RG108.2 RG109.2 RG112.2 RG116.2 RG117.2 RG118.2 RG119.2 RG120.2 RG123.2 RG127.2 RG128.2 RG129.2 RG130.2 RG131.2 RG134.2 RG165.1 RG518.2 RG557.2 RG562.2 RG573.2 RH13.1 RH29.2 RH33.2 RH41.2 RH57.1 RH58.1 RH59.2 RH60.1 RH61.1 RH77.2 RH94.2 RH95.1 RH109.2 RH112.2 RH113.2 RH127.2 RH148.1 RH149.1 RH150.1 RH166.1 RH183.2 RH184.2 RH185.2 RH186.2 RH187.2 RH188.2 RH209.2 RH210.2 RH211.2 RH212.2 RH516.2 RH518.2 RH548.2 RH550.2 RH552.2 RH554.2 RH558.2 RH560.2 RH562.2 RH567.1 RH571.2 RH581.1 RI3.2 RI11.1 RI23.1 RI25.1 RI45.2 RI46.1 RI47.1 RI48.1 RI49.2 RI51.1 RI54.1 RI55.1 RI56.1 RI57.1 RI58.1 RL27.1 RL30.2 RL31.1 RN4.2 RP32.2 RP39.1 RP40.1 RP41.1 RP42.1 RP43.1 RP44.1 RT3.2 RT4.2 RT5.2 RT11.2 RT17.2 RT18.2 RT19.2 RT24.2 RT34.2 RT35.2 RT36.2 RT37.2 RT38.2 RT39.2 RT40.2 RT41.2 RT42.2 RT43.2 RT44.2 RT45.2 RT46.2 RT47.2 RT62.2 RT63.2 RT68.2 RT69.2 RT71.2 RT72.2 RT73.2 RT75.2 RT78.2 RT79.2 RT83.1 RT108.2 RT111.2 RT113.2 RTPM7.2 RTPM9.2 RV536.2 RV537.2 RV551.2 RVGA4.2 RVGA5.2 RVGA10.1 RVGA11.2 RVGA12.2 RVGA13.2 RZ40.2 RZ71.2 SW5.4 U5603.5 U5603.6 U5603.7 U5603.8 UA1.2 UC1.3 UC16.3 UE1.17 UE1.51 UE1.64 UE1.84 UE1.100 UE1.124 UE3.1 UE4.2 UE6.3 UG1.A1 UG1.A3 UG1.A12 UG1.A14 UG1.B5 UG1.B10 UG1.C1 UG1.C3 UG1.C4 UG1.C11 UG1.C12 UG1.C14 UG1.D10 UG1.E1 UG1.E3 UG1.E12 UG1.E14 UG1.F5 UG1.F10 UG1.G5 UG1.G10 UG1.H1 UG1.H2 UG1.H13 UG1.H14 UG1.K1 UG1.K2 UG1.K13 UG1.K14 UG1.L5 UG1.L10 UG1.M5 UG1.M10 UG1.N1 UG1.N3 UG1.N12 UG1.N14 UG1.P10 UG1.R1 UG1.R3 UG1.R4 UG1.R11 UG1.R12 UG1.R14 UG1.T5 UG1.T10 UG1.U1 UG1.U3 UG1.U12 UG1.U14 UG2.A1 UG2.A3 UG2.A12 UG2.A14 UG2.B5 UG2.B10 UG2.C1 UG2.C3 UG2.C4 UG2.C11 UG2.C12 UG2.C14 UG2.D10 UG2.E1 UG2.E3 UG2.E12 UG2.E14 UG2.F5 UG2.F10 UG2.G5 UG2.G10 UG2.H1 UG2.H2 UG2.H13 UG2.H14 UG2.K1 UG2.K2 UG2.K13 UG2.K14 UG2.L5 UG2.L10 UG2.M5 UG2.M10 UG2.N1 UG2.N3 UG2.N12 UG2.N14 UG2.P10 UG2.R1 UG2.R3 UG2.R4 UG2.R11 UG2.R12 UG2.R14 UG2.T5 UG2.T10 UG2.U1 UG2.U3 UG2.U12 UG2.U14 UG3.A1 UG3.A3 UG3.A12 UG3.A14 UG3.B5 UG3.B10 UG3.C1 UG3.C3 UG3.C4 UG3.C11 UG3.C12 UG3.C14 UG3.D10 UG3.E1 UG3.E3 UG3.E12 UG3.E14 UG3.F5 UG3.F10 UG3.G5 UG3.G10 UG3.H1 UG3.H2 UG3.H13 UG3.H14 UG3.K1 UG3.K2 UG3.K13 UG3.K14 UG3.L5 UG3.L10 UG3.M5 UG3.M10 UG3.N1 UG3.N3 UG3.N12 UG3.N14 UG3.P10 UG3.R1 UG3.R3 UG3.R4 UG3.R11 UG3.R12 UG3.R14 UG3.T5 UG3.T10 UG3.U1 UG3.U3 UG3.U12 UG3.U14 UG4.A1 UG4.A3 UG4.A12 UG4.A14 UG4.B5 UG4.B10 UG4.C1 UG4.C3 UG4.C4 UG4.C11 UG4.C12 UG4.C14 UG4.D10 UG4.E1 UG4.E3 UG4.E12 UG4.E14 UG4.F5 UG4.F10 UG4.G5 UG4.G10 UG4.H1 UG4.H2 UG4.H13 UG4.H14 UG4.K1 UG4.K2 UG4.K13 UG4.K14 UG4.L5 UG4.L10 UG4.M5 UG4.M10 UG4.N1 UG4.N3 UG4.N12 UG4.N14 UG4.P10 UG4.R1 UG4.R3 UG4.R4 UG4.R11 UG4.R12 UG4.R14 UG4.T5 UG4.T10 UG4.U1 UG4.U3 UG4.U12 UG4.U14 UG5.A1 UG5.A3 UG5.A12 UG5.A14 UG5.B5 UG5.B10 UG5.C1 UG5.C3 UG5.C4 UG5.C11 UG5.C12 UG5.C14 UG5.D10 UG5.E1 UG5.E3 UG5.E12 UG5.E14 UG5.F5 UG5.F10 UG5.G5 UG5.G10 UG5.H1 UG5.H2 UG5.H13 UG5.H14 UG5.K1 UG5.K2 UG5.K13 UG5.K14 UG5.L5 UG5.L10 UG5.M5 UG5.M10 UG5.N1 UG5.N3 UG5.N12 UG5.N14 UG5.P10 UG5.R1 UG5.R3 UG5.R4 UG5.R11 UG5.R12 UG5.R14 UG5.T5 UG5.T10 UG5.U1 UG5.U3 UG5.U12 UG5.U14 UG6.A1 UG6.A3 UG6.A12 UG6.A14 UG6.B5 UG6.B10 UG6.C1 UG6.C3 UG6.C4 UG6.C11 UG6.C12 UG6.C14 UG6.D10 UG6.E1 UG6.E3 UG6.E12 UG6.E14 UG6.F5 UG6.F10 UG6.G5 UG6.G10 UG6.H1 UG6.H2 UG6.H13 UG6.H14 UG6.K1 UG6.K2 UG6.K13 UG6.K14 UG6.L5 UG6.L10 UG6.M5 UG6.M10 UG6.N1 UG6.N3 UG6.N12 UG6.N14 UG6.P10 UG6.R1 UG6.R3 UG6.R4 UG6.R11 UG6.R12 UG6.R14 UG6.T5 UG6.T10 UG6.U1 UG6.U3 UG6.U12 UG6.U14 UG9.A2 UG9.A3 UG9.A26 UG9.A29 UG9.A32 UG9.A50 UG9.A51 UG9.AA8 UG9.AA49 UG9.AB2 UG9.AB4 UG9.AB6 UG9.AB8 UG9.AB10 UG9.AB14 UG9.AB15 UG9.AB16 UG9.AB17 UG9.AB18 UG9.AB19 UG9.AB20 UG9.AB21 UG9.AB22 UG9.AB23 UG9.AB24 UG9.AB25 UG9.AB26 UG9.AB27 UG9.AB28 UG9.AB29 UG9.AB30 UG9.AB31 UG9.AB32 UG9.AB33 UG9.AB34 UG9.AB35 UG9.AB36 UG9.AB37 UG9.AB38 UG9.AB39 UG9.AB43 UG9.AB45 UG9.AB47 UG9.AB49 UG9.AB51 UG9.AD14 UG9.AD15 UG9.AD16 UG9.AD17 UG9.AD18 UG9.AD19 UG9.AD20 UG9.AD21 UG9.AD22 UG9.AD23 UG9.AD24 UG9.AD25 UG9.AD26 UG9.AD27 UG9.AD28 UG9.AD29 UG9.AD30 UG9.AD31 UG9.AD32 UG9.AD33 UG9.AD34 UG9.AD35 UG9.AD36 UG9.AD37 UG9.AD38 UG9.AD39 UG9.AD44 UG9.AE2 UG9.AE4 UG9.AE6 UG9.AE8 UG9.AE10 UG9.AE43 UG9.AE45 UG9.AE47 UG9.AE49 UG9.AE51 UG9.AF1 UG9.AF5 UG9.AF19 UG9.AF20 UG9.AF21 UG9.AF22 UG9.AF23 UG9.AF27 UG9.AF28 UG9.AF29 UG9.AF35 UG9.AF36 UG9.AF37 UG9.AF38 UG9.AF39 UG9.AF45 UG9.AG3 UG9.AG14 UG9.AG15 UG9.AG16 UG9.AG17 UG9.AG18 UG9.AG24 UG9.AG25 UG9.AG26 UG9.AG30 UG9.AG31 UG9.AG32 UG9.AG33 UG9.AG34 UG9.AG44 UG9.AH2 UG9.AH4 UG9.AH6 UG9.AH8 UG9.AH10 UG9.AH43 UG9.AH45 UG9.AH47 UG9.AH49 UG9.AH51 UG9.AJ2 UG9.AJ9 UG9.AJ14 UG9.AJ15 UG9.AJ16 UG9.AJ17 UG9.AJ18 UG9.AJ19 UG9.AJ20 UG9.AJ21 UG9.AJ22 UG9.AJ23 UG9.AJ24 UG9.AJ25 UG9.AJ26 UG9.AJ27 UG9.AJ28 UG9.AJ29 UG9.AJ30 UG9.AJ31 UG9.AJ32 UG9.AJ33 UG9.AJ34 UG9.AJ35 UG9.AJ36 UG9.AJ37 UG9.AJ38 UG9.AJ39 UG9.AK1 UG9.AK44 UG9.AK47 UG9.AL2 UG9.AL4 UG9.AL6 UG9.AL8 UG9.AL10 UG9.AL14 UG9.AL15 UG9.AL16 UG9.AL17 UG9.AL18 UG9.AL19 UG9.AL20 UG9.AL21 UG9.AL22 UG9.AL23 UG9.AL24 UG9.AL25 UG9.AL26 UG9.AL27 UG9.AL28 UG9.AL29 UG9.AL30 UG9.AL31 UG9.AL32 UG9.AL33 UG9.AL34 UG9.AL35 UG9.AL36 UG9.AL37 UG9.AL38 UG9.AL39 UG9.AL43 UG9.AL45 UG9.AL47 UG9.AL49 UG9.AL51 UG9.AM4 UG9.AM9 UG9.AN4 UG9.AN5 UG9.AN8 UG9.AN14 UG9.AN15 UG9.AN16 UG9.AN17 UG9.AN18 UG9.AN19 UG9.AN20 UG9.AN21 UG9.AN22 UG9.AN23 UG9.AN24 UG9.AN25 UG9.AN26 UG9.AN27 UG9.AN28 UG9.AN29 UG9.AN30 UG9.AN31 UG9.AN32 UG9.AN33 UG9.AN34 UG9.AN35 UG9.AN36 UG9.AN37 UG9.AN38 UG9.AN39 UG9.AP2 UG9.AP4 UG9.AP6 UG9.AP8 UG9.AP10 UG9.AP43 UG9.AP45 UG9.AP47 UG9.AP49 UG9.AP51 UG9.AR4 UG9.AR9 UG9.AR14 UG9.AR15 UG9.AR16 UG9.AR17 UG9.AR18 UG9.AR19 UG9.AR20 UG9.AR21 UG9.AR22 UG9.AR23 UG9.AR24 UG9.AR25 UG9.AR26 UG9.AR27 UG9.AR28 UG9.AR29 UG9.AR30 UG9.AR31 UG9.AR32 UG9.AR33 UG9.AR34 UG9.AR35 UG9.AR36 UG9.AR37 UG9.AR38 UG9.AR39 UG9.AR52 UG9.AT4 UG9.AT5 UG9.AT8 UG9.AT51 UG9.AT52 UG9.AU2 UG9.AU4 UG9.AU6 UG9.AU8 UG9.AU10 UG9.AU14 UG9.AU15 UG9.AU16 UG9.AU17 UG9.AU18 UG9.AU19 UG9.AU20 UG9.AU21 UG9.AU22 UG9.AU23 UG9.AU24 UG9.AU25 UG9.AU26 UG9.AU27 UG9.AU28 UG9.AU29 UG9.AU30 UG9.AU31 UG9.AU32 UG9.AU33 UG9.AU34 UG9.AU35 UG9.AU36 UG9.AU37 UG9.AU38 UG9.AU39 UG9.AU45 UG9.AU47 UG9.AU49 UG9.AU51 UG9.AV4 UG9.AV9 UG9.AV45 UG9.AW4 UG9.AW5 UG9.AW8 UG9.AW14 UG9.AW15 UG9.AW16 UG9.AW17 UG9.AW18 UG9.AW19 UG9.AW20 UG9.AW21 UG9.AW22 UG9.AW23 UG9.AW24 UG9.AW25 UG9.AW26 UG9.AW27 UG9.AW28 UG9.AW29 UG9.AW30 UG9.AW31 UG9.AW32 UG9.AW33 UG9.AW34 UG9.AW35 UG9.AW36 UG9.AW37 UG9.AW38 UG9.AW39 UG9.AW46 UG9.AW52 UG9.AY2 UG9.AY4 UG9.AY6 UG9.AY8 UG9.AY10 UG9.AY47 UG9.AY49 UG9.AY51 UG9.B1 UG9.B2 UG9.B5 UG9.B7 UG9.B10 UG9.B13 UG9.B16 UG9.B19 UG9.B22 UG9.B25 UG9.B28 UG9.B31 UG9.B34 UG9.B37 UG9.B40 UG9.B43 UG9.B46 UG9.B48 UG9.B51 UG9.B52 UG9.BA48 UG9.BB49 UG9.BC2 UG9.BC4 UG9.BC6 UG9.BC8 UG9.BC13 UG9.BC16 UG9.BC19 UG9.BC22 UG9.BC24 UG9.BC25 UG9.BC28 UG9.BC31 UG9.BC34 UG9.BC37 UG9.BC51 UG9.BD24 UG9.BD26 UG9.BD29 UG9.BD32 UG9.BD35 UG9.BD38 UG9.BD52 UG9.BE10 UG9.BE13 UG9.BE15 UG9.BE16 UG9.BE18 UG9.BE19 UG9.BE21 UG9.BE22 UG9.BE24 UG9.BE25 UG9.BE27 UG9.BE28 UG9.BE30 UG9.BE31 UG9.BE33 UG9.BE34 UG9.BE36 UG9.BE37 UG9.BE39 UG9.BE40 UG9.BF2 UG9.BF4 UG9.BF6 UG9.BF41 UG9.BG7 UG9.BG10 UG9.BG13 UG9.BG16 UG9.BG19 UG9.BG22 UG9.BG25 UG9.BG28 UG9.BG31 UG9.BG34 UG9.BG37 UG9.BG40 UG9.BG42 UG9.BH2 UG9.BH5 UG9.BH15 UG9.BH18 UG9.BH21 UG9.BH24 UG9.BH27 UG9.BH30 UG9.BH33 UG9.BH36 UG9.BH39 UG9.BH42 UG9.BJ7 UG9.BJ10 UG9.BJ12 UG9.BJ13 UG9.BJ14 UG9.BJ15 UG9.BJ16 UG9.BJ17 UG9.BJ18 UG9.BJ19 UG9.BJ20 UG9.BJ21 UG9.BJ22 UG9.BJ23 UG9.BJ24 UG9.BJ25 UG9.BJ26 UG9.BJ27 UG9.BJ28 UG9.BJ29 UG9.BJ30 UG9.BJ31 UG9.BJ32 UG9.BJ33 UG9.BJ34 UG9.BJ35 UG9.BJ36 UG9.BJ37 UG9.BJ38 UG9.BJ39 UG9.BJ40 UG9.BJ41 UG9.BJ42 UG9.BJ43 UG9.BK1 UG9.BL1 UG9.BL2 UG9.BL5 UG9.BL7 UG9.BL10 UG9.BL13 UG9.BL16 UG9.BL19 UG9.BL22 UG9.BL25 UG9.BL28 UG9.BL31 UG9.BL34 UG9.BL37 UG9.BL40 UG9.BL43 UG9.BM2 UG9.BM3 UG9.C1 UG9.C5 UG9.C29 UG9.C33 UG9.C51 UG9.C52 UG9.D4 UG9.D7 UG9.D10 UG9.D12 UG9.D13 UG9.D16 UG9.D19 UG9.D22 UG9.D24 UG9.D25 UG9.D28 UG9.D30 UG9.D31 UG9.D34 UG9.D37 UG9.D40 UG9.D43 UG9.D46 UG9.D49 UG9.E2 UG9.E4 UG9.E5 UG9.E8 UG9.E48 UG9.E51 UG9.F7 UG9.F10 UG9.F13 UG9.F16 UG9.F17 UG9.F19 UG9.F21 UG9.F22 UG9.F25 UG9.F28 UG9.F31 UG9.F34 UG9.F35 UG9.F37 UG9.F40 UG9.F43 UG9.F44 UG9.F46 UG9.F52 UG9.G2 UG9.G4 UG9.G6 UG9.G38 UG9.G47 UG9.G49 UG9.G51 UG9.H1 UG9.H10 UG9.H13 UG9.H16 UG9.H19 UG9.H22 UG9.H25 UG9.H28 UG9.H31 UG9.H34 UG9.H37 UG9.H40 UG9.H43 UG9.J1 UG9.J12 UG9.J17 UG9.J20 UG9.J38 UG9.J49 UG9.J52 UG9.K2 UG9.K4 UG9.K6 UG9.K8 UG9.K13 UG9.K16 UG9.K19 UG9.K22 UG9.K25 UG9.K28 UG9.K31 UG9.K34 UG9.K37 UG9.K40 UG9.K45 UG9.K47 UG9.K49 UG9.K51 UG9.M6 UG9.M52 UG9.N2 UG9.N4 UG9.N6 UG9.N8 UG9.N10 UG9.N43 UG9.N45 UG9.N47 UG9.N49 UG9.N51 UG9.P14 UG9.P15 UG9.P16 UG9.P17 UG9.P18 UG9.P19 UG9.P20 UG9.P21 UG9.P22 UG9.P23 UG9.P24 UG9.P25 UG9.P26 UG9.P27 UG9.P28 UG9.P29 UG9.P30 UG9.P31 UG9.P32 UG9.P33 UG9.P34 UG9.P35 UG9.P36 UG9.P37 UG9.P38 UG9.P39 UG9.P51 UG9.R49 UG9.R52 UG9.T2 UG9.T4 UG9.T6 UG9.T8 UG9.T10 UG9.T14 UG9.T15 UG9.T16 UG9.T17 UG9.T18 UG9.T19 UG9.T20 UG9.T21 UG9.T22 UG9.T23 UG9.T24 UG9.T25 UG9.T26 UG9.T27 UG9.T28 UG9.T29 UG9.T30 UG9.T31 UG9.T32 UG9.T33 UG9.T34 UG9.T35 UG9.T36 UG9.T37 UG9.T38 UG9.T39 UG9.T43 UG9.T45 UG9.T47 UG9.T49 UG9.T51 UG9.U7 UG9.U9 UG9.V14 UG9.V15 UG9.V16 UG9.V17 UG9.V18 UG9.V19 UG9.V20 UG9.V21 UG9.V22 UG9.V23 UG9.V24 UG9.V25 UG9.V26 UG9.V27 UG9.V28 UG9.V29 UG9.V30 UG9.V31 UG9.V32 UG9.V33 UG9.V34 UG9.V35 UG9.V36 UG9.V37 UG9.V38 UG9.V39 UG9.V49 UG9.V52 UG9.W2 UG9.W4 UG9.W6 UG9.W8 UG9.W10 UG9.W43 UG9.W45 UG9.W47 UG9.W49 UG9.W51 UG9.Y9 UG9.Y14 UG9.Y15 UG9.Y16 UG9.Y17 UG9.Y18 UG9.Y19 UG9.Y20 UG9.Y21 UG9.Y22 UG9.Y23 UG9.Y24 UG9.Y25 UG9.Y26 UG9.Y27 UG9.Y28 UG9.Y29 UG9.Y30 UG9.Y31 UG9.Y32 UG9.Y33 UG9.Y34 UG9.Y35 UG9.Y36 UG9.Y37 UG9.Y38 UG9.Y39 UG10.3 UG11.3 UG11.17 UG12.11 UG12.15 UG13.4 UG14.5 UG22.3 UG25.3 UG26.3 UG27.3 UG29.3 UG30.3 UG31.3 UH1.A3 UH1.A4 UH1.A6 UH1.A9 UH1.A10 UH1.A12 UH1.A14 UH1.A16 UH1.A18 UH1.A20 UH1.A22 UH1.A24 UH1.A26 UH1.A28 UH1.A30 UH1.A34 UH1.A36 UH1.A37 UH1.AA12 UH1.AA29 UH1.AA30 UH1.AB6 UH1.AB33 UH1.AB34 UH1.AC1 UH1.AC2 UH1.AC3 UH1.AC4 UH1.AC5 UH1.AC6 UH1.AC12 UH1.AC37 UH1.AC38 UH1.AD6 UH1.AD7 UH1.AD8 UH1.AD9 UH1.AD10 UH1.AD11 UH1.AD12 UH1.AD29 UH1.AD30 UH1.AE6 UH1.AE33 UH1.AE34 UH1.AF1 UH1.AF2 UH1.AF3 UH1.AF4 UH1.AF12 UH1.AF13 UH1.AF14 UH1.AG6 UH1.AG7 UH1.AG8 UH1.AG10 UH1.AG11 UH1.AG29 UH1.AG30 UH1.AH6 UH1.AH12 UH1.AH33 UH1.AH34 UH1.AJ1 UH1.AJ2 UH1.AJ3 UH1.AJ4 UH1.AJ5 UH1.AJ6 UH1.AJ37 UH1.AJ38 UH1.AK4 UH1.AK29 UH1.AK30 UH1.AL4 UH1.AL7 UH1.AL8 UH1.AL9 UH1.AL10 UH1.AL12 UH1.AL14 UH1.AL33 UH1.AL34 UH1.AM1 UH1.AM2 UH1.AM3 UH1.AM4 UH1.AM5 UH1.AM12 UH1.AM37 UH1.AM38 UH1.AN5 UH1.AN6 UH1.AN12 UH1.AN29 UH1.AN30 UH1.AP8 UH1.AP9 UH1.AP10 UH1.AP11 UH1.AP12 UH1.AP33 UH1.AP34 UH1.AR1 UH1.AR2 UH1.AR3 UH1.AR4 UH1.AR5 UH1.AR13 UH1.AR14 UH1.AR37 UH1.AR38 UH1.AT6 UH1.AT29 UH1.AT30 UH1.AU6 UH1.AU7 UH1.AU8 UH1.AU9 UH1.AU10 UH1.AU11 UH1.AU12 UH1.AU33 UH1.AU34 UH1.AV37 UH1.AV38 UH1.AW1 UH1.AW2 UH1.AW3 UH1.AW4 UH1.AW5 UH1.AW12 UH1.AW29 UH1.AW30 UH1.AY12 UH1.AY14 UH1.AY33 UH1.AY34 UH1.B3 UH1.B9 UH1.B37 UH1.BA6 UH1.BA7 UH1.BA8 UH1.BA9 UH1.BA10 UH1.BA11 UH1.BA12 UH1.BA37 UH1.BA38 UH1.BB1 UH1.BB2 UH1.BB3 UH1.BB4 UH1.BB5 UH1.BB6 UH1.BB12 UH1.BB29 UH1.BB30 UH1.BC6 UH1.BC12 UH1.BC13 UH1.BC14 UH1.BC33 UH1.BC34 UH1.BD6 UH1.BD7 UH1.BD8 UH1.BD9 UH1.BD10 UH1.BD11 UH1.BD12 UH1.BD37 UH1.BD38 UH1.BE1 UH1.BE2 UH1.BE3 UH1.BE4 UH1.BE5 UH1.BE6 UH1.BE29 UH1.BE30 UH1.BF6 UH1.BF12 UH1.BF33 UH1.BF34 UH1.BG6 UH1.BG12 UH1.BG13 UH1.BG14 UH1.BG37 UH1.BG38 UH1.BH1 UH1.BH2 UH1.BH3 UH1.BH4 UH1.BH5 UH1.BH6 UH1.BH7 UH1.BH8 UH1.BH9 UH1.BH10 UH1.BH11 UH1.BH12 UH1.BH14 UH1.BJ12 UH1.BJ15 UH1.BJ18 UH1.BJ22 UH1.BJ25 UH1.BJ29 UH1.BJ30 UH1.BJ31 UH1.BJ32 UH1.BK6 UH1.BK13 UH1.BK14 UH1.BK15 UH1.BK18 UH1.BK22 UH1.BK25 UH1.BK29 UH1.BL6 UH1.BL13 UH1.BL29 UH1.BL35 UH1.BL38 UH1.BM2 UH1.BM3 UH1.BM5 UH1.BM6 UH1.BM7 UH1.BM8 UH1.BM9 UH1.BM11 UH1.BM12 UH1.BM13 UH1.BM18 UH1.BM21 UH1.BM23 UH1.BM25 UH1.BM26 UH1.BM27 UH1.BM28 UH1.BM29 UH1.BM35 UH1.BM38 UH1.BN2 UH1.BN4 UH1.BN7 UH1.BN9 UH1.BN12 UH1.BN14 UH1.BN18 UH1.BN19 UH1.BN20 UH1.BN21 UH1.BN24 UH1.BN29 UH1.BN30 UH1.BN31 UH1.BN34 UH1.BP7 UH1.BP12 UH1.BP14 UH1.BP18 UH1.BP21 UH1.BP24 UH1.BP26 UH1.BP29 UH1.BP33 UH1.BP34 UH1.BR7 UH1.BR12 UH1.BR14 UH1.BR18 UH1.BR21 UH1.BR24 UH1.BR26 UH1.BR29 UH1.BR34 UH1.BR36 UH1.BR38 UH1.BT3 UH1.BT4 UH1.BT5 UH1.BT9 UH1.BT12 UH1.BT14 UH1.BT18 UH1.BT21 UH1.BT24 UH1.BT26 UH1.BT32 UH1.BT35 UH1.BT36 UH1.C2 UH1.C5 UH1.C8 UH1.C9 UH1.C11 UH1.C13 UH1.C15 UH1.C17 UH1.C19 UH1.C21 UH1.C23 UH1.C25 UH1.C27 UH1.C29 UH1.C31 UH1.C37 UH1.D3 UH1.D6 UH1.D9 UH1.D10 UH1.D12 UH1.D14 UH1.D16 UH1.D18 UH1.D20 UH1.D22 UH1.D24 UH1.D26 UH1.D28 UH1.D30 UH1.D33 UH1.D38 UH1.E4 UH1.E9 UH1.E34 UH1.E35 UH1.E38 UH1.F2 UH1.F3 UH1.F4 UH1.F5 UH1.F8 UH1.F9 UH1.F11 UH1.F13 UH1.F15 UH1.F17 UH1.F19 UH1.F21 UH1.F23 UH1.F25 UH1.F27 UH1.F29 UH1.F31 UH1.F36 UH1.G4 UH1.G5 UH1.G6 UH1.G8 UH1.G9 UH1.G10 UH1.G12 UH1.G14 UH1.G16 UH1.G18 UH1.G20 UH1.G22 UH1.G23 UH1.G24 UH1.G26 UH1.G28 UH1.H11 UH1.H12 UH1.H18 UH1.H22 UH1.H25 UH1.H32 UH1.H35 UH1.J4 UH1.J7 UH1.J10 UH1.J18 UH1.J22 UH1.J25 UH1.J32 UH1.J33 UH1.J36 UH1.K1 UH1.K2 UH1.K3 UH1.K4 UH1.K5 UH1.K7 UH1.K8 UH1.K9 UH1.K10 UH1.K11 UH1.K38 UH1.L29 UH1.L30 UH1.L33 UH1.L34 UH1.M6 UH1.M12 UH1.M13 UH1.M14 UH1.N1 UH1.N2 UH1.N3 UH1.N4 UH1.N5 UH1.N6 UH1.N7 UH1.N8 UH1.N9 UH1.N10 UH1.N11 UH1.N12 UH1.N33 UH1.N34 UH1.P6 UH1.P12 UH1.P37 UH1.P38 UH1.R12 UH1.R29 UH1.R30 UH1.T1 UH1.T2 UH1.T3 UH1.T4 UH1.T5 UH1.T7 UH1.T8 UH1.T9 UH1.T10 UH1.T11 UH1.T12 UH1.T13 UH1.T14 UH1.T33 UH1.T34 UH1.U6 UH1.U37 UH1.U38 UH1.V6 UH1.V12 UH1.V29 UH1.V30 UH1.W1 UH1.W2 UH1.W3 UH1.W4 UH1.W5 UH1.W12 UH1.W33 UH1.W34 UH1.Y7 UH1.Y8 UH1.Y9 UH1.Y10 UH1.Y11 UH1.Y13 UH1.Y14 UH1.Y37 UH1.Y38 UH2.A2 UH2.A3 UH2.A4 UH2.A18 UH2.A25 UH2.A32 UH2.A37 UH2.A42 UH2.A44 UH2.AA4 UH2.AA17 UH2.AA18 UH2.AA20 UH2.AA21 UH2.AA25 UH2.AA29 UH2.AA42 UH2.AB4 UH2.AB5 UH2.AB7 UH2.AB8 UH2.AB10 UH2.AB11 UH2.AB14 UH2.AB15 UH2.AB31 UH2.AB32 UH2.AB38 UH2.AC1 UH2.AC18 UH2.AC20 UH2.AC21 UH2.AC25 UH2.AC29 UH2.AC45 UH2.AD4 UH2.AD8 UH2.AD11 UH2.AD14 UH2.AD32 UH2.AD33 UH2.AD36 UH2.AE4 UH2.AE18 UH2.AE20 UH2.AE21 UH2.AE25 UH2.AE28 UH2.AE29 UH2.AE42 UH2.AF18 UH2.AF20 UH2.AF21 UH2.AF23 UH2.AF25 UH2.AF26 UH2.AF28 UH2.AF29 UH2.AG4 UH2.AG11 UH2.AG13 UH2.AG31 UH2.AG32 UH2.AG33 UH2.AG38 UH2.AH1 UH2.AH17 UH2.AH18 UH2.AH20 UH2.AH21 UH2.AH23 UH2.AH25 UH2.AH26 UH2.AH28 UH2.AH29 UH2.AH45 UH2.AJ10 UH2.AJ14 UH2.AJ15 UH2.AJ17 UH2.AJ18 UH2.AJ26 UH2.AJ28 UH2.AJ29 UH2.AJ31 UH2.AJ32 UH2.AJ36 UH2.AK4 UH2.AK42 UH2.AL4 UH2.AL10 UH2.AL11 UH2.AL13 UH2.AL17 UH2.AL19 UH2.AL24 UH2.AL29 UH2.AL32 UH2.AL33 UH2.AL38 UH2.AM15 UH2.AM17 UH2.AM19 UH2.AM22 UH2.AM24 UH2.AM27 UH2.AM29 UH2.AM45 UH2.AN4 UH2.AN7 UH2.AN8 UH2.AN10 UH2.AN11 UH2.AN22 UH2.AN27 UH2.AN31 UH2.AN39 UH2.AP4 UH2.AP11 UH2.AR5 UH2.AR7 UH2.AR9 UH2.AR33 UH2.AR34 UH2.AR42 UH2.AT9 UH2.AT10 UH2.AT15 UH2.AT36 UH2.AU1 UH2.AU7 UH2.AU35 UH2.AU36 UH2.AU39 UH2.AU45 UH2.AV6 UH2.AV17 UH2.AV24 UH2.AV27 UH2.AV31 UH2.AV33 UH2.AW9 UH2.AW13 UH2.AW19 UH2.AW29 UH2.AW37 UH2.AY38 UH2.AY45 UH2.B1 UH2.B2 UH2.B3 UH2.B6 UH2.B25 UH2.B37 UH2.B40 UH2.B44 UH2.B45 UH2.BA1 UH2.BB1 UH2.BB11 UH2.BB16 UH2.BB21 UH2.BB25 UH2.BB30 UH2.BB34 UH2.BC1 UH2.BC2 UH2.BD2 UH2.BD43 UH2.BD44 UH2.BD45 UH2.BE9 UH2.BE14 UH2.BE18 UH2.BE23 UH2.BE28 UH2.BE32 UH2.BE37 UH2.BE40 UH2.BE44 UH2.C1 UH2.C2 UH2.C4 UH2.C10 UH2.C28 UH2.C37 UH2.C42 UH2.D1 UH2.D10 UH2.D12 UH2.D15 UH2.D16 UH2.D17 UH2.D19 UH2.D21 UH2.D24 UH2.D25 UH2.D27 UH2.D29 UH2.D30 UH2.D31 UH2.D33 UH2.D35 UH2.D36 UH2.D45 UH2.E13 UH2.E15 UH2.E31 UH2.E33 UH2.F8 UH2.F44 UH2.G9 UH2.G42 UH2.H3 UH2.H17 UH2.H19 UH2.H22 UH2.H24 UH2.H27 UH2.H29 UH2.H35 UH2.J3 UH2.J5 UH2.J7 UH2.J10 UH2.J11 UH2.J39 UH2.K4 UH2.K10 UH2.K27 UH2.K33 UH2.K36 UH2.K42 UH2.K43 UH2.L4 UH2.L8 UH2.L12 UH2.L13 UH2.L15 UH2.L41 UH2.M35 UH2.M42 UH2.N4 UH2.N5 UH2.N10 UH2.N15 UH2.N19 UH2.N22 UH2.N24 UH2.N35 UH2.N36 UH2.N41 UH2.P17 UH2.P19 UH2.P22 UH2.P45 UH2.R5 UH2.R10 UH2.R14 UH2.R22 UH2.R29 UH2.R33 UH2.R38 UH2.T1 UH2.T2 UH2.T4 UH2.T42 UH2.U4 UH2.U8 UH2.U10 UH2.U11 UH2.U14 UH2.U15 UH2.U17 UH2.U18 UH2.U28 UH2.U29 UH2.U31 UH2.U32 UH2.U33 UH2.U38 UH2.V3 UH2.V18 UH2.V20 UH2.V21 UH2.V23 UH2.V25 UH2.V29 UH2.V45 UH2.W4 UH2.W8 UH2.W14 UH2.W31 UH2.W32 UH2.W33 UH2.W38 UH2.Y17 UH2.Y18 UH2.Y20 UH2.Y21 UH2.Y26 UH2.Y28 UH2.Y29 UH7.3 UH8.4 UH14.3 UI3.10 UI3.21 UI3.25 UL1.33 UL2.2 UP2.49 UR1.24 UR1.25 US1.14 US1.17 US2.2 UT1.A1 UT1.A6 UT1.A8 UT1.A10 UT1.A12 UT1.A14 UT1.A16 UT1.A18 UT1.A20 UT1.A22 UT1.AA22 UT1.AA23 UT1.AB1 UT1.AB2 UT1.AB6 UT1.AB8 UT1.AB10 UT1.AB12 UT1.AB14 UT1.AB16 UT1.AB18 UT1.AB20 UT1.AB22 UT1.AC1 UT1.AC2 UT1.AC6 UT1.AC8 UT1.AC10 UT1.AC12 UT1.AC14 UT1.AC16 UT1.AC18 UT1.AC20 UT1.AC22 UT1.B1 UT1.B2 UT1.B6 UT1.B8 UT1.B10 UT1.B12 UT1.B14 UT1.B16 UT1.B18 UT1.B20 UT1.B22 UT1.C22 UT1.C23 UT1.D5 UT1.D6 UT1.D8 UT1.D9 UT1.D11 UT1.D12 UT1.D13 UT1.D15 UT1.D16 UT1.D18 UT1.E4 UT1.E5 UT1.E6 UT1.E8 UT1.E9 UT1.E11 UT1.E15 UT1.E16 UT1.E22 UT1.E23 UT1.F5 UT1.F6 UT1.F9 UT1.F16 UT1.F20 UT1.G22 UT1.G23 UT1.H1 UT1.H2 UT1.H5 UT1.H8 UT1.H12 UT1.H13 UT1.H15 UT1.H16 UT1.H20 UT1.J5 UT1.J8 UT1.J12 UT1.J13 UT1.J15 UT1.J18 UT1.J19 UT1.J20 UT1.J22 UT1.J23 UT1.K1 UT1.K2 UT1.L5 UT1.L13 UT1.L15 UT1.L20 UT1.L22 UT1.L23 UT1.M1 UT1.M2 UT1.M5 UT1.M11 UT1.M12 UT1.M19 UT1.M20 UT1.N5 UT1.N8 UT1.N9 UT1.N11 UT1.N12 UT1.N13 UT1.N15 UT1.N20 UT1.N22 UT1.N23 UT1.P1 UT1.P2 UT1.R5 UT1.R18 UT1.R19 UT1.R20 UT1.R22 UT1.R23 UT1.T1 UT1.T2 UT1.T5 UT1.T6 UT1.T8 UT1.T9 UT1.T13 UT1.T15 UT1.T16 UT1.T18 UT1.T20 UT1.U22 UT1.U23 UT1.V5 UT1.V6 UT1.V8 UT1.V9 UT1.V15 UT1.V16 UT1.V20 UT1.W5 UT1.W6 UT1.W8 UT1.W9 UT1.W13 UT1.W18 UT1.W20 UT1.W22 UT1.W23 UT1.Y9 UT1.Y13 UT1.Y20 UT2.4 UT4.A1 UT4.A6 UT4.A7 UT4.A8 UT4.B7 UT4.B8 UT4.D8 UT4.E5 UT4.E6 UT4.E7 UT4.E8 UT4.F5 UT4.F6 UT4.F7 UT4.F8 UT4.G5 UT4.G6 UT4.G7 UT4.G8 UT4.H4 UT4.H5 UT4.H8 UT4.K9 UT4.K10 UT4.L1 UT5.4 UTH1.6 UTPM1.9 UTPM1.16 UTPM1.23 UTPM1.32 UTPM1.33 UV17.2 UVGA1.24 UVGA1.33 UZ1.11 UZ1.15 UZ8.2 UZ9.5 UZ15.5 UZ16.5 UZ16.9 UZ21.3 YG1.2 YG1.4 YH2.2 YH2.4 YL2.2 YL2.4 YT1.2 YT1.4
V18: CR8.2 UR1.1
VCC_1.8V: PC18V08.1 PU18V00.16 PU18V00.17
VCC_CHG: PD700.1 PR711.1 R3.1
VCC_CHG_1: PC715.2 PR711.2 PU700.28
VCC_CORE_PH1: PL5101.2 PR5106.1 PR5107.2 PR5108.1 PU5101.11 PU5101.12 PU5101.13 PU5101.14 PU5101.15 PU5101.16 PU5101.17 PU5101.18 PU5101.19 PU5101.20 PU5101.21
VCC_CORE_PH2: PL5102.2 PR5119.2 PR5120.1 PR5121.1 PU5102.11 PU5102.12 PU5102.13 PU5102.14 PU5102.15 PU5102.16 PU5102.17 PU5102.18 PU5102.19 PU5102.20 PU5102.21
VCC_CORE_PH3: PL5103.2 PR5131.1 PR5132.2 PR5133.1 PU5103.11 PU5103.12 PU5103.13 PU5103.14 PU5103.15 PU5103.16 PU5103.17 PU5103.18 PU5103.19 PU5103.20 PU5103.21
VCC_GT_PH1: PL5201.2 PR5206.1 PR5207.2 PR5208.1 PU5201.11 PU5201.12 PU5201.13 PU5201.14 PU5201.15 PU5201.16 PU5201.17 PU5201.18 PU5201.19 PU5201.20 PU5201.21
VCC_GT_PH2: PL5202.2 PR5218.1 PR5219.2 PR5220.1 PU5202.11 PU5202.12 PU5202.13 PU5202.14 PU5202.15 PU5202.16 PU5202.17 PU5202.18 PU5202.19 PU5202.20 PU5202.21
VCC_VCCIO: PC4012.1 PU4000.16 PU4000.17
VCCGT_SENSE: PC5009.1 PR5031.2 RH204.2
VCCIO_EN: CZ108.1 DZ2.2 PR4003.1 RZ108.2
VCCIO_SENSE: PR4007.2 RH514.2
VCCSA_SENSE: PC5015.2 PR5033.2 RH202.2
VCCSENSE: PC5034.1 PR5050.1 RH198.2
VCCST_EN: RZ111.2 RZ112.2 UZ15.4
VCCST_PWRGD_CPU: RH154.2 UH1.H13
VDD_1.2V: PC214.1 PR201.1 PR203.2 PU200.11
VDD_DAC_33: CVGA2.2 CVGA3.1 RVGA2.2 UVGA1.20
VDDP_1.2V: PC209.2 PR204.2 PU200.12
VIN: PC3.1 PC4.1 PC19.1 PC20.1 PC700.1 PC701.1 PD700.2 PL1.2 PL2.2 PL6.2 PL7.2 PL8.2 PL9.2 PQ701.5 PQ702.5 PR15.1 PR16.2 PR31.1 PR720.1
VIN1N: CG62.2 RG59.2 UG11.11
VIN1P: CG62.1 RG62.2 UG11.12
VIN2N: CG63.2 RG64.2 UG11.14
VIN2P: CG63.1 RG66.2 UG11.15
VIN_2.5V: PC25V01.1 PC25V02.1 PJP25V1.2 PU25V00.3
VINMON: PR6000.1 PR6006.2 PU6000.27
VSSGT_SENSE: PC5014.1 PU5000.6 RH32.2
VSSIO_SENSE: PR4010.2 RH513.2
VSSSA_SENSE: PC5016.1 PU5000.31 RH31.2
VSSSENSE: PC5035.1 PU5000.18 RH28.2
+CHGRTC: DC2.3 PJP1304.2
+CRT_5V_OUT: CVGA22.1 FVGA1.1 JCRT1.9 RVGA7.2 RVGA8.2
+DCPRTC: CH70.1 UH2.BA26
+DEBUG_PWR: JESPI1.1 JESPI1.2 RE130.2
+EDPVDD: CV576.1 CV577.1 CZ41.1 JEDP1.20 JEDP1.21 JEDP1.22 RZ35.2
+EDPVDD_OUT: RZ35.1 UZ8.1
+FBA_VREFC: CG78.1 CG79.1 RG110.2 RG111.2 RG112.1 UG1.J14 UG2.J14
+FBB_VREFC: CG113.1 CG114.1 RG121.2 RG122.2 RG123.1 UG3.J14 UG4.J14
+FBC_VREFC: CG148.1 CG149.1 RG132.2 RG133.2 RG134.1 UG5.J14 UG6.J14
+FBX_PLLAVDD: CG54.1 CG55.1 CG56.1 CG57.1 CG58.1 CG59.1 CG60.1 LG6.1 LG7.1 UG9.AF42 UG9.AN42 UG9.L17 UG9.L29 UG9.L38 UG9.V11
+IFPX_PLLVDD: CG47.1 LG8.2 UG9.BD18
+INV_PWR_SRC: CV579.1 CV922.1 F2.2 JEDP1.1 JEDP1.2 JEDP1.3 QV11.1 QV11.2 QV11.5 QV11.6
+LAN_IO: CL15.1 CL19.1 CL21.1 CL43.1 CL44.1 RL42.1 UL1.11 UL1.23 UL1.32 UL2.1
+LAN_VDD: CL20.1 CL22.1 CL24.1 CL32.1 CL34.1 CL35.1 CL42.1 UL1.3 UL1.8 UL1.22 UL1.24 UL1.30
+NVVDD1: CG244.1 CG245.1 PC6107.1 PC6121.1 PC6140.1 PC6500.1 PC6501.1 PC6502.1 PC6503.1 PC6504.1 PC6505.1 PC6506.1 PC6507.1 PC6508.1 PC6509.1 PC6510.1 PC6511.1 PC6512.1 PC6513.1 PC6514.1 PC6515.1 PC6516.1 PC6517.1 PC6518.1 PC6519.1 PC6520.1 PC6521.1 PC6522.1 PC6523.1 PC6524.1 PC6525.1 PC6526.1 PC6527.1 PC6528.1 PC6529.1 PC6530.1 PC6531.1 PC6532.1 PC6533.1 PC6534.1 PC6535.1 PC6536.1 PC6537.1 PC6538.1 PC6539.1 PC6540.1 PC6541.1 PC6542.1 PC6543.1 PC6544.1 PC6545.1 PC6546.1 PC6547.1 PC6548.1 PC6549.1 PC6550.1 PC6551.1 PC6552.1 PC6553.1 PC6554.1 PC6555.1 PC6556.1 PC6557.1 PC6558.1 PC6559.1 PC6560.1 PC6561.1 PC6562.1 PC6563.1 PC6564.1 PC6565.1 PC6566.1 PC6567.1 PC6568.1 PC6569.1 PC6570.1 PC6571.1 PC6572.1 PC6573.1 PC6574.1 PC6575.1 PC6576.1 PC6577.1 PC6578.1 PC6579.1 PC6580.1 PC6581.1 PC6582.1 PC6583.1 PC6584.1 PC6585.1 PC6586.1 PC6587.1 PC6588.1 PC6589.1 PL6101.4 PL6102.4 PL6103.4 PR6023.2 UG9.AA14 UG9.AA15 UG9.AA16 UG9.AA17 UG9.AA18 UG9.AA19 UG9.AA20 UG9.AA21 UG9.AA22 UG9.AA23 UG9.AA24 UG9.AA25 UG9.AA26 UG9.AA27 UG9.AA28 UG9.AA29 UG9.AA30 UG9.AA31 UG9.AA32 UG9.AA33 UG9.AA34 UG9.AA35 UG9.AA36 UG9.AA37 UG9.AA38 UG9.AA39 UG9.AB13 UG9.AB40 UG9.AC14 UG9.AC15 UG9.AC16 UG9.AC17 UG9.AC18 UG9.AC19 UG9.AC20 UG9.AC21 UG9.AC22 UG9.AC23 UG9.AC24 UG9.AC25 UG9.AC26 UG9.AC27 UG9.AC28 UG9.AC29 UG9.AC30 UG9.AC31 UG9.AC32 UG9.AC33 UG9.AC34 UG9.AC35 UG9.AC36 UG9.AC37 UG9.AC38 UG9.AC39 UG9.AE14 UG9.AE15 UG9.AE16 UG9.AE17 UG9.AE18 UG9.AE19 UG9.AE20 UG9.AE21 UG9.AE22 UG9.AE23 UG9.AE24 UG9.AE25 UG9.AE26 UG9.AE27 UG9.AE28 UG9.AE29 UG9.AE30 UG9.AE31 UG9.AE32 UG9.AE33 UG9.AE34 UG9.AE35 UG9.AE36 UG9.AE37 UG9.AE38 UG9.AE39 UG9.AF13 UG9.AF14 UG9.AF15 UG9.AF16 UG9.AF17 UG9.AF18 UG9.AF24 UG9.AF25 UG9.AF26 UG9.AF30 UG9.AF31 UG9.AF32 UG9.AF33 UG9.AF34 UG9.AF40 UG9.AG13 UG9.AG19 UG9.AG20 UG9.AG21 UG9.AG22 UG9.AG23 UG9.AG27 UG9.AG28 UG9.AG29 UG9.AG35 UG9.AG36 UG9.AG37 UG9.AG38 UG9.AG39 UG9.AG40 UG9.AH14 UG9.AH15 UG9.AH16 UG9.AH17 UG9.AH18 UG9.AH19 UG9.AH20 UG9.AH21 UG9.AH22 UG9.AH23 UG9.AH24 UG9.AH25 UG9.AH26 UG9.AH27 UG9.AH28 UG9.AH29 UG9.AH30 UG9.AH31 UG9.AH32 UG9.AH33 UG9.AH34 UG9.AH35 UG9.AH36 UG9.AH37 UG9.AH38 UG9.AH39 UG9.AK14 UG9.AK15 UG9.AK16 UG9.AK17 UG9.AK18 UG9.AK19 UG9.AK20 UG9.AK21 UG9.AK22 UG9.AK23 UG9.AK24 UG9.AK25 UG9.AK26 UG9.AK27 UG9.AK28 UG9.AK29 UG9.AK30 UG9.AK31 UG9.AK32 UG9.AK33 UG9.AK34 UG9.AK35 UG9.AK36 UG9.AK37 UG9.AK38 UG9.AK39 UG9.AL13 UG9.AL40 UG9.AM14 UG9.AM15 UG9.AM16 UG9.AM17 UG9.AM18 UG9.AM19 UG9.AM20 UG9.AM21 UG9.AM22 UG9.AM23 UG9.AM24 UG9.AM25 UG9.AM26 UG9.AM27 UG9.AM28 UG9.AM29 UG9.AM30 UG9.AM31 UG9.AM32 UG9.AM33 UG9.AM34 UG9.AM35 UG9.AM36 UG9.AM37 UG9.AM38 UG9.AM39 UG9.AP14 UG9.AP15 UG9.AP16 UG9.AP17 UG9.AP18 UG9.AP19 UG9.AP20 UG9.AP21 UG9.AP22 UG9.AP23 UG9.AP24 UG9.AP25 UG9.AP26 UG9.AP27 UG9.AP28 UG9.AP29 UG9.AP30 UG9.AP31 UG9.AP32 UG9.AP33 UG9.AP34 UG9.AP35 UG9.AP36 UG9.AP37 UG9.AP38 UG9.AP39 UG9.AR13 UG9.AR40 UG9.AT14 UG9.AT15 UG9.AT16 UG9.AT17 UG9.AT18 UG9.AT19 UG9.AT20 UG9.AT21 UG9.AT22 UG9.AT23 UG9.AT24 UG9.AT25 UG9.AT26 UG9.AT27 UG9.AT28 UG9.AT29 UG9.AT30 UG9.AT31 UG9.AT32 UG9.AT33 UG9.AT34 UG9.AT35 UG9.AT36 UG9.AT37 UG9.AT38 UG9.AT39 UG9.AT42 UG9.AU43 UG9.AV14 UG9.AV15 UG9.AV16 UG9.AV17 UG9.AV18 UG9.AV19 UG9.AV20 UG9.AV21 UG9.AV22 UG9.AV23 UG9.AV24 UG9.AV25 UG9.AV26 UG9.AV27 UG9.AV28 UG9.AV29 UG9.AV30 UG9.AV31 UG9.AV32 UG9.AV33 UG9.AV34 UG9.AV35 UG9.AV36 UG9.AV37 UG9.AV38 UG9.AV39 UG9.AV42 UG9.AV43 UG9.AV44 UG9.AW13 UG9.AW40 UG9.AW42 UG9.AW43 UG9.AW44 UG9.AW45 UG9.AY14 UG9.AY18 UG9.AY22 UG9.AY26 UG9.AY27 UG9.AY31 UG9.AY35 UG9.AY39 UG9.AY43 UG9.AY45 UG9.BA43 UG9.BA44 UG9.BA45 UG9.BA46 UG9.BA47 UG9.BB38 UG9.BB39 UG9.BB45 UG9.BB46 UG9.BB47 UG9.BB48 UG9.BC38 UG9.BC39 UG9.BC40 UG9.BC41 UG9.BC45 UG9.BC47 UG9.BC49 UG9.BD39 UG9.BD41 UG9.BD46 UG9.BD47 UG9.BD48 UG9.BD49 UG9.BD50 UG9.BD51 UG9.BE41 UG9.BE42 UG9.BE43 UG9.BE46 UG9.BE47 UG9.BE48 UG9.BE49 UG9.BE50 UG9.BE51 UG9.BE52 UG9.BF42 UG9.BF44 UG9.BF45 UG9.BF47 UG9.BF49 UG9.BF51 UG9.BG43 UG9.BG44 UG9.BG45 UG9.BG46 UG9.BG47 UG9.BG48 UG9.BG49 UG9.BG50 UG9.BG51 UG9.BG52 UG9.BH44 UG9.BH45 UG9.BH47 UG9.BH48 UG9.BH49 UG9.BH50 UG9.BH51 UG9.BH52 UG9.BJ44 UG9.BJ45 UG9.BJ46 UG9.BJ47 UG9.BJ48 UG9.BJ49 UG9.BJ50 UG9.BJ51 UG9.BJ52 UG9.BK47 UG9.BK48 UG9.BK49 UG9.BK50 UG9.BK51 UG9.BK52 UG9.BL46 UG9.BL47 UG9.BL48 UG9.BL49 UG9.BL50 UG9.BL51 UG9.BL52 UG9.BM47 UG9.BM48 UG9.BM49 UG9.BM50 UG9.BM51 UG9.N14 UG9.N18 UG9.N22 UG9.N26 UG9.N27 UG9.N31 UG9.N35 UG9.N39 UG9.P13 UG9.P40 UG9.R14 UG9.R15 UG9.R16 UG9.R17 UG9.R18 UG9.R19 UG9.R20 UG9.R21 UG9.R22 UG9.R23 UG9.R24 UG9.R25 UG9.R26 UG9.R27 UG9.R28 UG9.R29 UG9.R30 UG9.R31 UG9.R32 UG9.R33 UG9.R34 UG9.R35 UG9.R36 UG9.R37 UG9.R38 UG9.R39 UG9.U14 UG9.U15 UG9.U16 UG9.U17 UG9.U18 UG9.U19 UG9.U20 UG9.U21 UG9.U22 UG9.U23 UG9.U24 UG9.U25 UG9.U26 UG9.U27 UG9.U28 UG9.U29 UG9.U30 UG9.U31 UG9.U32 UG9.U33 UG9.U34 UG9.U35 UG9.U36 UG9.U37 UG9.U38 UG9.U39 UG9.V13 UG9.V40 UG9.W14 UG9.W15 UG9.W16 UG9.W17 UG9.W18 UG9.W19 UG9.W20 UG9.W21 UG9.W22 UG9.W23 UG9.W24 UG9.W25 UG9.W26 UG9.W27 UG9.W28 UG9.W29 UG9.W30 UG9.W31 UG9.W32 UG9.W33 UG9.W34 UG9.W35 UG9.W36 UG9.W37 UG9.W38 UG9.W39
+PEX_PLL_HVDD: CG34.1 LG9.1 UG9.BB30
+PEX_VDD: CG40.1 CG42.1 CG43.1 CG48.1 CG51.1 CG53.1 CG308.1 CG309.1 CG310.1 CG311.1 CG504.1 CG509.1 CG510.1 CG511.2 CG521.1 CG523.1 CG524.1 CG525.1 PJP10V1.2 RG544.1 UG9.BB15 UG9.BB17 UG9.BB18 UG9.BB20 UG9.BB21 UG9.BB23 UG9.BB33 UG9.BB35 UG9.BB36 UG9.BC15 UG9.BC17 UG9.BC18 UG9.BC20 UG9.BC21 UG9.BC23 UG9.BC33 UG9.BC35 UG9.BC36 UG9.BD33 UG9.BD36
+RTC_CELL_VBAT: CE73.1 RE16.2 UE1.122
+RTCBATT: JRTC.1 RC11.2
+RTCVCC: CC27.1 CH80.1 CH173.1 DC2.1 RA18.2 RE16.1 RE31.1 RE52.2 RH83.1 RH84.1 RH143.2 UH2.BA22
+TBTA_VBUS: CT94.2 CT95.2 CT96.1 CT97.1 CT106.1 DT1.1 DT15.2 DT15.3 JUSBC1.A4 JUSBC1.A9 JUSBC1.B4 JUSBC1.B9 UT4.A10 UT4.B10 UT4.H11 UT4.J10 UT4.J11 UT4.K11
+V_DAC: CL41.1 CL49.1 CL52.1 CL53.1 CL54.1 CL55.1 CL56.1 CL57.1 TL2.1 TL2.4 TL2.7 TL2.10
+V_DDR_REFA: CD96.1 JDIMM1.164 RH45.2 RH206.2 RH209.1
+V_DDR_REFA_R: CH101.1 RH45.1 UH1.BN13
+V_DDR_REFB: CD29.1 JDIMM2.164 RH46.2 RH207.2 RH210.1
+V_DDR_REFB_R: CH100.1 RH46.1 UH1.BR13
+VDISPLAY_VCC: CV597.1 CV598.1 JHDMI1.18 RM3.1 RM4.1 UV17.3
A_DE0: RI19.1 RI54.2 UI3.3
A_DE1: RI20.1 RI57.2 UI3.6
A_EQ0: RI15.1 RI55.2 UI3.2
A_OS0: RI16.1 RI46.2 UI3.4
AC_DIS: PQ708.2 PR734.1 UE1.69
AC_PRESENT: DV1.2 RH125.1 UH2.BB15
ACAV_IN: CE84.2 DV1.1 PR20.1 PR718.2 PR719.1 PU700.5 RE138.1
ACDET_CHG: PC724.1 PQ708.1 PR720.2 PR725.1 PU700.6
ACDRV_CHG: PR709.2 PU700.4
ADPIN: PC1.1 PC2.1 PC17.1 PC18.1 PJPDC1.6 PJPDC1.7 PJPDC1.8 PJPDC1.9 PL1.1 PL2.1 PL6.1 PL7.1 PL8.1 PL9.1
ALERT#: RG504.1 UG9.BJ3
ALL_SYS_PWRGD: PQ305.2 RE62.2 RH105.2 UH14.2
ALWON: PR18V00.1 PR313.1 UE1.121
AUD_AGND: CA1.2 CA2.2 CA16.1 CA17.2 CA18.2 CA19.1 CA22.1 CA23.2 CA24.2 CA40.2 CA41.2 CA42.2 CA43.2 CA60.2 CA61.2 CA63.1 HDA1.25 HDA1.38 JHP1.5 JHP1.7 RA9.1 RA11.1 RA12.1 RA13.1 RA14.1 RA15.1 RA16.1
AUD_AZA_CPU_SCLK: RH147.1 UH1.G27
AUD_AZA_CPU_SCLK_R: RH147.2 UH2.AM2
AUD_AZA_CPU_SDI: RH145.1 UH1.G29
AUD_AZA_CPU_SDI_R: RH145.2 UH2.AN2
AUD_AZA_CPU_SDO: RH146.1 UH1.G25
AUD_AZA_CPU_SDO_R: RH146.2 UH2.AM1
AUD_HP1_JACK_L: HDA1.32 RA44.1
AUD_HP1_JACK_L1: LA20.1 RA44.2 RA46.2 RA48.2
AUD_HP1_JACK_R: HDA1.33 RA49.1
AUD_HP1_JACK_R1: LA21.1 RA49.2 RA51.2 RA53.2
AUD_PC_BEEP: CA29.2 RA19.2
AUD_PC_BEEP_C: D1.1 RA30.1
AUD_PORTA_L_R_B: CA41.1 CA61.1 DA6.2 JHP1.1 LA20.2
AUD_PORTA_R_R_B: CA40.1 CA60.1 DA5.2 JHP1.2 LA21.2
AUD_SENSE: RA22.2 RA56.2
AUD_SENSE_A: CA24.1 HDA1.13 RA22.1 RA24.2
AUD_SPK_L+: HDA1.42 LA25.1
AUD_SPK_L+_C: CA37.1 DA2.3 JSPK1.3 LA25.2
AUD_SPK_L-: HDA1.43 LA26.1
AUD_SPK_L-_C: CA36.1 DA2.2 JSPK1.4 LA26.2
AUD_SPK_R+: HDA1.45 LA23.1
AUD_SPK_R+_C: CA39.1 DA3.3 JSPK1.1 LA23.2
AUD_SPK_R-: HDA1.44 LA24.1
AUD_SPK_R-_C: CA38.1 DA3.2 JSPK1.2 LA24.2
AUX_ON: RE131.1 UE1.3
B2B_G: PC700.2 PC701.2 PC702.2 PQ700.1 PQ703.4 PR702.2 PR704.2 PR709.1
B+: CV578.1 F2.1 PC100.1 PC105.1 PC204.1 PC205.1 PC305.1 PC306.1 PC708.1 PC709.1 PC4003.1 PC4004.1 PC5110.1 PC5111.1 PJP11.1 PJP18V1.1 PJP200.1 PJP4000.1 PL300.1 PL301.1 PL700.1 PL5100.1 PQ704.5 PR703.4 PR6100.1 QV11.4 R1.1 R2.2 RV535.1
B+_VCCIO: PC4000.1 PC4001.1 PC4002.1 PJP4000.2 PU4000.2 PU4000.3 PU4000.4 PU4000.5
B_DE0: RI21.1 RI56.2 UI3.16
B_DE1: RI22.1 RI58.2 UI3.18
B_EQ0: RI17.1 RI47.2 UI3.17
B_OS0: RI18.1 RI48.2 UI3.15
BAT1_LED#: QE20.5 RE39.1 UE1.106
BAT2_LED#: QE23.2 RE113.1 UE1.1
BATDRV_CHG: PR707.2 PU700.18
BATLOW#: RT31.2 UT1.F2
BATPRES#_CHG: PR723.2 PU700.15
BATSRC_CHG: PR708.2 PU700.17
BATT+: PC5.1 PC6.1 PC716.1 PC717.1 PC718.1 PL4.1 PL5.1 PR716.4
BATT++: PBATT1.1 PBATT1.2 PBATT1.3 PC7.1 PC8.1 PD700.3 PL4.2 PL5.2
BATT_PRS: PBATT1.6 PR12.1
BBS_BIT0: RH130.2 UH2.AT29
BEEP: D1.2 UE1.45
BIA_PWM_PCH: DV2.2 RH20.2 UH2.W36
BKLT_IN_EC: RE114.2 RE134.1 UE1.67
BOARD_ID: CE98.1 RE13.2 RE14.2 UE1.111
BOOT_1.2V: PR200.2 PU200.18
BOOT_GPU1: PR6107.2 PU6100.5
BOOT_GPU2: PR6114.2 PU6101.5
BOOT_GPU3: PR6121.2 PU6102.5
BREATH_LED#: QE24.2 RE119.1 UE1.70
BREATH_LED_MB: D5225.3 JPW.5 LED3.1 QE24.3
BREATH_LED_R2: LED3.2 RW3.1
BS_1.8V: PR18V01.1 PU18V00.1
BS_VCCIO: PR4000.1 PU4000.1
BST_1.2V: PC206.1 PR200.1
BST_1.8V: PC18V01.1 PR18V01.2
BST_1V: PC106.1 PR101.2
BST_3V: PC309.2 PR307.1
BST_5V: PC310.1 PR308.2
BST_+1.35V: PC808.1 PR801.2
BST_CHG: PC713.2 PR712.1
BST_GPU_PH1: PC6102.1 PR6107.1
BST_GPU_PH2: PC6115.1 PR6114.1
BST_GPU_PH3: PC6129.1 PR6121.1
BST_VCCIO: PC4005.1 PR4000.2
BT_RADIO_DIS#: DN2.1 UH2.AV43
BT_RADIO_DIS#_R: DN2.2 JNGFF1.46
BTST_CHG: PR712.2 PU700.25
BUSPOWER#: RT74.2 UT4.F10
CAM_CBL_DET#: RH79.1 UH2.U43
CAP_LED: JKB1.4 RE2.2
CAP_LED#: QE3.3 RE120.1 UE1.93
CAP_LED_R: QE4.1 RE2.1
CBN: CA20.2 HDA1.35
CBP: CA20.1 HDA1.37
CFG0: JXDP1.9 RH183.1 RH528.2 UH1.BN25
CFG1: JXDP1.11 UH1.BN27
CFG2: JXDP1.15 RH184.1 UH1.BN26
CFG3: JXDP1.17 RH517.2 UH1.BN28
CFG4: JXDP1.27 RH185.1 UH1.BR20
CFG5: JXDP1.29 RH186.1 UH1.BM20
CFG6: JXDP1.33 RH187.1 UH1.BT20
CFG7: JXDP1.35 RH188.1 UH1.BP20
CFG8: JXDP1.10 UH1.BR23
CFG9: JXDP1.12 UH1.BR22
CFG10: JXDP1.16 UH1.BT23
CFG11: JXDP1.18 UH1.BT22
CFG12: JXDP1.28 UH1.BM19
CFG13: JXDP1.30 UH1.BR19
CFG14: JXDP1.34 UH1.BP19
CFG15: JXDP1.36 UH1.BT19
CFG16: JXDP1.6 UH1.BP23
CFG17: JXDP1.4 UH1.BN23
CFG18: JXDP1.24 UH1.BN22
CFG19: JXDP1.22 UH1.BP22
CFG_RCOMP: RH59.1 UH1.BT25
CHG_B+: PC704.1 PC705.1 PC706.1 PC707.1 PL700.2 PQ705.5
CLK_PCIE_LAN: UH2.F2 UL1.15
CLK_PCIE_LAN#: UH2.D3 UL1.16
CLK_PCIE_N5: UH2.D8 UT1.T19
CLK_PCIE_P5: UH2.D7 UT1.V19
CLK_PCIE_SSD: JNGFF2.55 UH2.R7
CLK_PCIE_SSD#: JNGFF2.53 UH2.R8
CLK_PCIE_WLAN: JNGFF1.39 UH2.G4
CLK_PCIE_WLAN#: JNGFF1.41 UH2.E5
CLK_PEG_GPU: UG9.BM26 UH2.U7
CLK_PEG_GPU#: UG9.BM27 UH2.U5
CLK_SMB: PBATT1.4 PR8.1
CLK_TP_SIO: CE10.1 DE4.4 JTP.1 RE24.2 UE1.78
CMP_VIN0: RE33.1 RE73.2 UE1.20
CMP_VOUT0: PR315.1 QG23.3 RE33.2 RE38.2 RG580.1 UE1.85
CMPIN: PR26.1 PR27.2 PR732.1
CMPOUT: PR28.2 PR29.1 PR30.1 PR733.1
CMSRC_CHG: PR710.2 PU700.3
COMP: PC6008.2 PR6017.1 PU6000.30
COMP_GPU_1: PC6006.2 PR6017.2
CPU_24MHZ_N: UH1.D31 UH2.F1
CPU_24MHZ_P: UH1.E31 UH2.G1
CPU_B+: PC5103.1 PC5105.1 PC5106.1 PC5107.1 PC5108.1 PC5109.1 PC5116.1 PC5117.1 PC5118.1 PC5119.1 PC5120.1 PC5121.1 PC5122.1 PC5127.1 PC5128.1 PC5129.1 PC5130.1 PC5131.1 PC5132.1 PC5133.1 PC5203.1 PC5204.1 PC5205.1 PC5206.1 PC5207.1 PC5208.1 PC5210.1 PC5214.1 PC5215.1 PC5216.1 PC5217.1 PC5218.1 PC5219.1 PC5220.1 PC5223.1 PC5224.1 PC5225.1 PC5226.1 PC5228.1 PC5229.1 PL5100.2 PR5005.2 PU5101.8 PU5101.9 PU5102.8 PU5102.9 PU5103.8 PU5103.9 PU5201.8 PU5201.9 PU5202.8 PU5202.9 PU5203.6
CPU_DDI1_N0: CT7.1 UH1.K37
CPU_DDI1_N1: CT9.1 UH1.J34
CPU_DDI1_N2: CT23.1 UH1.H36
CPU_DDI1_N3: CT24.1 UH1.J38
CPU_DDI1_P0: CT6.1 UH1.K36
CPU_DDI1_P1: CT8.1 UH1.J35
CPU_DDI1_P2: CT10.1 UH1.H37
CPU_DDI1_P3: CT11.1 UH1.J37
CPU_DDI1HPD: RT38.1 UH2.AW4 UT1.AA2
CPU_DDI2_N0: CT28.1 UH1.H33
CPU_DDI2_N1: CT30.1 UH1.G38
CPU_DDI2_N2: CT32.1 UH1.F35
CPU_DDI2_N3: CT34.1 UH1.E36
CPU_DDI2_P0: CT27.1 UH1.H34
CPU_DDI2_P1: CT29.1 UH1.F37
CPU_DDI2_P2: CT31.1 UH1.F34
CPU_DDI2_P3: CT33.1 UH1.E37
CPU_DDI2HPD: RT39.1 UH2.AY2 UT1.Y6
CPU_DDI3_N0: CVGA11.1 UH1.D34
CPU_DDI3_N1: CVGA13.1 UH1.B34
CPU_DDI3_P0: CVGA10.1 UH1.C34
CPU_DDI3_P1: CVGA12.1 UH1.B36
CPU_DDI3HPD: RVGA9.1 UH2.AV4
CPU_DP1_AUXN_C: CT26.2 UT1.W11
CPU_DP1_AUXP_C: CT25.2 UT1.Y11
CPU_DP1_N0_C: CT7.2 UT1.AC7
CPU_DP1_N1_C: CT9.2 UT1.AC9
CPU_DP1_N2_C: CT23.2 UT1.AC11
CPU_DP1_N3_C: CT24.2 UT1.AC13
CPU_DP1_P0_C: CT6.2 UT1.AB7
CPU_DP1_P1_C: CT8.2 UT1.AB9
CPU_DP1_P2_C: CT10.2 UT1.AB11
CPU_DP1_P3_C: CT11.2 UT1.AB13
CPU_DP2_AUXN_C: CT36.2 UT1.W12
CPU_DP2_AUXP_C: CT35.2 UT1.Y12
CPU_DP2_N0_C: CT28.2 UT1.AC15
CPU_DP2_N1_C: CT30.2 UT1.AC17
CPU_DP2_N2_C: CT32.2 UT1.AC19
CPU_DP2_N3_C: CT34.2 UT1.AC21
CPU_DP2_P0_C: CT27.2 UT1.AB15
CPU_DP2_P1_C: CT29.2 UT1.AB17
CPU_DP2_P2_C: CT31.2 UT1.AB19
CPU_DP2_P3_C: CT33.2 UT1.AB21
CPU_TRIGGER: RH192.1 UH2.AK1
CPU_TRIGGER_R: RH192.2 UH1.J23
CPU_XDP_TCK: JXDP1.57 RH38.2 RH61.2 UH1.BR28
CPU_XDP_TDI: RH56.2 RH534.2 UH1.BL32
CPU_XDP_TDO: RH497.2 RH533.2 UH1.BT28
CPU_XDP_TMS: RH496.2 RH535.2 UH1.BP28
CPU_XDP_TRST#: RH60.2 RH536.2 UH1.BP30 UH2.AY5
CPVEE: CA15.2 HDA1.34
CRT_B: CVGA21.1 JCRT1.3 LVGA3.2
CRT_DDCCLK_CON: JCRT1.15 RVGA7.1 UVGA1.15
CRT_DDCDATA_CON: JCRT1.12 RVGA8.1 UVGA1.16
CRT_G: CVGA20.1 JCRT1.2 LVGA2.2
CRT_HSYNC_CON: CVGA23.1 JCRT1.13 RVGA14.1
CRT_PCH_HPD: RVGA9.2 RVGA10.2 UVGA1.32
CRT_R: CVGA19.1 JCRT1.1 LVGA1.2
CRT_VSYNC_CON: CVGA24.1 JCRT1.14 RVGA15.1
CS1: PR305.2 PU300.1
CS2: PR304.2 PU300.5
CS_1.2V: PR201.2 PU200.13
CSNSUM: PR6020.2 PU6000.21
CSON_1: PC721.2 PC722.1 PR716.3 PR726.2
CSOP_1: PC720.2 PC721.1 PR716.2 PR724.2
CSPSUM: PC6007.1 PR6002.2 PR6003.2 PR6004.2 PR6007.1 PR6011.1 PU6000.22
CSSN_1: PR703.3 PR706.2
CSSN_2: PC711.2 PC712.1 PR706.1 PU700.1
CSSN_B+: PR6100.3 RG59.1
CSSN_NVVDD: PR6101.3 RG64.1
CSSP_1: PR703.2 PR705.2
CSSP_2: PC710.2 PC711.1 PR705.1 PU700.2
CSSP_B+: PR6100.2 RG62.1
CSSP_NVVDD: PR6101.2 RG66.1
DAT_SMB: PBATT1.5 PR10.1
DAT_TP_SIO: CE9.1 DE4.6 JTP.2 RE55.2 UE1.79
DDC_SCL_HDMI: JHDMI1.15 RG578.2 RM3.2 UP2.7
DDC_SDA_HDMI: JHDMI1.16 RG577.2 RM4.2 UP2.8
DDI1_AUXN: CT26.1 RT76.1 UH1.E27
DDI1_AUXP: CT25.1 RT78.1 UH1.D27
DDI1_DDPB_CTRLDAT: RH580.1 UH2.BC4
DDI2_AUXN: CT36.1 RT77.1 UH1.E26
DDI2_AUXP: CT35.1 RT79.1 UH1.F26
DDI2_DDPC_CTRLDAT: RH579.1 UH2.BD6
DDI3_AUXN: CVGA9.1 UH1.B27
DDI3_AUXN_C: CVGA9.2 RVGA3.1 UVGA1.3
