# Allegro board Dell_Inspiron_15_7577_Compal_CKA50_CKF50_LA_E992P_Rev_1_0_BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PEG_GTX_C_HRX_N10: length 27.2
  TOP w0.102: v2(177.37,91.56) 177.75,91.94 178.9,91.94 179.21,91.63 181.25,91.63 181.28,91.66 181.38,91.66
  TOP w0.14: CG492.1 195.52,103.91 194.12,102.52 193.25,102.52 189.02,98.28 189.02,95.61 185.06,91.66 184.01,91.66 184,91.67 183.4,91.67 183.4,91.66 181.38,91.66
  BOTTOM w0.114: UH1.F20 177.05,91.89 v2(177.37,91.56)
PEG_GTX_C_HRX_N11: length 28
  TOP w0.102: 181.38,92.18 181.33,92.24 181.33,92.28 181.11,92.5 179.88,92.5 179.66,92.73 178.79,92.73 178.6,92.54 178.6,92.42 v2(178.67,92.35)
  TOP w0.14: 181.38,92.18 181.4,92.17 181.62,92.17 181.63,92.16 182.23,92.16 182.23,92.17 183.36,92.17 183.37,92.16 184.1,92.16 184.1,92.17 184.94,92.17 188.57,95.8 188.57,98.46 193.07,102.96 193.9,102.96 195.48,104.54 197.91,104.54 198.22,104.23 CG494.1
  BOTTOM w0.076: UH1.D21 178.45,92.85 178.6,92.85 178.72,92.72 178.72,92.39 v2(178.67,92.35)
PEG_GTX_C_HRX_N12: length 29.8
  TOP w0.089: CG496.1 199.22,105.81 199.07,105.66 198.97,105.62 198.6,105.62 198.55,105.57
  TOP w0.102: v2(177.37,93.14) 177.75,93.52 178.18,93.52 178.36,93.34 180.58,93.34 180.81,93.11 181.19,93.11 181.29,93.21 181.34,93.21 181.37,93.24 181.38,93.24
  TOP w0.14: 181.38,93.24 183.39,93.24 183.39,93.25 183.97,93.25 183.97,93.24 184.67,93.24 187.62,96.19 187.62,98.87 192.66,103.91 193.5,103.91 195.09,105.5 198.18,105.5 198.25,105.57 198.55,105.57
  BOTTOM w0.076: v2(177.37,93.14) 177.05,93.46 UH1.F22
PEG_GTX_C_HRX_N13: length 27.4
  TOP w0.102: v2(178.67,93.92) 178.67,93.85 178.77,93.75 180.18,93.75 180.6,94.17 180.98,94.17 180.99,94.16 181.01,94.16 181.02,94.17 181.09,94.17
  TOP w0.14: 181.09,94.17 181.2,94.17 181.4,93.97 184.4,93.97 186.92,96.48 186.92,99.16 192.37,104.61 193.21,104.61 194.8,106.2 196.33,106.2 196.34,106.21 197.06,106.21 197.07,106.2 197.61,106.2 197.61,106.21 197.72,106.32 197.8,106.32 CG498.1
  BOTTOM w0.076: UH1.D23 178.35,94.38 178.42,94.46 178.53,94.46 178.63,94.36 178.63,94.29 178.78,94.14 178.78,94.03 v2(178.67,93.92)
PEG_GTX_C_HRX_N14: length 30.2
  TOP w0.089: 198.55,107.28 198.57,107.28 198.61,107.24 199.42,107.24 CG500.1
  TOP w0.102: 181.38,94.72 181.3,94.72 181.26,94.67 180.13,94.67 179.73,94.27 179.16,94.27 178.6,94.83 178.47,94.83 178.21,95.09 177.75,95.09 v2(177.37,94.71)
  TOP w0.14: 181.38,94.72 181.39,94.71 v3(181.84,94.71) 184.16,94.71 186.22,96.77 186.22,99.45 192.08,105.31 192.92,105.31 194.89,107.28 198.55,107.28
  BOTTOM w0.076: UH1.F24 177.37,94.78 v2(177.37,94.71)
PEG_GTX_C_HRX_N15: length 28.1
  TOP w0.102: 181.38,95.61 181.32,95.61 181.13,95.8 179.53,95.8 179.39,95.66 179.11,95.66 178.83,95.94 178.51,95.94 178.41,95.84 178.41,95.6 178.52,95.5 v2(178.67,95.5)
  TOP w0.14: CG502.1 198.15,108.2 194.83,108.2 192.63,106.01 191.79,106.01 185.52,99.74 185.52,97.06 184.07,95.61 v3(183.67,95.61) 181.38,95.61
  BOTTOM w0.076: v2(178.67,95.5) 178.67,95.5 178.35,95.82 UH1.D25
PEG_GTX_C_HRX_P0: length 24
  TOP w0.102: v2(177.37,83.69) 177.43,83.69 177.84,83.28 179.74,83.28 179.77,83.26
  TOP w0.14: CG519.1 196.19,92.54 186.9,83.26 181.03,83.26 181.02,83.25 180.41,83.25 180.4,83.26 179.77,83.26
  BOTTOM w0.076: UH1.F10 177.05,84.01 v2(177.37,83.69)
PEG_GTX_C_HRX_P1: length 25.1
  TOP w0.102: v2(178.03,84.48) 178.23,84.28 180.24,84.28 180.59,84.63 181.11,84.63 181.3,84.43 181.33,84.43 181.38,84.38
  TOP w0.14: CG506.1 196.64,94.1 195.96,94.1 v3(195.95,94.11) 195.94,94.1 195.71,94.1 195.37,93.75 195.37,93.07 186.58,84.28 183.57,84.28 183.56,84.29 183.02,84.29 183.01,84.28 181.47,84.28 181.47,84.29 181.38,84.38
  BOTTOM w0.076: v2(178.03,84.48) 178.09,84.42 178.65,84.42 178.73,84.5 178.73,84.73 178.59,84.87 UH1.D11
PEG_GTX_C_HRX_P2: length 24.8
  TOP w0.102: 181.38,84.82 181.35,84.86 181.16,84.86 181.12,84.9 180.99,85.03 179.91,85.03 179.54,84.66 178.39,84.66 178.18,84.86 177.77,84.86 v2(177.37,85.26)
  TOP w0.14: CG518.1 194.86,94.86 194.86,93.19 186.49,84.82 182.25,84.82 182.24,84.82 181.67,84.82 181.66,84.82 181.38,84.82
  BOTTOM w0.076: v2(177.37,85.26) 177.05,85.59 UH1.F12
PEG_GTX_C_HRX_P3: length 26.6
  TOP w0.102: 181.38,85.9 181.35,85.93 181.2,85.93 181.08,86.05 180.61,86.05 180.58,86.02 179.89,86.02 179.46,86.45 178.53,86.45 178.39,86.3 178.39,86.16 178.5,86.05 v2(178.67,86.05)
  TOP w0.14: 181.38,85.9 181.65,85.9 181.81,85.73 182.02,85.52 186.2,85.52 194.16,93.48 194.16,95.91 195.11,96.86 196.91,96.86 197.23,96.54 CG26.1
  BOTTOM w0.076: UH1.D13 178.67,86.12 v2(178.67,86.05)
PEG_GTX_C_HRX_P4: length 26
  TOP w0.102: 181.38,86.63 181.2,86.63 181.16,86.6 180.07,86.6 179.65,87.02 177.75,87.02 177.63,87.13 177.49,87.13 177.37,87.02 v2(177.37,86.83)
  TOP w0.14: 181.38,86.63 183.19,86.63 183.19,86.62 183.71,86.62 183.71,86.63 186.32,86.63 193.46,93.77 193.46,96.32 194.9,97.75 196.16,97.75 CG28.1
  BOTTOM w0.076: v2(177.37,86.83) 177.05,87.16 UH1.F14
PEG_GTX_C_HRX_P5: length 27.8
  TOP w0.102: 181.38,87.34 181.37,87.34 181.33,87.38 181.24,87.38 181.01,87.61 179.92,87.61 179.52,88 178.78,88 178.59,87.8 178.59,87.7 v2(178.67,87.62)
  TOP w0.14: 181.38,87.34 181.48,87.34 181.49,87.33 182.06,87.33 182.07,87.34 186.04,87.34 192.76,94.06 192.76,96.63 194.66,98.53 195.75,98.53 195.96,98.74 197.28,98.74 197.38,98.84 198.05,98.84 198.11,98.77 198.19,98.77 CG30.1
  BOTTOM w0.076: UH1.D15 178.35,88.1 178.48,88.24 178.59,88.24 178.67,88.15 v2(178.67,87.62)
PEG_GTX_C_HRX_P6: length 26.9
  TOP w0.102: 181.38,88.1 181.36,88.1 181.33,88.13 180.07,88.13 179.66,88.53 178.72,88.53 178.21,88.03 177.75,88.03 v2(177.37,88.41)
  TOP w0.14: CG32.1 195.7,99.47 195.46,99.23 194.3,99.23 192.06,96.98 192.06,94.35 185.82,88.1 183.83,88.1 183.83,88.1 183.27,88.1 183.27,88.1 181.38,88.1
  BOTTOM w0.076: UH1.F16 177.37,88.48 v2(177.37,88.41)
PEG_GTX_C_HRX_P7: length 27.7
  TOP w0.102: v2(178.67,89.2) 178.6,89.27 178.6,89.4 178.78,89.58 179.48,89.58 179.85,89.21 181.05,89.21 181.24,89.02 181.27,89.02 181.29,89 181.34,89 181.37,88.97 181.38,88.97
  TOP w0.14: 181.38,88.97 185.69,88.97 191.36,94.64 191.36,97.31 194.22,100.16 195.09,100.16 195.55,100.62 195.76,100.62 195.77,100.62 196.31,100.62 196.32,100.62 198.12,100.62 CG35.1
  BOTTOM w0.114: UH1.D17 178.35,89.76 178.4,89.82 178.56,89.82 178.67,89.7 v2(178.67,89.2)
PEG_GTX_C_HRX_P8: length 26.9
  TOP w0.102: 181.38,89.72 181.23,89.72 181.2,89.74 179.89,89.74 179.63,90.01 178.51,90.01 178.41,89.91 178.41,89.82 178.17,89.58 178,89.58 177.9,89.68 177.9,89.87 v2(178.02,89.99)
  TOP w0.14: 181.38,89.72 v3(182.11,89.72) 185.46,89.72 190.67,94.93 190.67,97.6 193.94,100.87 194.81,100.87 195.57,101.63 196.78,101.63 CG488.1
  BOTTOM w0.102: UH1.E18 177.7,90.31 v2(178.02,89.99)
PEG_GTX_C_HRX_P9: length 28.6
  TOP w0.102: 181.38,90.86 181.33,90.91 181.3,90.91 181.13,91.09 180.37,91.09 180.34,91.11 179.87,91.11 179.85,91.09 179.18,91.09 178.91,91.36 178.36,91.36 178.19,91.18 177.78,91.18 v2(177.37,90.77)
  TOP w0.14: CG491.1 197.29,102.9 197.13,102.74 v3(196.13,102.74) 195.33,102.74 194.41,101.82 193.54,101.82 189.71,97.99 189.71,95.32 185.1,90.71 181.54,90.71 181.38,90.86
  BOTTOM w0.127: UH1.E19 v2(177.37,90.77)
PEG_GTX_C_HRX_P10: length 27.1
  TOP w0.102: 181.38,91.4 181.28,91.4 181.25,91.43 179.13,91.43 178.82,91.74 178.12,91.74 178.02,91.64 v2(178.02,91.56)
  TOP w0.14: 181.38,91.4 v3(183.68,91.4) 185.17,91.4 189.27,95.51 189.27,98.18 193.36,102.26 194.23,102.26 195.62,103.66 196.47,103.66 196.6,103.53 196.6,103.31 196.72,103.18 196.95,103.18 CG493.1
  BOTTOM w0.114: UH1.E20 177.72,91.97 177.95,91.97 178.05,91.87 178.05,91.83 178.08,91.8 178.08,91.62 v2(178.02,91.56)
PEG_GTX_C_HRX_P11: length 28
  TOP w0.102: 181.38,92.54 181.33,92.6 181.3,92.6 181.19,92.71 179.97,92.71 179.74,92.93 178.7,92.93 178.3,92.53 178.2,92.53 v2(178.02,92.35)
  TOP w0.14: CG495.1 195.37,104.8 193.79,103.22 192.96,103.22 188.32,98.57 188.32,95.9 184.84,92.42 v3(181.9,92.42) 181.5,92.42 181.38,92.54
  BOTTOM w0.076: v2(178.02,92.35) 177.7,92.67 UH1.E21
PEG_GTX_C_HRX_P12: length 29.8
  TOP w0.089: 198.55,105.32 198.58,105.32 198.71,105.44 198.95,105.44 199.03,105.44 199.22,105.25 CG497.1
  TOP w0.102: v2(178.02,93.14) 177.85,92.96 177.85,92.85 177.97,92.73 178.21,92.73 178.62,93.14 180.5,93.14 180.72,92.91 181.3,92.91 181.38,92.99
  TOP w0.14: 181.38,92.99 v3(183.68,92.99) 184.77,92.99 187.87,96.09 187.87,98.77 192.77,103.66 193.61,103.66 195.2,105.25 198.28,105.25 198.35,105.32 198.55,105.32
  BOTTOM w0.076: v2(178.02,93.14) 178.02,93.34 177.83,93.53 UH1.E22
PEG_GTX_C_HRX_P13: length 27.6
  TOP w0.102: 181.09,93.93 181.07,93.95 180.67,93.95 180.26,93.54 178.51,93.54 178.13,93.92 v2(178.02,93.92)
  TOP w0.14: 181.09,93.93 181.1,93.93 181.31,93.71 184.51,93.71 187.17,96.38 187.17,99.06 192.48,104.36 193.32,104.36 194.91,105.95 v3(196.71,105.95) CG499.1
  BOTTOM w0.076: UH1.E23 177.7,94.25 v2(178.02,93.92)
PEG_GTX_C_HRX_P14: length 30.1
  TOP w0.089: CG501.1 199.23,107.06 198.61,107.06 198.57,107.03 198.55,107.03
  TOP w0.102: v2(178.02,94.71) 177.97,94.71 177.81,94.55 177.81,94.41 177.91,94.3 178.15,94.3 178.43,94.58 178.57,94.58 179.08,94.07 179.85,94.07 v3(180.04,94.26) 180.24,94.47 181.34,94.47 181.35,94.45 181.38,94.45
  TOP w0.14: 198.55,107.03 195,107.03 193.03,105.06 192.19,105.06 186.48,99.35 186.48,96.67 184.26,94.45 183.89,94.45 182.14,94.45 182.14,94.45 181.6,94.45 181.59,94.45 181.38,94.45
  BOTTOM w0.076: UH1.E24 178.02,94.78 v2(178.02,94.71)
PEG_GTX_C_HRX_P15: length 28.2
  TOP w0.102: 181.38,95.35 181.29,95.35 181.05,95.59 179.61,95.59 179.48,95.46 179.17,95.46 178.83,95.12 178.51,95.12 178.13,95.5 v2(177.98,95.5)
  TOP w0.14: 181.38,95.35 183.42,95.35 183.43,95.35 183.91,95.35 183.92,95.35 184.18,95.35 185.78,96.96 185.78,99.64 191.9,105.76 192.74,105.76 194.93,107.95 198.15,107.95 CG503.1
  BOTTOM w0.114: UH1.E25 177.98,95.61 v2(177.98,95.5)
PEG_GTX_HRX_N0: length 8.5
  TOP w0.14: v2(202.64,96.76) 202.79,96.61 202.87,96.61 203.01,96.47 203.01,96.2 202.19,95.38 201.54,95.38 199.58,93.41 198.96,92.8 197.91,92.8 197.77,92.94 197.77,93 197.65,93.12 CG516.2
  BOTTOM w0.114: UG9.BH26 202.85,96.96 202.64,96.76 v2(202.64,96.76)
PEG_GTX_HRX_N1: length 10
  TOP w0.102: 200.13,94.55 200.24,94.66 200.45,94.66 201.55,95.76 201.98,95.76 202.3,96.08 202.3,96.56 202.25,96.61 202.25,96.89 202.55,97.19 203.97,97.19 204.12,97.04 204.48,97.04 204.59,96.94 v2(204.59,96.8)
  TOP w0.14: CG513.2 197.51,93.82 v3(198.26,93.82) 199.4,93.82 200.13,94.55
  BOTTOM w0.089: UG9.BE26 204.6,96.8 v2(204.59,96.8)
PEG_GTX_HRX_N2: length 9.3
  TOP w0.102: 199.73,96.06 199.76,96.06 199.76,96.06 200.1,96.06 200.53,96.5 200.53,96.55 200.93,96.94 200.98,96.94 201.33,97.3 201.83,97.3 202.29,97.76 203.44,97.76 203.58,97.9 203.58,98.04 203.47,98.15 v2(203.25,98.15)
  TOP w0.14: CG25.2 196.42,96.04 196.43,96.04 196.44,96.05 198.4,96.05 198.4,96.05 v3(199.37,96.05) 199.72,96.05 199.73,96.06
  BOTTOM w0.117: UG9.BG27 203.55,98.07 203.47,98.15 v2(203.25,98.15)
PEG_GTX_HRX_N3: length 7.2
  TOP w0.102: v2(202.6,98.88) 202.67,98.95 202.76,98.95 202.92,98.78 202.92,98.67 202.71,98.45 202.42,98.45 201.86,97.89 v3(201.49,97.89) 201.1,97.89 199.77,96.56 199.16,96.56 198.85,96.87 198.69,96.87 198.6,96.87 198.55,96.92
  TOP w0.14: CG27.2 198.08,96.92 198.55,96.92
  BOTTOM w0.089: v2(202.6,98.88) 202.85,99.13 UG9.BH29
PEG_GTX_HRX_N4: length 10.4
  TOP w0.102: 198.55,98.09 198.56,98.09 198.59,98.06 199.16,98.06 199.33,98.23 199.91,98.23 201.12,99.43 v3(201.73,99.43) 202.19,99.43 202.35,99.6 203.81,99.6 204.06,99.85 204.9,99.85 205.13,99.62 205.13,99.07 v2(205.25,98.95)
  TOP w0.14: CG29.2 196.98,98.09 198.55,98.09
  BOTTOM w0.089: UG9.BE29 v2(205.25,98.95)
PEG_GTX_HRX_N5: length 6.2
  TOP w0.102: CG31.2 199.17,98.95 199.35,98.95 v3(199.91,99.5) 200.46,100.05 202.69,100.05 202.79,100.16 202.79,100.38 203.07,100.65 203.3,100.65 203.41,100.55 203.41,100.41 v2(203.25,100.25)
  BOTTOM w0.102: v2(203.25,100.25) UG9.BG30
PEG_GTX_HRX_N6: length 7
  TOP w0.102: 198.55,99.88 198.56,99.88 198.6,99.84 198.96,99.84 199.07,99.84 200.31,101.08 201.5,101.08 201.51,101.09 201.97,101.09 202.07,100.99 202.14,100.99 202.2,101.06 202.2,101.27 202.3,101.37 202.45,101.37 202.6,101.22 v2(202.6,100.98)
  TOP w0.14: 198.55,99.88 197.73,99.88 CG33.2
  BOTTOM w0.089: v2(202.6,100.98) 202.5,101.07 202.5,101.26 202.66,101.42 202.78,101.42 UG9.BH32
PEG_GTX_HRX_N7: length 7.9
  TOP w0.102: CG36.2 198.99,100.9 199.34,100.9 199.43,100.99 199.43,101.05 199.73,101.35 199.78,101.35 200.19,101.76 202.62,101.76 202.79,101.58 203.75,101.58 203.99,101.82 204.76,101.82 205.07,101.51 205.07,101.23 v2(205.25,101.05)
  BOTTOM w0.102: UG9.BE32 v2(205.25,101.05)
PEG_GTX_HRX_N8: length 7.5
  TOP w0.089: 198.55,101.81 198.57,101.81
  TOP w0.102: 198.57,101.81 198.6,101.78 199.38,101.78 199.86,102.26 v3(201.37,102.26) 202.33,102.26 202.45,102.14 202.86,102.14 203.04,101.96 203.43,101.96 203.58,102.11 203.58,102.33 203.51,102.4 203.3,102.4 v2(203.25,102.35)
  TOP w0.14: CG489.2 197.76,101.81 198.55,101.81
  BOTTOM w0.089: UG9.BG33 v2(203.25,102.35)
PEG_GTX_HRX_N9: length 5.3
  TOP w0.102: v2(202.6,103.08) 202.6,103.15 202.47,103.28 202.21,103.28 201.99,103.06 200.04,103.06 v3(199.87,102.9) 199.68,102.71 199.47,102.71 199.37,102.61 199.37,102.21 199.26,102.11 199.12,102.11 CG490.2
  BOTTOM w0.089: UG9.BH35 202.85,103.12 202.77,103.04 202.64,103.04 v2(202.6,103.08)
PEG_GTX_HRX_N10: length 8.8
  TOP w0.102: v2(205.25,103.15) 205.25,103.62 205.02,103.85 201.7,103.85 201.59,103.74 v3(201.22,103.74) 200.73,103.74 200.61,103.85 199.17,103.85 199.17,103.85 199.08,103.85 198.99,103.85 198.87,103.72
  TOP w0.14: CG492.2 197.88,103.72 198.87,103.72
  BOTTOM w0.102: UG9.BE35 v2(205.25,103.15)
PEG_GTX_HRX_N11: length 6.1
  TOP w0.102: CG494.2 199.09,104.42 v3(199.91,104.42) 200.57,104.42 200.9,104.1 202.01,104.1 202.34,104.42 202.82,104.42 202.88,104.36 202.88,104.21 203.05,104.04 203.42,104.04 203.49,104.11 203.49,104.3 203.34,104.45 v2(203.25,104.45)
  BOTTOM w0.089: UG9.BG36 v2(203.25,104.45)
PEG_GTX_HRX_N12: length 4
  TOP w0.102: CG496.2 200.29,105.63 200.62,105.63 200.79,105.46 201.5,105.46 201.64,105.32 202.17,105.32 202.42,105.58 202.75,105.58 202.86,105.46 202.86,105.36 202.67,105.18 v2(202.6,105.18)
  BOTTOM w0.089: UG9.BH38 v2(202.6,105.18)
PEG_GTX_HRX_N13: length 7.8
  TOP w0.102: v2(205.25,105.25) 205.08,105.42 205.08,105.65 204.78,105.96 202.93,105.96 202.69,106.2 201.05,106.2 200.87,106.38 198.74,106.38 198.73,106.37 CG498.2
  BOTTOM w0.102: v2(205.25,105.25) UG9.BE38
PEG_GTX_HRX_N14: length 4.8
  TOP w0.102: v2(203.25,106.55) 203.37,106.55 203.49,106.67 203.49,106.89 203.42,106.96 203.05,106.96 202.74,106.66 201.56,106.66 v3(201.36,106.86) 201.13,107.09 200.36,107.09 CG500.2
  BOTTOM w0.089: UG9.BG39 v2(203.25,106.55)
PEG_GTX_HRX_N15: length 5.5
  TOP w0.14: v2(203.25,107.35) 203.12,107.48 203.12,108 202.83,108.3 v3(201.13,108.3) 199.32,108.3 199.3,108.32 198.93,108.32 CG502.2
  BOTTOM w0.102: UG9.BG41 v2(203.25,107.35)
PEG_GTX_HRX_P0: length 8.5
  TOP w0.14: v2(203.24,96.82) 203.24,96.1 202.29,95.15 201.64,95.15 v3(199.52,93.03) 199.03,92.54 CG519.2
  BOTTOM w0.089: 203.31,96.92 203.25,96.85 203.24,96.85 v2(203.24,96.82)
  BOTTOM w0.102: UG9.BG26 203.31,96.92
PEG_GTX_HRX_P1: length 9.9
  TOP w0.102: 199.9,94.65 200.11,94.85 200.37,94.85 201.47,95.95 201.91,95.95 202.11,96.16 202.11,96.48 202.06,96.53 202.06,96.97 202.47,97.38 204.05,97.38 204.19,97.23 204.46,97.23 204.59,97.36 v2(204.59,97.49)
  TOP w0.14: 199.9,94.65 199.33,94.07 198.59,94.07 198.58,94.08 197.92,94.08 197.92,94.07 197.57,94.07 CG506.2
  BOTTOM w0.089: v2(204.59,97.49) UG9.BF26
PEG_GTX_HRX_P2: length 9.3
  TOP w0.102: v2(203.95,98.15) 203.81,98.01 203.81,97.86 203.52,97.57 202.37,97.57 201.91,97.11 201.41,97.11 v3(200.9,96.59) 200.18,95.87 199.86,95.87 199.85,95.85
  TOP w0.14: 199.85,95.85 199.81,95.82 199.59,95.82 199.57,95.79 199.13,95.79 199.11,95.82 198.57,95.82 198.55,95.79 196.54,95.79 196.54,95.79 196.37,95.79 CG518.2
  BOTTOM w0.117: UG9.BF27 v2(203.95,98.15)
PEG_GTX_HRX_P3: length 7.2
  TOP w0.089: 198.55,96.63 198.57,96.65
  TOP w0.102: 198.57,96.65 198.59,96.68 198.78,96.68 199.08,96.37 199.85,96.37 201.18,97.7 201.49,97.7 201.53,97.67 201.9,97.67 202.5,98.26 202.78,98.26 203.11,98.59 203.11,98.81 v2(203.25,98.95)
  TOP w0.14: 198.55,96.63 198.54,96.63 197.97,96.63 CG26.2
  BOTTOM w0.089: UG9.BG29 v2(203.25,98.95)
PEG_GTX_HRX_P4: length 10.3
  TOP w0.089: 198.55,97.83 198.57,97.83
  TOP w0.102: 198.57,97.83 198.61,97.87 199.24,97.87 199.41,98.04 199.99,98.04 201.19,99.24 201.47,99.24 201.51,99.2 201.91,99.2 201.94,99.24 202.31,99.24 202.48,99.41 203.89,99.41 204.14,99.66 204.82,99.66 204.94,99.54 204.94,99.14 204.74,98.95 v2(204.55,98.95)
  TOP w0.14: 198.55,97.83 196.95,97.83 CG28.2
  BOTTOM w0.089: UG9.BF29 v2(204.55,98.95)
PEG_GTX_HRX_P5: length 6.1
  TOP w0.102: CG30.2 199.15,98.76 199.43,98.76 199.88,99.2 199.93,99.2 200.24,99.51 200.24,99.56 200.52,99.85 203.37,99.85 203.77,100.25 v2(203.95,100.25)
  BOTTOM w0.102: v2(203.95,100.25) UG9.BF30
PEG_GTX_HRX_P6: length 7.1
  TOP w0.102: 198.55,99.62 198.56,99.62 198.59,99.65 198.88,99.65 199.15,99.65 200.35,100.85 v3(201.12,100.85) 201.56,100.85 201.61,100.9 201.9,100.9 201.99,100.8 202.1,100.8 202.37,100.53 202.68,100.53 203.17,101.02 v2(203.22,101.02)
  TOP w0.14: 198.55,99.62 197.73,99.62 CG32.2
  BOTTOM w0.089: UG9.BG32 v2(203.22,101.02)
PEG_GTX_HRX_P7: length 7.9
  TOP w0.102: CG35.2 199.07,100.71 199.42,100.71 v3(199.7,101) 200.27,101.56 202.54,101.56 202.72,101.39 203.82,101.39 204.06,101.63 204.68,101.63 204.88,101.43 204.88,101.05 204.8,100.97 204.63,100.97 v2(204.55,101.05)
  BOTTOM w0.102: UG9.BF32 v2(204.55,101.05)
PEG_GTX_HRX_P8: length 7.6
  TOP w0.089: 198.55,101.56 198.57,101.56
  TOP w0.102: 198.57,101.56 198.6,101.59 199.46,101.59 199.94,102.07 201.14,102.07 201.18,102.03 201.64,102.03 201.68,102.07 202.25,102.07 202.37,101.95 202.78,101.95 202.96,101.77 203.51,101.77 203.77,102.03 203.77,102.17 v2(203.95,102.35)
  TOP w0.14: 198.55,101.56 197.68,101.56 CG488.2
  BOTTOM w0.102: UG9.BF33 v2(203.95,102.35)
PEG_GTX_HRX_P9: length 5.1
  TOP w0.102: CG491.2 199.54,102.9 199.9,103.25 201.92,103.25 202.13,103.47 202.73,103.47 202.97,103.23 202.97,103.22 203.04,103.15 v2(203.25,103.15)
  BOTTOM w0.089: UG9.BG35 v2(203.25,103.15)
PEG_GTX_HRX_P10: length 8.8
  TOP w0.102: 198.83,103.47 198.94,103.47 199.13,103.66 200.53,103.66 200.69,103.51 201.63,103.51 201.78,103.66 204.94,103.66 205.06,103.54 205.06,103.48 204.88,103.3 204.88,103.25 204.78,103.15 v2(204.55,103.15)
  TOP w0.14: 198.83,103.47 197.83,103.47 197.77,103.41 197.76,103.41 CG493.2
  BOTTOM w0.102: UG9.BF35 v2(204.55,103.15)
PEG_GTX_HRX_P11: length 6.1
  TOP w0.102: v2(203.95,104.45) 203.95,104.47 203.6,104.82 203.1,104.82 202.89,104.61 202.26,104.61 201.94,104.29 200.98,104.29 200.65,104.62 200.15,104.62 200.1,104.67 199.7,104.67 199.65,104.62 199.09,104.62 CG495.2
  BOTTOM w0.102: UG9.BF36 v2(203.95,104.45)
PEG_GTX_HRX_P12: length 4.1
  TOP w0.102: v2(203.25,105.25) 203.19,105.25 202.97,105.03 202.97,105.02 202.75,104.81 202.45,104.81 202.13,105.13 201.56,105.13 201.46,105.24 v3(201.13,105.24) 200.75,105.24 200.54,105.44 200.29,105.44 CG497.2
  BOTTOM w0.089: UG9.BG38 v2(203.25,105.25)
PEG_GTX_HRX_P13: length 7.7
  TOP w0.102: CG499.2 198.82,106.19 200.8,106.19 200.97,106.01 202.61,106.01 202.85,105.77 204.7,105.77 204.89,105.57 204.89,105.34 204.75,105.2 204.62,105.2 v2(204.6,105.22)
  BOTTOM w0.089: v2(204.6,105.22) 204.27,105.55 UG9.BF38
PEG_GTX_HRX_P14: length 4.8
  TOP w0.102: v2(203.95,106.55) 203.76,106.55 203.62,106.41 203.62,106.4 203.4,106.18 203.1,106.18 202.88,106.4 202.88,106.41 202.82,106.47 201.47,106.47 201.04,106.9 200.23,106.9 CG501.2
  BOTTOM w0.089: 204.22,106.28 204.06,106.44
  BOTTOM w0.102: UG9.BF39 204.22,106.28 ; 204.06,106.44 v2(203.95,106.55)
PEG_GTX_HRX_P15: length 5.5
  TOP w0.14: v2(202.6,107.28) 202.87,107.55 202.87,107.9 202.72,108.04 201.56,108.04 201.56,108.04 200.79,108.04 200.79,108.04 199.43,108.04 199.31,107.93 199.31,107.79 199.21,107.69 199,107.69 CG503.2
  BOTTOM w0.089: 202.69,107.49 202.6,107.4 v2(202.6,107.28)
  BOTTOM w0.102: UG9.BH41 202.69,107.49
PEG_HTX_C_GRX_N0: length 18.2
  BOTTOM w0.102: UG9.BK27 201.16,98.14 200.9,98.14 200.82,98.22 200.39,98.22 200.22,98.4 199.64,98.4 199.33,98.09 199.18,98.09
  BOTTOM w0.14: CH36.2 191.32,86.6 192.23,86.6 193.75,88.12 193.75,88.14 194.22,88.61 194.24,88.61 v3(195.39,89.76) 196.24,90.61 196.24,93.54 197.33,94.62 197.33,96.29 199.13,98.09 199.18,98.09
PEG_HTX_C_GRX_N1: length 19.5
  BOTTOM w0.102: UG9.BL29 200.75,99.33 200.63,99.44 200.47,99.44 200.37,99.34 200.37,99.18 200.41,99.14 200.41,98.99 200.25,98.83 199.22,98.83 199.18,98.87
  BOTTOM w0.14: 199.18,98.87 198.92,98.87 197.32,97.27 197.31,97.27 196.89,96.85 196.89,96.84 196.63,96.58 196.63,94.91 195.54,93.83 195.54,90.93 v3(192.51,87.89) 192.1,87.49 190.23,87.49 190.09,87.63 190.09,87.79 189.97,87.91 189.71,87.91 CH34.2
PEG_HTX_C_GRX_N2: length 16.5
  BOTTOM w0.14: UG9.BM30 199.8,99.7 199.28,99.7 199.23,99.65 198.68,99.65 195.44,96.41 195.44,95.03 194.83,94.42 v3(194.83,92.79) 194.83,91.27 193.81,90.24 193.8,90.24 193.3,89.75 193.3,89.73 192.18,88.61 191.21,88.61 CH32.2
PEG_HTX_C_GRX_N3: length 19.8
  BOTTOM w0.102: 199.12,100.1 199.26,100.1 199.31,100.15 199.75,100.15 199.87,100.27 200.18,100.27 200.39,100.05 200.39,99.86 200.62,99.63 201.13,99.63 UG9.BK30
  BOTTOM w0.14: 199.12,100.1 198.34,100.1 196.46,98.23 196.46,98.22 196.02,97.78 196.02,97.78 195,96.76 195,95.21 194.39,94.6 194.39,91.47 192.56,89.64 v3(191.97,89.64) 191.47,89.64 191.13,89.3 189.58,89.3 CH30.2
PEG_HTX_C_GRX_N4: length 17.9
  BOTTOM w0.102: UG9.BL32 200.83,101.43 200.83,101.59 200.72,101.69 200.55,101.69 200.38,101.52 200.38,101.1 200.3,101.02 199.22,101.02 199.18,101.06
  BOTTOM w0.14: 199.18,101.06 197.93,101.06 v3(196.97,100.1) 194.04,97.17 194.04,95.62 193.43,95.01 193.43,91.86 192.35,90.78 191.08,90.78 CH28.2
PEG_HTX_C_GRX_N5: length 19.2
  BOTTOM w0.089: 199.23,101.53 199.37,101.53 199.43,101.46 199.43,101.25 199.47,101.2 199.68,101.2 199.74,101.27 199.74,101.48 199.89,101.63 199.89,101.69 199.73,101.84 199.73,101.92 199.93,102.11 199.99,102.11 UG9.BM33
  BOTTOM w0.14: CH26.2 189.72,91.23 189.79,91.3 189.79,91.46 189.89,91.55 190.95,91.55 191.28,91.22 191.71,91.22 191.96,91.47 192.35,91.47 v3(192.75,91.87) 192.99,92.11 192.99,95.19 193.6,95.8 193.6,97.37 194.31,98.08 194.32,98.08 194.66,98.42 194.66,98.43 197.73,101.5 199.21,101.5 199.23,101.53
PEG_HTX_C_GRX_N6: length 17.4
  BOTTOM w0.089: 199.18,102.45 199.21,102.43 199.48,102.43 199.77,102.72 200.33,102.72 200.68,102.36 200.88,102.36 201.19,102.05 UG9.BK33
  BOTTOM w0.14: 199.18,102.45 197.31,102.45 192.63,97.78 v3(192.63,96.92) 192.63,96.18 192.04,95.59 192.04,94 192.03,94 192.03,93.51 192.04,93.51 192.04,93.12 191.72,92.8 190.96,92.8 CH24.2
PEG_HTX_C_GRX_N7: length 18
  BOTTOM w0.102: 199.18,102.9 199.21,102.92 200.27,102.92 200.41,103.07 201.03,103.07 201.14,103.17 201.14,103.41 201,103.55 200.85,103.55 UG9.BL35
  BOTTOM w0.14: 199.18,102.9 197.11,102.9 v3(195.81,101.59) 192.19,97.98 192.19,96.37 191.57,95.75 191.57,94.77 191.11,94.31 191.11,94.3 190.67,93.86 190.66,93.86 190.25,93.46 189.67,93.46 CH22.2
PEG_HTX_C_GRX_N8: length 15.9
  BOTTOM w0.102: UG9.BM36 200.05,104.03 199.86,103.84 199.2,103.84 199.18,103.85
  BOTTOM w0.14: CH20.2 189.74,95.1 190.34,95.1 190.62,95.37 190.62,96.14 191.24,96.76 191.24,98.39 v3(191.99,99.14) 193.27,100.42 193.27,100.43 193.72,100.88 193.73,100.88 196.7,103.85 199.18,103.85
PEG_HTX_C_GRX_N9: length 18
  BOTTOM w0.102: UG9.BK36 201.2,104.15 200.86,104.49 200.59,104.49 200.42,104.66 199.7,104.66 199.57,104.53 199.2,104.53 199.18,104.55
  BOTTOM w0.14: CH18.2 188.24,96.28 189.77,96.28 189.99,96.51 189.99,96.52 190.54,97.06 190.54,98.7 v3(195.36,103.52) 196.39,104.55 199.18,104.55
PEG_HTX_C_GRX_N10: length 17
  BOTTOM w0.089: UG9.BL38 200.76,105.54
  BOTTOM w0.102: 199.14,104.99 199.18,104.99 199.22,105.03 200.26,105.03 200.47,105.23 201.05,105.23 201.15,105.33 201.15,105.4 201.13,105.42 201.13,105.57 201.03,105.67 200.88,105.67 200.76,105.54
  BOTTOM w0.14: CH16.2 189.54,96.95 189.8,96.95 190.09,97.25 v3(190.09,98.47) 190.09,98.9 193.52,102.33 193.53,102.33 193.93,102.72 193.93,102.73 196.19,104.99 199.14,104.99
PEG_HTX_C_GRX_N11: length 16.1
  BOTTOM w0.102: UG9.BM39 199.74,105.94 199.63,105.94 199.58,105.9 199.25,105.9 199.22,105.92 199.18,105.92
  BOTTOM w0.14: 199.18,105.92 199.14,105.92 199.12,105.95 195.77,105.95 v3(195.46,105.63) 191.02,101.2 191.01,101.2 190.59,100.77 190.59,100.76 188.91,99.09 188.91,98.33 188.68,98.1 188.01,98.1 CH14.2
PEG_HTX_C_GRX_N12: length 16.8
  BOTTOM w0.102: 199.18,106.66 199.2,106.66 199.22,106.63 199.71,106.63 199.84,106.76 200.42,106.76 200.61,106.57 201.13,106.57 UG9.BK39
  BOTTOM w0.14: CH12.2 188.37,99.55 191.47,102.64 191.47,102.66 191.83,103.03 191.85,103.03 195.48,106.66 v3(197.51,106.66) 199.18,106.66
PEG_HTX_C_GRX_N13: length 18.1
  BOTTOM w0.102: UG9.BL41 200.83,107.73 200.83,107.88 200.73,107.98 200.57,107.98 200.43,107.84 200.43,107.47 200.29,107.33 199.21,107.33 199.18,107.36
  BOTTOM w0.14: CH10.2 186.77,100.36 188.17,100.36 188.57,100.75 188.57,100.77 189.08,101.28 189.1,101.28 v3(193.29,105.47) 195.17,107.36 199.18,107.36
PEG_HTX_C_GRX_N14: length 15.8
  BOTTOM w0.102: 199.19,108.07 199.23,108.03 199.42,108.03 199.49,108.11 199.8,108.11 UG9.BM42
  BOTTOM w0.14: 199.19,108.07 v3(195.72,108.07) 194.88,108.07 190.21,103.4 190.2,103.4 189.72,102.92 189.72,102.91 188.37,101.56 187.4,101.56 CH8.2
PEG_HTX_C_GRX_N15: length 18.4
  BOTTOM w0.102: UG9.BK42 201.2,108.35 200.88,108.67 200.64,108.67 200.44,108.86 199.84,108.86 199.71,108.73 199.23,108.73 199.2,108.77 199.18,108.77
  BOTTOM w0.14: CH6.2 187.78,102.58 187.79,102.59 188.4,102.59 v3(191.24,105.43) 194.58,108.77 199.18,108.77
PEG_HTX_C_GRX_P0: length 18.2
  BOTTOM w0.102: 199.18,97.78 199.26,97.86 199.28,97.86 199.32,97.9 199.41,97.9 199.72,98.21 200.14,98.21 200.38,97.97 200.38,97.69 200.58,97.49 200.72,97.49 200.83,97.59 200.83,97.77 UG9.BL27
  BOTTOM w0.14: 199.18,97.78 197.58,96.18 197.58,94.52 196.5,93.43 196.5,90.51 195.74,89.75 195.74,89.74 195.4,89.4 195.39,89.4 v3(194.15,88.16) 192.33,86.34 191.32,86.34 CH35.2
PEG_HTX_C_GRX_P1: length 19.5
  BOTTOM w0.102: 199.18,98.62 199.21,98.64 200.33,98.64 200.55,98.87 200.82,98.87 201.07,99.12 201.07,99.13 201.19,99.25 UG9.BK29
  BOTTOM w0.14: 199.18,98.62 199.03,98.62 v3(197.25,96.84) 196.88,96.47 196.88,94.81 195.8,93.72 195.8,90.82 192.92,87.94 192.92,87.93 192.52,87.54 192.51,87.54 192.21,87.23 189.67,87.23 CH33.2
PEG_HTX_C_GRX_P2: length 16.5
  BOTTOM w0.14: UG9.BM29 199.83,99.47 199.37,99.47 199.3,99.39 198.79,99.39 195.7,96.3 195.7,94.92 195.09,94.31 195.09,93.14 195.09,93.14 195.09,92.43 195.09,92.42 195.09,91.16 v3(193.74,89.82) 192.28,88.36 191.17,88.36 CH31.2
PEG_HTX_C_GRX_P3: length 19.8
  BOTTOM w0.102: 199.19,100.33 199.19,100.34 199.64,100.34 199.76,100.46 199.87,100.46 200.26,100.46 200.49,100.23 200.6,100.23 200.67,100.31 200.88,100.31 201.08,100.1 201.08,99.9 201,99.82 200.88,99.82 UG9.BL30
  BOTTOM w0.14: CH29.2 189.76,89.56 191.03,89.56 191.37,89.9 192.46,89.9 194.13,91.57 194.13,94.71 194.74,95.32 194.74,96.86 v3(196.06,98.18) 198.24,100.36 199.12,100.36 199.14,100.33 199.19,100.33
PEG_HTX_C_GRX_P4: length 17.9
  BOTTOM w0.102: 199.18,100.8 200.43,100.8 200.66,101.03 200.99,101.03 201.31,101.35 UG9.BK32
  BOTTOM w0.14: CH27.2 191.05,90.52 192.45,90.52 193.69,91.76 193.69,94.89 v3(194.02,95.22) 194.3,95.5 194.3,97.07 196.94,99.71 196.95,99.71 197.4,100.16 197.4,100.17 198.03,100.8 199.18,100.8
PEG_HTX_C_GRX_P5: length 19.3
  BOTTOM w0.089: UG9.BM32 200.14,101.44 200.14,101.68 200.36,101.9 200.36,102.18 200.18,102.36 199.92,102.36 199.34,101.78 199.2,101.78 199.2,101.76 199.21,101.76 199.18,101.76
  BOTTOM w0.14: 199.18,101.76 197.62,101.76 v3(194.3,98.44) 193.35,97.48 193.35,95.91 192.74,95.3 192.74,92.23 192.23,91.72 191.14,91.72 191.05,91.81 189.41,91.81 CH25.2
PEG_HTX_C_GRX_P6: length 17.4
  BOTTOM w0.089: UG9.BL33 200.74,102.05 200.25,102.54 199.85,102.54 199.56,102.25 199.25,102.25 199.23,102.23 199.18,102.23
  BOTTOM w0.14: CH23.2 190.9,92.25 191.2,92.55 191.44,92.55 191.56,92.43 191.56,92.31 191.69,92.17 191.99,92.17 192.13,92.31 192.13,92.85 192.29,93.02 v3(192.29,93.75) 192.29,95.48 192.89,96.08 192.89,96.61 192.89,96.62 192.89,97.24 192.89,97.25 192.89,97.67 197.42,102.2 199.12,102.2 199.14,102.23 199.18,102.23
PEG_HTX_C_GRX_P7: length 18
  BOTTOM w0.102: 199.17,103.15 199.19,103.13 199.2,103.13 199.21,103.13 200.2,103.13 200.43,103.36 200.43,103.58 200.62,103.77 201.13,103.77 UG9.BK35
  BOTTOM w0.14: 199.17,103.15 197.01,103.15 195.85,102 195.84,102 195.42,101.57 195.42,101.56 191.94,98.08 191.94,96.47 191.31,95.85 191.31,94.88 v3(190.7,94.26) 190.15,93.71 189.67,93.71 CH21.2
PEG_HTX_C_GRX_P8: length 15.8
  BOTTOM w0.102: 199.18,103.62 199.21,103.62 199.22,103.63 199.96,103.63 200.05,103.55 UG9.BM35
  BOTTOM w0.14: 199.18,103.62 199.14,103.62 199.12,103.6 196.8,103.6 v3(193.72,100.52) 192.37,99.16 192.37,99.15 191.95,98.74 191.94,98.74 191.49,98.29 191.49,96.66 190.87,96.04 190.87,95.27 190.45,94.85 189.6,94.85 CH19.2
PEG_HTX_C_GRX_P9: length 18
  BOTTOM w0.102: UG9.BL36 200.78,104.12 200.78,104.04 200.71,103.98 200.56,103.98 200.48,103.9 200.42,103.9 200.37,103.95 200.37,104.17 200.45,104.25 200.45,104.36 200.34,104.47 199.78,104.47 199.64,104.32 199.18,104.32
  BOTTOM w0.14: 199.18,104.32 199.14,104.32 199.12,104.3 196.5,104.3 195.8,103.6 195.8,103.59 195.29,103.08 195.28,103.08 190.79,98.59 190.79,96.95 v3(190.39,96.54) 189.87,96.03 188.43,96.03 CH17.2
PEG_HTX_C_GRX_P10: length 17
  BOTTOM w0.102: UG9.BK38 201.13,105.87 200.62,105.87 200.43,105.68 200.43,105.47 200.19,105.22 199.21,105.22 199.18,105.25
  BOTTOM w0.14: 199.18,105.25 196.08,105.25 v3(193.57,102.74) 189.83,99 189.83,98.22 189.84,98.22 189.84,97.35 189.69,97.2 189.54,97.2 CH15.2
PEG_HTX_C_GRX_P11: length 16.1
  BOTTOM w0.102: 199.18,105.69 199.2,105.68 199.64,105.68 199.71,105.75 199.85,105.75 UG9.BM38
  BOTTOM w0.14: CH13.2 188.01,97.85 188.79,97.85 189.17,98.23 189.17,98.98 v3(190.99,100.8) 195.45,105.27 195.46,105.27 195.89,105.69 199.18,105.69
PEG_HTX_C_GRX_P12: length 16.8
  BOTTOM w0.102: UG9.BL39 200.76,106.24 200.76,106.14 200.68,106.06 200.47,106.06 200.39,106.14 200.39,106.51 200.34,106.57 199.92,106.57 199.79,106.44 199.33,106.44 199.29,106.4 199.18,106.4
  BOTTOM w0.14: 199.18,106.4 197.8,106.4 197.8,106.4 197.17,106.4 197.17,106.4 195.58,106.4 v3(191.82,102.64) 188.48,99.3 188.34,99.3 188.23,99.19 188.23,99.01 188.14,98.92 CH11.2
PEG_HTX_C_GRX_P13: length 18.1
  BOTTOM w0.102: UG9.BK41 201.2,107.65 200.88,107.33 200.87,107.33 200.86,107.32 200.55,107.32 200.37,107.14 199.23,107.14 199.2,107.1 199.18,107.1
  BOTTOM w0.14: CH9.2 186.73,100.1 188.28,100.1 v3(189.01,100.83) 193.18,105 193.19,105 193.74,105.55 193.74,105.56 195.28,107.1 199.18,107.1
PEG_HTX_C_GRX_P14: length 15.8
  BOTTOM w0.102: 199.18,107.81 199.47,107.81 199.57,107.91 199.79,107.91 UG9.BM41
  BOTTOM w0.14: 199.18,107.81 196.01,107.81 196.01,107.81 195.33,107.81 195.33,107.81 194.98,107.81 v3(190.11,102.94) 188.48,101.31 187.36,101.31 CH7.2
PEG_HTX_C_GRX_P15: length 18.4
  BOTTOM w0.102: UG9.BL42 200.75,108.27 200.66,108.18 200.45,108.18 200.37,108.26 200.37,108.42 200.45,108.5 200.45,108.59 200.37,108.67 199.92,108.67 199.79,108.54 199.22,108.54 199.2,108.51 199.18,108.51
  BOTTOM w0.14: CH5.2 185.92,101.97 186.15,101.97 186.28,102.1 186.28,102.26 186.35,102.33 v3(188.11,102.33) 188.5,102.33 191.08,104.91 191.09,104.91 191.73,105.55 191.73,105.56 194.68,108.51 199.18,108.51
PEG_HTX_GRX_N0: length 13.1
  BOTTOM w0.076: UH1.B10 179.41,84.08 179.32,83.98 179.32,83.87 179.44,83.75 180.51,83.75 180.61,83.65 181.33,83.65 181.39,83.71 182.46,83.71 182.51,83.75 182.54,83.75
  BOTTOM w0.14: 182.54,83.75 182.9,83.75 182.91,83.76 183.4,83.76 183.4,83.75 185.55,83.75 v3(186.17,84.37) 188.39,86.6 190.35,86.6 CH36.1
PEG_HTX_GRX_N1: length 12.8
  BOTTOM w0.076: UH1.B11 179.54,84.87 179.49,84.82 179.49,84.64 179.59,84.54 179.72,84.54 179.91,84.73 180.04,84.73 180.22,84.54 180.44,84.54 180.51,84.62 181.03,84.62 181.19,84.45 181.3,84.45 181.38,84.53 181.38,84.77 181.46,84.84 181.61,84.84 181.68,84.77 181.68,84.52 181.76,84.45 181.89,84.45 181.97,84.52 181.97,84.75 182.04,84.83 182.21,84.83 182.28,84.75 182.28,84.52 182.36,84.45 182.47,84.45 182.52,84.49 182.54,84.49
  BOTTOM w0.14: CH34.1 188.83,87.61 188.37,87.61 187.72,86.96 187.71,86.96 187.37,86.62 187.37,86.62 185.25,84.49 v3(184.58,84.49) 182.54,84.49
PEG_HTX_GRX_N2: length 13.2
  BOTTOM w0.076: UH1.B12 179.57,85.74 179.57,85.82 179.64,85.89 179.64,85.97 179.72,86.05 179.8,86.05 179.96,85.88 179.96,85.58 180.22,85.32 180.68,85.32 180.83,85.17 182.48,85.17 182.53,85.22 182.54,85.22
  BOTTOM w0.14: CH32.1 190.21,88.61 188.29,88.61 187.74,88.06 187.74,88.05 v3(186.11,86.42) 184.91,85.22 182.54,85.22
PEG_HTX_GRX_N3: length 11.3
  BOTTOM w0.076: UH1.B13 179.8,86.44 179.85,86.39 179.85,86.24 180.12,85.97 180.64,85.97 180.68,86.01 181.29,86.01 181.57,85.73 182.47,85.73 182.54,85.66
  BOTTOM w0.14: CH30.1 188.77,89.32 188.33,89.32 187.07,88.06 187.07,88.05 186.59,87.57 186.59,87.57 184.67,85.66 v3(183.4,85.66) 182.54,85.66
PEG_HTX_GRX_N4: length 13.5
  BOTTOM w0.076: UH1.B14 179.38,87.23 179.3,87.15 179.3,87.04 179.45,86.9 180.57,86.9 180.86,86.61 182.47,86.61 182.52,86.65 182.54,86.65
  BOTTOM w0.14: 182.54,86.65 184.23,86.65 184.61,87.03 184.61,87.03 v3(187.66,90.08) 188.38,90.79 190.1,90.79 CH28.1
PEG_HTX_GRX_N5: length 11.2
  BOTTOM w0.076: 182.54,87.4 182.52,87.4 182.47,87.45 181.16,87.45 181.02,87.58 180.54,87.58 180.51,87.56 179.99,87.56 179.78,87.77 179.78,87.88 UH1.B15
  BOTTOM w0.14: CH26.1 188.59,91.4 188.24,91.4 185.3,88.47 185.3,88.46 184.93,88.09 184.93,88.09 184.24,87.4 v3(183.21,87.4) 182.54,87.4
PEG_HTX_GRX_N6: length 13.5
  BOTTOM w0.076: 182.54,88.41 182.51,88.41 182.46,88.36 180.73,88.36 180.58,88.51 179.38,88.51 179.27,88.62 179.27,88.73 179.34,88.8 UH1.B16
  BOTTOM w0.14: CH24.1 190.1,92.69 188.09,92.69 187.83,92.43 187.82,92.43 187.36,91.97 187.36,91.96 v3(186.36,90.96) 183.81,88.41 182.54,88.41
PEG_HTX_GRX_N7: length 11.7
  BOTTOM w0.076: UH1.B17 179.77,89.47 179.77,89.31 179.97,89.12 180.67,89.12 180.74,89.19 181.1,89.19 181.38,88.91 182.47,88.91 182.52,88.86 182.54,88.86
  BOTTOM w0.14: 182.54,88.86 182.86,88.86 182.86,88.86 183.45,88.86 183.45,88.86 183.56,88.86 v3(184.82,90.13) 188.15,93.46 188.7,93.46 CH22.1
PEG_HTX_GRX_N8: length 12.8
  BOTTOM w0.076: UH1.C18 179.21,90.38 179.51,90.68 179.76,90.68 179.93,90.51 179.93,90.33 180.2,90.06 180.71,90.06 181,89.77 182.47,89.77 182.52,89.82 182.54,89.82
  BOTTOM w0.14: 182.54,89.82 183.13,89.82 186.02,92.7 186.02,92.71 186.45,93.15 186.46,93.15 v3(187.79,94.47) 188.46,95.15 188.68,95.15 CH20.1
PEG_HTX_GRX_N9: length 11.7
  BOTTOM w0.076: 182.54,90.52 182.53,90.52 182.48,90.47 181.82,90.47 181.32,90.97 180.5,90.97 180.4,90.87 180.07,90.87 179.93,91.01 179.93,91.11 179.99,91.17 UH1.A19
  BOTTOM w0.14: CH18.1 187.35,96.17 187.08,96.17 186.79,95.88 186.79,94.49 184.82,92.52 184.81,92.52 184.4,92.11 184.4,92.1 v3(183.24,90.94) 182.82,90.52 182.54,90.52
PEG_HTX_GRX_N10: length 13.8
  BOTTOM w0.076: UH1.C20 179.06,91.95 179.13,91.88 179.13,91.68 179.35,91.46 180.72,91.46 180.82,91.36 181.33,91.36 181.62,91.07 182.39,91.07 182.43,91.02 182.54,91.02
  BOTTOM w0.14: CH16.1 188.57,96.95 186.92,96.95 186.28,96.32 v3(186.28,95.52) 186.28,94.64 185.54,93.89 185.54,93.88 185.09,93.43 185.08,93.43 182.67,91.02 182.54,91.02
PEG_HTX_GRX_N11: length 11.6
  BOTTOM w0.076: 182.54,92.31 182.47,92.25 181.69,92.25 181.27,92.67 180.76,92.67 180.51,92.42 180.13,92.42 180,92.55 180,92.66 180.07,92.74 UH1.A21
  BOTTOM w0.14: CH14.1 187.07,98.07 186.46,98.07 v3(185.88,97.49) 185.26,96.87 185.26,95.03 183.22,92.99 183.21,92.99 182.74,92.53 182.74,92.52 182.54,92.31
PEG_HTX_GRX_N12: length 13.4
  BOTTOM w0.076: UH1.C22 179.29,93.82 179.76,93.82 179.96,93.61 179.96,93.36 180.13,93.2 180.63,93.2 180.7,93.13 182.42,93.13 182.54,93.25 182.54,93.33
  BOTTOM w0.14: CH12.1 187.07,99.36 186.37,99.36 186.36,99.37 185.83,99.37 185.82,99.36 185.36,99.36 184.13,98.13 v3(184.13,95.99) 184.13,94.91 182.54,93.33
PEG_HTX_GRX_N13: length 11.2
  BOTTOM w0.076: 182.36,94.22 182.25,94.11 180.49,94.11 180.36,93.98 180.08,93.98 179.97,94.09 179.97,94.24 180.05,94.32 UH1.A23
  BOTTOM w0.14: CH10.1 185.78,100.38 185.28,100.38 183.94,99.04 183.93,99.04 183.41,98.53 183.41,95.28 v3(182.84,94.71) 182.36,94.22
PEG_HTX_GRX_N14: length 13
  BOTTOM w0.076: 182.36,95.32 182.34,95.3 182.34,95.24 181.87,94.77 180.24,94.77 180.12,94.88 180.02,94.88 179.93,94.97 179.93,95.22 179.76,95.38 179.28,95.38 UH1.C24
  BOTTOM w0.14: 182.36,95.32 182.67,95.62 v3(182.67,96.68) 182.67,98.92 185.26,101.52 186.35,101.52 CH8.1
PEG_HTX_GRX_N15: length 10.6
  BOTTOM w0.076: 182.36,99.77 182.34,99.76 182.34,99.69 182.15,99.5 182.15,96.45 181.39,95.7 180.63,95.7 180.5,95.57 180.2,95.57 180.01,95.76 180.01,95.85 180.11,95.95 180.24,95.95 UH1.A25
  BOTTOM w0.14: CH6.1 185.17,102.45 184.86,102.45 184.6,102.19 184.6,102.01 v3(184.32,101.73) 182.84,100.25 182.83,100.25 182.46,99.88 182.46,99.87 182.36,99.77
PEG_HTX_GRX_P0: length 13.2
  BOTTOM w0.076: UH1.C10 179.15,83.92 179.15,83.81 179.38,83.58 180.44,83.58 180.54,83.49 181.4,83.49 181.46,83.54 182.48,83.54 182.53,83.5 182.54,83.5
  BOTTOM w0.14: CH35.1 190.35,86.34 188.5,86.34 186.58,84.43 186.58,84.42 186.14,83.98 186.13,83.98 185.65,83.5 v3(183.15,83.5) 182.54,83.5
PEG_HTX_GRX_P1: length 12.8
  BOTTOM w0.076: 182.54,84.24 182.49,84.28 181.13,84.28 180.96,84.45 180.58,84.45 180.51,84.38 179.52,84.38 179.33,84.57 179.33,84.97 179.51,85.15 179.93,85.15 180.21,84.87 UH1.A11
  BOTTOM w0.14: 182.54,84.24 184.34,84.24 184.34,84.23 184.83,84.23 184.84,84.24 185.35,84.24 v3(187.73,86.61) 188.48,87.36 188.83,87.36 CH33.1
PEG_HTX_GRX_P2: length 13.2
  BOTTOM w0.076: UH1.C12 179.25,85.65 179.57,85.34 179.97,85.34 180.16,85.15 180.61,85.15 180.76,85.01 182.47,85.01 182.52,84.96 182.54,84.96
  BOTTOM w0.14: 182.54,84.96 185.01,84.96 186.06,86.01 186.07,86.01 186.48,86.41 186.48,86.42 v3(188.17,88.11) 188.41,88.36 190.25,88.36 CH31.1
PEG_HTX_GRX_P3: length 11.2
  BOTTOM w0.076: 182.54,85.91 182.53,85.91 182.51,85.9 181.63,85.9 181.35,86.17 180.61,86.17 180.57,86.13 180.19,86.13 180.02,86.3 180.02,86.46 180.1,86.55 180.19,86.55 UH1.A13
  BOTTOM w0.14: CH29.1 188.89,89.82 188.65,89.58 188.23,89.58 v3(186.63,87.98) 184.57,85.91 183.71,85.91 183.7,85.92 183.11,85.92 183.11,85.91 182.54,85.91
PEG_HTX_GRX_P4: length 13.5
  BOTTOM w0.076: UH1.C14 179.13,87.09 179.13,86.98 179.38,86.73 180.5,86.73 180.79,86.44 182.47,86.44 182.52,86.4 182.54,86.4
  BOTTOM w0.14: 182.54,86.4 184.35,86.4 v3(184.56,86.61) 187.67,89.72 187.68,89.72 188.02,90.06 188.02,90.07 188.48,90.54 190.1,90.54 CH27.1
PEG_HTX_GRX_P5: length 11.2
  BOTTOM w0.076: UH1.A15 180.03,88.02 179.95,87.94 179.95,87.84 180.06,87.72 180.44,87.72 180.47,87.75 181.09,87.75 181.23,87.61 182.47,87.61 182.52,87.66 182.54,87.66
  BOTTOM w0.14: CH25.1 188.56,91.66 188.14,91.66 v3(184.92,88.44) 184.13,87.66 183.54,87.66 183.54,87.66 182.97,87.66 182.96,87.66 182.54,87.66
PEG_HTX_GRX_P6: length 13.5
  BOTTOM w0.076: 182.54,88.15 182.51,88.15 182.46,88.2 180.66,88.2 180.51,88.34 179.29,88.34 179.1,88.53 179.1,88.7 UH1.C16
  BOTTOM w0.14: 182.54,88.15 183.91,88.15 186.36,90.6 186.37,90.6 186.78,91.01 186.78,91.02 v3(187.79,92.03) 188.2,92.44 190.1,92.44 CH23.1
PEG_HTX_GRX_P7: length 11.7
  BOTTOM w0.076: UH1.A17 180.01,89.59 179.93,89.51 179.93,89.38 180.03,89.28 180.6,89.28 180.67,89.35 181.17,89.35 181.45,89.07 182.47,89.07 182.52,89.12 182.54,89.12
  BOTTOM w0.14: 182.54,89.12 v3(183.15,89.12) 183.45,89.12 184.45,90.11 184.45,90.12 184.86,90.54 184.87,90.54 188.05,93.71 188.7,93.71 CH21.1
PEG_HTX_GRX_P8: length 12.9
  BOTTOM w0.076: UH1.B18 179.44,90.38 179.3,90.24 179.3,89.98 179.38,89.9 179.58,89.9 179.8,90.12 179.9,90.12 180.13,89.89 180.64,89.89 180.93,89.61 182.47,89.61 182.52,89.56 182.54,89.56
  BOTTOM w0.14: 182.54,89.56 183.24,89.56 v3(186.44,92.76) 187.76,94.08 187.77,94.08 188.14,94.46 188.14,94.47 188.57,94.9 188.72,94.9 CH19.1
PEG_HTX_GRX_P9: length 11.7
  BOTTOM w0.076: UH1.B19 179.77,91.04 179.77,90.94 180.01,90.71 180.47,90.71 180.57,90.81 181.25,90.81 181.75,90.31 182.48,90.31 182.53,90.26 182.54,90.26
  BOTTOM w0.14: CH17.1 187.38,95.92 187.19,95.92 187.05,95.78 187.05,94.39 v3(184.79,92.13) 183.72,91.06 183.72,91.05 182.93,90.26 182.54,90.26
PEG_HTX_GRX_P10: length 13.7
  BOTTOM w0.076: 182.54,91.28 182.53,91.28 182.48,91.23 181.69,91.23 181.4,91.53 180.89,91.53 180.79,91.63 179.42,91.63 179.3,91.75 179.3,91.88 179.38,91.95 UH1.B20
  BOTTOM w0.14: 182.54,91.28 182.57,91.28 v3(185.12,93.83) 186.03,94.74 186.03,95.21 186.02,95.22 186.02,95.77 186.03,95.77 186.03,96.42 186.81,97.2 188.57,97.2 CH15.1
PEG_HTX_GRX_P11: length 11.7
  BOTTOM w0.076: 182.54,92.04 182.52,92.04 182.47,92.08 181.62,92.08 181.2,92.51 180.83,92.51 180.57,92.26 180.26,92.26 180.06,92.26 179.81,92.5 179.81,92.58 UH1.B21
  BOTTOM w0.14: 182.54,92.04 182.62,92.04 v3(183.15,92.56) 185.51,94.93 185.51,96.76 185.83,97.08 185.84,97.08 186.23,97.48 186.23,97.49 186.56,97.82 187.14,97.82 CH13.1
PEG_HTX_GRX_P12: length 13.4
  BOTTOM w0.076: UH1.B22 179.38,93.53 179.28,93.43 179.28,93.18 179.41,93.06 179.55,93.06 179.75,93.26 179.83,93.26 180.06,93.03 180.57,93.03 180.63,92.96 182.53,92.96 182.54,92.97
  BOTTOM w0.14: 182.54,92.97 184.38,94.81 184.38,95.68 184.39,95.69 184.39,96.28 184.38,96.28 184.38,98.02 185.47,99.11 v3(186.07,99.11) 187.07,99.11 CH11.1
PEG_HTX_GRX_P13: length 11.2
  BOTTOM w0.076: UH1.B23 179.81,94.16 179.81,94.02 180.01,93.82 180.43,93.82 180.56,93.94 182.38,93.94 182.46,94.03 182.52,94.03 182.54,94.04
  BOTTOM w0.14: 182.54,94.04 182.85,94.35 182.86,94.35 183.2,94.69 183.2,94.7 183.67,95.17 183.67,98.41 v3(183.94,98.69) 185.38,100.12 185.78,100.12 CH9.1
PEG_HTX_GRX_P14: length 13
  BOTTOM w0.076: UH1.B24 179.66,95.1 179.66,94.67 179.71,94.61 179.84,94.61 179.95,94.72 180.05,94.72 180.17,94.61 180.5,94.61 180.58,94.53 180.58,94.35 180.66,94.27 180.81,94.27 180.88,94.35 180.88,94.53 180.96,94.61 181.13,94.61 181.2,94.53 181.2,94.47 181.28,94.39 181.43,94.39 181.51,94.47 181.51,94.53 181.58,94.61 181.94,94.61 182.46,95.12 182.52,95.12 182.54,95.14
  BOTTOM w0.14: 182.54,95.14 182.92,95.52 182.92,96.4 182.93,96.4 182.93,97.01 182.92,97.01 182.92,98.81 v3(184.3,100.19) 185.38,101.27 186.48,101.27 CH7.1
PEG_HTX_GRX_P15: length 10.6
  BOTTOM w0.076: UH1.B25 179.88,95.66 180.13,95.41 180.57,95.41 180.7,95.53 181.46,95.53 182.31,96.39 182.31,99.43 182.46,99.58 182.52,99.58 182.54,99.59
  BOTTOM w0.14: CH5.1 185.1,102.2 184.97,102.2 184.85,102.08 184.85,101.89 184.28,101.32 184.27,101.32 v3(182.83,99.88) 182.76,99.81 182.54,99.59
PEG_RCOMP: length 11.5
  BOTTOM w0.152: UH1.G2 176.51,78.84 176.83,78.52 177.27,78.52 177.28,78.53 177.66,78.53 177.95,78.24 177.95,77.88 178.22,77.61
  BOTTOM w0.508: RH24.2 175.05,70.65 v2(176.09,71.68) 178.22,73.81 178.22,77.61
PEX_CLKREQ#: length 29.4
  TOP w0.14: RG163.1 197.97,95.09 v2(198.15,95.27)
  IN4 w0.137: v2(204.32,74.96) 204.23,74.96 203.47,75.72 202.64,75.72 201.61,76.75 201.61,77.54 200.38,78.77 199.66,78.77 198.34,80.09 198.34,87.22 198.55,87.43 198.55,94.42 198.15,94.82 v2(198.15,95.27)
  BOTTOM w0.089: 199.18,96.54 199.76,96.54 200.02,96.8 200.19,96.8 200.2,96.8 200.32,96.8 200.67,97.15 UG9.BL26
  BOTTOM w0.14: v2(204.32,74.96) 204.4,75.03 QG510.3 ; 199.18,96.54 198.98,96.54 198.15,95.71 v2(198.15,95.27)
PEX_TERMP: length 3.3
  BOTTOM w0.089: 199.12,109.38 200.38,109.38 UG9.BL44
  BOTTOM w0.14: 199.12,109.38 RG23.2
PEX_VDD_EN: length 157.4
  TOP w0.14: v2(192.77,59.31) v1(193.23,58.86) 193.36,58.73 195.91,58.73 196.39,59.21 196.39,60.86 196.71,61.18 197.07,61.18 197.27,61.38 QG509.2
  IN1 w0.097: v2(99.7,71.14) 100.38,71.82 100.38,74.4 101.17,75.19 102.77,76.21 103.46,76.51 103.6,76.57 103.98,76.81 104.26,76.96 105.14,77.6 105.9,78.36 105.97,78.4 107.9,80.34 107.9,80.36 107.9,83.83 108.82,84.75 111.93,84.75 114.14,86.96 117.98,86.96 v2(118.5,87.48)
  IN3 w0.254: v2(118.5,87.48) 122.92,91.9 122.92,92.37 123.23,92.67 v2(123.57,92.67)
  BOTTOM w0.14: v2(192.77,59.31) 190.96,57.5 170.04,57.5 167.88,55.34 105.98,55.34 102.43,58.89 102.43,62.38 101.86,62.95 101.86,65.12 102.21,65.47 102.21,69.42 101.14,70.49 100.34,70.49 v2(99.7,71.14)
  BOTTOM w0.254: v2(118.5,87.48) 118.5,88.19 117.6,89.09 117.2,89.09 116.23,90.06 115.2,90.06 114.83,89.69 UG31.4 ; PR10V4.1 v2(123.57,92.67)
PEX_VDD_EN_U: length 4.6
  BOTTOM w0.14: DG10.2 114.92,85.07 114.49,84.64 v1(113.79,84.64)
  BOTTOM w0.254: DG10.2 114.87,85.25 CG482.1 RG550.2 115.74,86.69 115.48,86.95 UG31.2
PHASE_ID1: length 5.7
  TOP w0.14: v1(274.21,32.76) 274.21,32.86 273.91,33.16 v2(273.91,33.21) 273.88,33.24 272.85,33.24 RH547.2 RH548.1
  BOTTOM w0.076: UH2.AU43 276.18,34.31 275.93,34.06 275.71,34.06 275.47,34.06 275.06,33.65 274.37,33.65 274.23,33.52
  BOTTOM w0.14: v2(273.91,33.21) 273.93,33.24 273.95,33.24 274.23,33.52
PHASE_ID2: length 5.8
  BOTTOM w0.076: 274.23,33.82 274.95,33.82 275.5,34.37 275.5,34.41 275.63,34.54 275.75,34.54 276.06,34.85 UH2.AT43
  BOTTOM w0.14: 274.23,33.82 273.37,33.82 273.17,33.62 RH550.1 RH549.2
PIRQA#: length 2.7
  TOP w0.14: v2(289.31,33.46) 289.12,33.46 RH546.1 287.8,34.79 v1(287.68,34.79)
  BOTTOM w0.076: UH2.AW17 288.94,33.09 v2(289.31,33.46)
PLTRST_CPU#: length 262.1
  TOP w0.14: v2(298.01,37.87) 298.07,37.87 298.44,37.49 299.14,37.49 299.89,38.24 299.89,38.85 297.42,41.32 297.42,41.74 296.9,42.26 296.9,42.64 297.73,43.46 298.51,43.46 299,43.95 299,44.18 299.59,44.77 v4(299.59,50.4) 299.59,51.95 299,52.54 291.63,52.54 291.11,52.02 290.5,52.02 290.09,52.43 290.09,53.89 287.25,56.73 287.25,59.4 285.22,61.43 v2(285.22,67.47) ; v2(199.3,74.81) 198.75,74.81 196.67,72.74 196.67,72.26 196.38,71.97 196.38,69.16 193.05,65.82 193.05,65.2 RH523.1
  IN2 w0.097: v2(285.22,67.47) 284.25,67.47 282.2,69.52 277.78,69.52 277.78,69.52 275.08,69.52 274.76,69.2 264.58,69.2 262.25,71.53 245.53,71.53 244.72,72.35 241.6,72.35 240.32,73.62 228.13,73.62 224.83,76.93 212.66,76.93 210.45,74.72 208.29,74.72 208.03,74.46 205.52,74.46 204.57,75.4 203.49,75.4 202.37,76.52 200.55,76.52 199.56,75.53 199.56,75.07 v2(199.3,74.81)
  IN3 w0.124: v2(132.17,105.39) 133.02,105.39 138.47,110.84 158.56,110.84 159.01,111.29 167.7,111.29 167.93,111.52 175.55,111.52 176.4,110.67 180.72,110.67 181.57,109.83 184.4,109.83 186.31,107.92 186.31,106.81 188.71,104.41 188.71,104.03 192.1,100.63 192.1,80.65 194.88,77.88 195.94,77.88 199,74.81 v2(199.3,74.81)
  BOTTOM w0.076: v2(298.01,37.87) 297.95,37.87 297.62,37.54 296.77,37.54 296.41,37.91 UH2.AK2
  BOTTOM w0.102: 137.76,103.48 137.76,103.3 138.78,102.28 139.96,102.28 140.02,102.35 140.6,102.35 140.97,102.71 UH1.BP35
  BOTTOM w0.14: 137.76,103.48 135.85,105.39 v2(132.17,105.39)
POL1_SCL: length 3.1
  TOP w0.14: UVGA1.9 322.88,37.11 323.06,36.92 323.06,36.4 323.25,36.21 v1(323.38,36.21) 323.44,36.21 RVGA6.1
POL1_SDA: length 2.3
  TOP w0.14: UVGA1.10 v1(323.37,37.51) 323.57,37.51 324.07,38 RVGA5.1
POWER_SW#_MB: length 111.3
  TOP w0.254: v2(272.31,13.24) 272.57,12.98 v4(272.95,12.98) 280.32,12.98 281.25,12.05 SW5.1 283.7,10.91 284.71,9.9 287.25,9.9 287.88,10.53 v2(287.88,11.78)
  IN1 w0.097: v2(302.62,15.33) 302.53,15.42 292.81,15.42 292.05,14.66 288.96,14.66 287.88,13.58 v2(287.88,11.78)
  IN2 w0.254: v2(218.47,23.73) 219,23.19 224.86,23.19 226.82,25.15 236.74,25.15 240.23,21.65 251.99,21.65 253.16,20.48 257.62,20.48 263.72,14.38 270.49,14.38 271.43,13.44 272.11,13.44 v2(272.31,13.24)
  BOTTOM w0.14: RE47.2 301.97,18.57 301.97,16.09 302.62,15.44 v2(302.62,15.33) ; v2(218.47,23.73) 218.47,29.82 D5225.2 217.68,30.4 216.15,28.88 JPW.4
POWER_SW_IN#: length 5.9
  TOP w0.14: UE1.127 301.2,21.77 v2(301.35,21.62)
  BOTTOM w0.14: v1(302.35,18.42) 302.35,18.67 301.49,19.54 RE47.1 CE12.1 301.49,21.48 v2(301.35,21.62) 301.35,22.3 RE31.2
PQ5_G: length 3.7
  TOP w0.127: PR21.2 v1(66.88,28.62)
  TOP w0.254: PQ5.2 65.55,28.51 PR21.2 PC12.2
PQ6A_D: length 2.5
  TOP w0.14: v1(50.83,31.32) PR15.2
  TOP w0.254: PQ6.6 51.1,29.42 50.83,29.7 PR15.2
PQ6A_G: length 5.3
  TOP w0.14: v1(49.58,26.48) 51.32,26.48 51.75,26.05
  TOP w0.254: PR16.1 52.96,26.98 52.87,27.07 PQ6.3 PQ6.2 51.75,26.05 PR22.2
PQ6B_G: length 5.4
  TOP w0.254: PC13.1 52.6,30.19 51.75,29.34 PQ6.5 51.75,28.67 51.45,28.36 50.62,28.36 50.34,28.65 v1(49.74,28.65) 49.45,28.36 PR20.2
PQ700_G: length 4.1
  TOP w0.14: PR700.1 v1(49.59,24.09)
  TOP w0.254: PQ700.2 52.64,25.89 PR701.2 50.89,24.13 PR700.1
PQ701_G: length 1.6
  BOTTOM w0.254: PR702.1 54.84,49.66 PQ701.4
PQ702_G: length 3
  TOP w0.127: v1(56.68,55.27) PR704.1
  TOP w0.254: PR704.1 55.49,54.33 PQ702.4
PQ703_S:
  vias: v1(51.97,39.94) v2(45.25,37.7) v2(45.84,37.7) v2(46.42,37.7) v2(47,37.7) v2(49.51,39.91) v2(49.51,39.27) v2(49.82,40.54) v2(50.14,39.91) v2(50.14,39.27) v2(50.46,40.54) v2(50.78,39.91) v2(50.78,39.27) v2(51.09,40.54) v2(51.41,39.91) v2(51.41,39.27) v2(53.38,39.91) v2(53.38,39.27) v2(54.01,39.91) v2(54.01,39.27)
PQ704_G: length 3.8
  TOP w0.14: v1(51.45,35.52) 51.04,35.93 PR707.1
  TOP w0.254: PQ704.4 52.12,36.72 PC703.1 51.11,36.73 PR707.1
PQ707_D: length 2.7
  TOP w0.14: v1(38.94,31.26) 39.45,31.77 PQ706.1
  TOP w0.254: PR713.2 39.45,32.96 PQ706.1
PQ8203B_G: length 3.9
  TOP w0.14: v1(167.51,130.42) 167.17,130.08 PR6034.2
  TOP w0.254: PR6034.2 166.36,130.08 PQ6000.6 166.36,131.43 166.2,131.59 165.84,131.59 165.71,131.46 PQ6000.5
PRIM_PWRGD: length 9.8
  TOP w0.14: RE149.1 RE150.1 RE133.1 293.61,12.06 v1(294.22,11.45) 295.08,10.59 295.08,9.84 295.4,9.52 296.98,9.52 297.25,9.79 UE1.30
PRIM_PWRGD_R: length 356.7
  TOP w0.14: RE133.2 292.74,10.72 v2(292.52,10.51)
  TOP w0.203: PU300.7 81.68,44.8 82.07,45.19 82.07,45.31 v2(82.2,45.44)
  TOP w0.254: v2(261.65,26.38) 256.07,20.79 254.37,20.79 253.99,21.17 v2(253.99,21.3) 253.44,20.75 252.95,20.75 250.78,22.93 250.78,24.99 v1(251.08,25.29) 251.08,27.68 249.53,29.23 249.53,35.46 249.34,35.65 PR103.1 ; PR314.1 84.41,46.48 v2(84.43,46.46)
  IN3 w0.124: v2(89.83,22.95) 91.08,24.2 114.68,24.2 116.19,22.7 121.51,22.7 123.22,24.4 128.73,24.4 130.2,22.93 140.36,22.93 140.46,22.82 161.14,22.82 162.77,24.46 208.2,24.46 210.02,22.63 224.64,22.63 226.65,24.64 236.84,24.64 239.21,22.27 251.27,22.27 252.44,21.1 253.79,21.1 v2(253.99,21.3) 253.99,21.44 254.32,21.77 255.3,21.77 262.84,14.23 262.84,13.63 264.97,11.51 270.84,11.51 274.44,7.9 291.89,7.9 292.52,8.54 v2(292.52,10.51)
  IN4 w0.137: v2(89.83,22.95) 89.19,22.32 82.14,22.32 80.3,24.16 80.3,26.83 82.62,29.14 82.62,32.29 81.93,32.97 81.93,33.35 81.29,34 81.29,38.63 81.94,39.28 81.94,41.08 82.62,41.76 82.62,45.02 v2(82.2,45.44)
  BOTTOM w0.254: v2(82.2,45.44) 83.41,45.44 v2(84.43,46.46) ; PU18V00.9 270.04,77.19 267.27,74.43 267.27,70.34 272.94,64.67 275.61,64.67 277.47,62.81 277.47,56.46 275.2,54.19 269.79,54.19 269,53.41 269,52.44 266.61,50.05 266.61,47.59 267.86,46.34 267.84,46.33 267.84,37.33 267.56,37.05 266.61,37.05 266.17,36.6 266.17,28.54 264.58,26.95 262.23,26.95 v2(261.65,26.38)
