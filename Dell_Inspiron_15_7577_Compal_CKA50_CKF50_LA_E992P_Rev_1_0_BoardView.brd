# Allegro board Dell_Inspiron_15_7577_Compal_CKA50_CKF50_LA_E992P_Rev_1_0_BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GPU_GC6_FB_EN: length 41.1
  TOP w0.089: UG27.1 210.87,79.2 v2(211.24,78.83) ; RG22.1 206.74,82.04 v2(206.59,82.19)
  TOP w0.14: v2(214.6,59.17) 215.23,59.81 v1(215.33,59.81) 216.12,59.81 216.54,59.39 218.23,59.39 RG553.1 219.35,59.47 QG511.3
  IN3 w0.089: v2(211.24,78.83) 210.8,78.39 207.33,78.39 206.89,78.83 206.89,80.03 206.59,80.34 v2(206.59,82.19)
  IN4 w0.137: v2(214.6,59.17) 214.36,58.94 213.08,58.94 212.54,59.48 212.54,61.92 212.12,62.33 211.48,62.33 211.14,62.68 211.14,63.79 211.57,64.22 211.57,65.42 211.21,65.78 210.73,65.78 210.53,65.97 210.46,66.04 210.46,66.61 209.93,67.13 209.93,70.14 210.89,71.09 210.89,78.48 v2(211.24,78.83)
  BOTTOM w0.114: UG9.BB5 206.85,82.45 v2(206.59,82.19)
GPU_GC6_FB_EN_H: length 97.4
  TOP w0.14: v2(223.08,60.11) 223.08,60.44 222.89,60.63 v1(222.71,60.63) 222.17,60.63 QG511.1 ; RH545.2 282.23,31.21 284.53,33.51 v2(284.67,33.51)
  IN3 w0.124: v2(223.08,60.11) 225.88,60.11 226.42,59.58 226.92,59.58 227.74,60.39 230.85,60.39 231.19,60.73 233.33,60.73 233.46,60.61 233.47,60.61 234.04,60.04 235.91,60.04 238.19,62.32 264.1,62.32 268.23,58.2 268.23,37.36 269.41,36.18 269.41,35.17 271.76,32.83 271.76,32.54 272.42,31.88 273.89,31.88 274.8,30.98 276.5,30.98 276.74,31.22 276.74,31.56 277.96,32.77 280.24,32.77 281.42,33.95 283.07,33.95 283.25,34.13 284.05,34.13 v2(284.67,33.51)
  BOTTOM w0.102: UH2.AW27 v2(284.67,33.51)
GPU_HPD_RT: length 168.2
  TOP w0.14: RG575.2 199.16,63.15 201.02,63.15 201.41,63.54 UG30.1 201.41,64.59 v2(201.08,64.93) ; RP45.2 331.83,38.14 331.39,37.71 v2(331.39,36.22)
  IN2 w0.124: v2(200.59,69.97) 200.59,69.55 201.06,69.08 208.64,69.08 210.08,70.51 211.95,70.51 212.3,70.86 222.45,70.86 223.11,71.53 244.38,71.53 245.19,70.71 261.91,70.71 264.24,68.38 275.1,68.38 275.42,68.7 277.44,68.7 277.44,68.7 281.86,68.7 284.11,66.45 290.6,66.45 298.59,58.46 302.64,58.46 304.4,56.7 308.13,56.7 309.47,55.37 313.12,55.37 316.29,52.19 316.29,48.88 315.52,48.11 315.52,42.39 316.17,41.74 316.17,41.11 321.3,35.97 327.47,35.97 328.07,35.37 330.84,35.37 331.39,35.93 v2(331.39,36.22)
  IN4 w0.137: v2(201.08,64.93) 201.08,65.24 200.43,65.9 200.43,69.55 200.59,69.71 v2(200.59,69.97)
GPU_ID1: length 12.4
  TOP w0.14: RH551.2 RH552.1 271.25,40.03 271.53,40.31 272.65,40.31 273.38,39.59 274.74,39.59 275.77,38.56 v1(279.27,38.56) 279.75,38.56 v2(280.5,37.81)
  BOTTOM w0.076: UH2.AJ33 280.86,38.17 v2(280.5,37.81)
GPU_ID2: length 11.4
  TOP w0.14: RH554.1 RH553.2 270.75,35.89 271.26,35.39 273.46,35.39 273.74,35.11 v1(273.88,35.11) v2(274.55,35.11)
  BOTTOM w0.076: v2(274.55,35.11) 274.55,35.1 274.7,34.95 275.31,34.95 275.59,35.23 275.8,35.23 275.95,35.37 275.95,35.44 276.22,35.71 276.7,35.71 276.84,35.85 276.84,36.41 276.66,36.59 UH2.AM43
GPU_IMON: length 2.4
  TOP w0.203: PU6000.25 155.24,138.34 154.79,138.79 v1(154.62,138.79) 153.87,138.79 PR6013.2
GPU_JTAG_TCK: length 4.4
  BOTTOM w0.114: UG9.BK24 201.28,95.92 201.04,95.92 200.88,96.07 200.62,96.07 200.61,96.07 200.58,96.11 199.9,96.11 199.5,95.72
  BOTTOM w0.14: 199.5,95.72 199.5,95.34 198.68,94.52 T10.1
GPU_JTAG_TDI: length 4.3
  BOTTOM w0.114: UG9.BM23 199.18,94.18
  BOTTOM w0.14: T12.1 197.84,93.08 198.08,93.08 199.18,94.18
GPU_JTAG_TDO: length 3.8
  BOTTOM w0.089: UG9.BM24 199.71,95.41 199.71,95.14 199.14,94.57
  BOTTOM w0.14: T13.1 197.99,93.42 199.14,94.57
GPU_JTAG_TMS: length 7.3
  BOTTOM w0.089: 199.18,93.5 199.5,93.82 199.51,93.82 200.74,95.05 UG9.BL23
  BOTTOM w0.14: T11.1 197.05,90.08 197.05,90.74 197.47,91.16 198.3,91.16 198.54,91.4 198.54,92.1 198.77,92.33 198.77,93.08 199.18,93.5 199.18,93.5
GPU_JTAG_TRST#: length 6.3
  TOP w0.089: v1(199.43,94.72) 200.11,95.41 v2(200.41,95.41)
  BOTTOM w0.089: UG9.BL24 200.75,95.75 v2(200.41,95.41) 200.41,94.97 199.89,94.45 199.79,94.45 199.18,93.84
  BOTTOM w0.14: 199.18,93.84 198.48,93.14 198.48,92.55 198.2,92.27 RG518.1
GPU_LPC: length 4.2
  TOP w0.203: v2(157.97,134.34) 158.14,134.51 PU6000.35
  TOP w0.254: PR6050.1 157.52,133.89 v2(157.97,134.34)
  BOTTOM w0.14: v2(157.97,134.34) 158.4,134.76 v1(158.56,134.76)
  BOTTOM w0.254: PR6063.2 157.96,133.82 157.96,134.33 v2(157.97,134.34)
GPU_PEX_RST_HOLD#: length 31.1
  IN3 w0.124: v2(206.16,69.89) 205.71,69.43 203.38,69.43 202.39,68.45 198.25,68.45 196.06,70.64 194.66,70.64 v2(193.97,69.95)
  IN4 w0.089: 204.42,78.19 203.98,78.19 203.18,79 203.18,79.37 203.27,79.46 203.27,80.28 203.73,80.74 v2(203.92,80.74)
  IN4 w0.137: v2(206.16,69.89) 206.16,71.41 205.78,71.8 205.78,74.06 206.33,74.61 206.33,76.28 204.42,78.19
  BOTTOM w0.109: UG9.BG3 203.61,81.05 v2(203.92,80.74)
  BOTTOM w0.14: RG166.1 192.94,70.35 193.17,70.57 193.17,71 193.55,71.38 DG9.3 194.02,70 v2(193.97,69.95)
GPU_PROG1: length 5.7
  TOP w0.203: PU6000.24 155.32,138.74 154.77,139.29 v2(154.55,139.29) 153.85,139.29 PR6046.1
  BOTTOM w0.127: PR6056.2 153.61,141.89 v1(153.79,142.07)
  BOTTOM w0.254: PR6056.2 153.61,140.24 v2(154.55,139.29)
GPU_PROG2: length 3.7
  TOP w0.203: PU6000.23 155.35,139.14 154.61,139.88 v1(154.61,140.2) 154.45,140.36 PR6047.1 PR6057.2
GPU_PROG3: length 5.2
  TOP w0.14: v1(154.79,133.15) 155.31,133.15 PR6048.1
  TOP w0.203: PU6000.33 157.34,135.12 156.69,134.47 156.57,134.47 v2(156.36,134.25) 156.36,134.2 PR6048.1
  BOTTOM w0.254: v2(156.36,134.25) 156.01,134.25 155.67,133.92 PR6058.2
GPU_PROG4: length 4.3
  TOP w0.203: PU6000.34 157.74,134.81 v2(157.33,134.39) 157.33,134.28 PR6044.1
  BOTTOM w0.14: v2(157.33,134.39) 157.33,134.9 v1(157.28,134.95)
  BOTTOM w0.254: v2(157.33,134.39) 157.33,134.23 PR6059.2
GPU_PROG5: length 8.1
  TOP w0.203: v2(154.67,138.07) 155.08,138.07 155.2,137.94 PU6000.26
  BOTTOM w0.14: v1(155.67,139.05) 154.69,138.07 v2(154.67,138.07)
  BOTTOM w0.254: PR6060.2 151.54,138.41 151.88,138.07 v2(154.67,138.07)
GPU_PROG6: length 2.2
  TOP w0.203: PR6035.1 161.41,137.14 PU6000.3
GPU_PSI: length 5.1
  TOP w0.203: PU6000.37 158.94,134.52 v2(159.3,134.17) PR6051.2
  BOTTOM w0.14: v2(159.3,134.17) 159.98,134.17 v1(160.39,134.57)
  BOTTOM w0.254: v2(159.3,134.17) 159.36,134.1 PR6054.2 158.46,133.39 PR6042.1
GPU_PWM1: length 20.6
  TOP w0.14: v2(172.19,128.93) v4(171.32,128.93)
  TOP w0.254: PR6041.2 163.5,141.37 163.17,141.7 v2(162.52,141.7)
  IN4 w0.254: v2(172.19,128.93) 172.19,134.58 170.79,135.98 169.39,135.98 163.74,141.63 162.85,141.63 162.79,141.7 v2(162.52,141.7)
GPU_PWM2: length 10
  TOP w0.14: v2(171.74,138.52) v1(170.96,138.52)
  TOP w0.254: PR6045.2 164.1,140.1 v2(164.12,140.12)
  IN1 w0.254: v2(171.74,138.52) 170.36,138.52 169.95,138.12 168.26,138.12 166.26,140.11 164.14,140.11 v2(164.12,140.12)
GPU_PWM3: length 30.8
  TOP w0.14: v2(173.84,117.19) v4(173.84,116.41)
  TOP w0.254: PR6053.1 163.55,139.16 v2(164.09,139.16)
  IN4 w0.254: v2(173.84,117.19) 173.84,121.24 175.26,122.67 175.26,124.93 174.18,126.01 174.18,126.33 173.33,127.18 172.74,127.18 171.68,128.24 171.68,129.11 171.83,129.26 171.83,134.44 170.64,135.63 169.25,135.63 165.72,139.16 v2(164.09,139.16)
GPU_PWR_EN: length 230.3
  TOP w0.14: v2(210.26,64.72) 210.1,64.56 UG25.2 210.1,61.22 RG551.2 210.4,60.66 210.57,60.49 211.58,60.49 v1(211.96,60.87) v2(211.96,61.64) ; v2(203.87,64.08) 203.81,64.01 203.81,62.39 203.35,61.93 UG26.1
  IN5 w0.097: v2(116.68,84.47) 119.5,81.65 119.5,53.49 121.57,51.43 121.57,36.48 123.59,34.45 139.29,34.45 141.51,32.23 143.76,32.23 144.39,32.86 167.06,32.86 167.38,33.18 167.38,33.63 167.72,33.97 168.67,33.97 168.83,34.12 171.18,34.12 171.59,33.71 175.99,33.71 176.54,33.17 176.54,32.67 176.99,32.22 188.74,32.22 189.42,32.9 228.9,32.9 229.57,33.58 230.84,33.58 233.24,35.98 233.24,40.8 234.61,42.17 234.61,51.3 228.68,57.23 227.27,57.23 224.9,59.6 220.8,59.6 218.95,61.46 212.14,61.46 v2(211.96,61.64) ; v2(203.87,64.08) 203.87,64.16 205.02,65.31 205.69,65.31 206.26,64.74 210.24,64.74 v2(210.26,64.72)
  BOTTOM w0.254: v2(116.68,84.47) 116.79,84.47 117.22,84.9 117.22,86.67 116.55,87.34 UG31.1
GPU_PWR_LEVEL: length 35.8
  TOP w0.14: UE1.10 300.75,17.79 v2(300.88,17.66) ; v2(302.11,43.53) v1(302.83,44.25) 304.76,44.25 304.96,44.04 DG8.1
  IN2 w0.097: v2(302.11,43.53) 302.49,43.14 302.49,37.3 302.17,36.99 302.17,31.27 304.3,29.15 304.32,29.15 304.56,28.91 304.56,28.89 304.59,28.86 304.59,27.27 304.39,27.08 304.39,23.02 304.84,22.57 304.84,21.34 304.55,21.05 303.7,21.05 302.17,19.52 302.17,18.16 302.08,18.06 301.28,18.06 v2(300.88,17.66)
GPU_THM_SMBCLK: length 420.4
  TOP w0.14: UE1.12 300.14,16.99 300.53,16.59 301.31,16.59 v2(301.41,16.69) ; QTH3.3 98.03,73.18 RTH6.2 98.1,74.11 96.91,74.11 v2(96.67,73.87)
  IN1 w0.097: v2(276.5,15.93) 275.64,16.78 269.83,16.78 268.95,17.67 264.93,17.67 257.2,25.39 254.18,25.39 253.03,26.54 250.09,26.54 249.23,27.4 246.05,27.4 245.26,26.62 240.81,26.62 238.65,28.78 172.2,28.78 171.74,29.24 142.63,29.24 141.45,30.42 120.44,30.42 119.44,29.43 108.37,29.43 106.89,30.91 82.72,30.91 v2(81.61,32.02)
  IN2 w0.097: v2(276.5,15.93) 276.14,16.29 276.14,17.36 275.88,17.62 275.88,24.09 274.42,25.56 274.42,27.65 273.99,28.09 273.99,30.26 275.18,31.45 275.18,32.72 275.76,33.3 276.21,33.3 276.59,32.92 v2(276.65,32.92) ; v2(81.61,32.02) 81.78,32.02 84.06,34.31 87.06,34.31 90.62,37.87 90.62,38.05 90.62,63.08 91.35,63.81 91.35,68.18 94.31,71.14 94.31,73.57 94.6,73.87 v2(96.67,73.87)
  IN3 w0.124: v2(276.65,32.92) 275.68,33.88 273.04,33.88 271.65,35.27 270.97,35.27 270.44,35.79 270.44,41.02 270.77,41.35 270.77,44.9 270.44,45.23 270.44,51.82 269.63,52.64 269.63,58.65 264.65,63.63 237.05,63.63 235.72,62.3 235.38,62.3 234.24,63.44 229.82,63.44 229.68,63.58 228.71,63.58 226.86,65.43 223.14,65.43 222.49,64.78 220.83,64.78 219.03,66.58 217.96,66.58 214.95,69.59 213.42,69.59 210.19,72.81 206.95,72.81 206.4,72.26 205.04,72.26 204.7,72.61 202.91,72.61 202.56,72.26 200.23,72.26 199.81,71.85 v2(199.75,71.85) ; v2(276.5,15.93) 279.5,12.93 285.83,12.93 286.49,13.59 286.93,13.59 287.25,13.92 288.29,13.92 288.98,14.61 293.68,14.61 294.37,13.92 298.64,13.92 v2(301.41,16.69)
  BOTTOM w0.076: v2(276.65,32.92) 276.75,33.02 UH2.AW42
  BOTTOM w0.14: v2(199.75,71.85) 199.9,72 QG6.3 ; v2(301.41,16.69) 300.77,16.05 RE46.1
GPU_THM_SMBDAT: length 417.4
  TOP w0.14: UE1.11 300.52,17.39 v2(300.88,17.03) ; v1(93.66,75.06) 93.66,74.89 v2(93.97,74.59) RTH5.2 95.61,74.59 QTH3.6
  IN1 w0.097: v2(275.49,15.92) 274.84,16.56 269.73,16.56 268.85,17.44 264.83,17.44 257.11,25.16 254.09,25.16 252.93,26.32 249.99,26.32 249.13,27.18 246.14,27.18 245.36,26.4 240.72,26.4 238.56,28.56 172.11,28.56 171.65,29.01 163.4,29.01 162.58,28.2 143.35,28.2 141.36,30.2 120.53,30.2 119.51,29.17 108.31,29.17 106.83,30.65 82.14,30.65 81.18,31.61 v2(81.18,32.45)
  IN2 w0.097: v2(93.97,74.59) 93.97,71.21 91.13,68.37 91.13,63.9 90.4,63.18 90.4,37.96 87.47,35.03 87.47,35.03 86.96,34.53 83.96,34.53 82.16,32.73 81.46,32.73 v2(81.18,32.45) ; v2(274.55,33.21) 274.64,33.21 274.95,32.9 274.95,31.55 273.76,30.35 273.76,27.99 274.2,27.56 274.2,25.46 275.66,24 275.66,17.53 275.91,17.27 275.91,16.34 v2(275.49,15.92)
  IN3 w0.124: v2(275.49,15.92) 275.92,16.35 276.68,16.35 279.85,13.18 285.73,13.18 286.38,13.84 286.82,13.84 287.15,14.17 288.19,14.17 288.88,14.86 293.78,14.86 294.47,14.17 298.53,14.17 300.88,16.51 v2(300.88,17.03) ; v2(274.55,33.21) 274.13,33.63 272.93,33.63 271.55,35.02 270.87,35.02 270.19,35.69 270.19,43.89 269.75,44.33 269.75,44.99 270.19,45.43 270.19,51.71 269.37,52.53 269.37,58.55 264.54,63.38 237.2,63.38 235.86,62.05 235.27,62.05 234.13,63.19 229.72,63.19 229.57,63.33 228.61,63.33 226.76,65.18 223.24,65.18 222.59,64.53 220.72,64.53 218.92,66.33 217.86,66.33 214.85,69.34 213.31,69.34 212.07,70.58 210.76,70.58 208.79,72.55 207.04,72.55 206.5,72.01 204.94,72.01 204.6,72.36 203.01,72.36 202.67,72.01 202.33,72.01 201.22,70.91 198.72,70.91 198.41,71.21 v2(198.41,71.25)
  BOTTOM w0.076: UH2.AW45 274.67,33.33 v2(274.55,33.21)
  BOTTOM w0.14: QG6.6 198.6,71.06 v2(198.41,71.25) ; v2(300.88,17.03) 300.84,17.07 RE45.1
GPU_VID: length 3.4
  TOP w0.203: PR6069.2 161.96,133.95 161.29,134.62 160.64,134.62 v1(160.54,134.52) 160.4,134.52 159.74,135.18 PU6000.39
H_CATERR#: length 5.9
  TOP w0.14: v2(142.65,99.95) 142.11,100.49 139.49,100.49 v4(139.42,100.42) 138.44,99.44 RH144.2
  BOTTOM w0.114: UH1.BM30 142.33,99.6 142.65,99.92 v2(142.65,99.95)
H_CPUPWRGD: length 264.6
  TOP w0.14: v4(299.62,35.73) 299.25,36.1 v2(298.92,36.1)
  IN4 w0.137: v2(298.92,36.1) 299.09,36.27 299.1,36.27 299.35,36.52 299.35,36.87 298.43,37.79 298.43,38.11 298.43,38.11 298.43,38.19 298.17,38.45 297.09,38.45 296.77,38.13 295.42,38.13 294.18,39.36 292.69,39.36 292.15,39.89 290.81,39.89 290.38,39.47 282.57,39.47 281.33,40.71 281.33,42.41 280.4,43.34 279.66,43.34 279.09,43.91 278.72,43.91 278.53,44.1 277.17,44.1 276.65,44.61 276.65,45.34 275.63,46.37 274.5,46.37 271.96,48.9 271.96,58.33 266.02,64.27 241.7,64.27 236.72,59.29 236.72,58.37 235.68,57.34 235.68,53.31 229.79,47.42 205.23,47.42 204.78,46.98 199.4,46.98 198.83,47.55 186.77,47.55 185.13,49.19 173.23,49.19 167.07,55.35 134.97,55.35 124.12,66.19 124.12,85.25 131.76,92.9 131.76,96.48 131.42,96.82 131.42,100.68 v2(131.74,100.99)
  BOTTOM w0.076: 298.87,36.1 297.92,37.05 295.99,37.05 UH2.AM3
  BOTTOM w0.114: UH1.BT31 138.5,100.36 137.88,100.98
  BOTTOM w0.14: v2(131.74,100.99) 132.06,101.31 137.55,101.31 137.88,100.98 ; 298.87,36.1 v2(298.92,36.1)
H_DRAMRST#: length 112.4
  TOP w0.14: v2(205.31,30.88) v1(205.98,30.88)
  IN1 w0.097: v2(205.31,30.88) 205.9,31.47 225.34,31.47 225.69,31.12 242.12,31.12 243.75,29.5 253.61,29.5 254.47,28.64 256.91,28.64 263.24,22.31 267.5,22.31 271.74,18.06 276.32,18.06 277.06,17.33 280.11,17.33 280.67,16.77 285.01,16.77 285.61,17.36 287.53,17.36 288.91,18.74 290.31,18.74 290.66,18.39 290.66,18.12 v2(290.67,18.11)
  IN2 w0.097: v2(290.67,18.11) 290.15,18.63 289.28,18.63 288.18,19.73 288.18,21.28 289.75,22.85 289.75,24.22 289.27,24.7 v2(289.27,27.84)
  BOTTOM w0.076: 289.88,28.48 289.92,28.51 289.92,29.35 290.21,29.64 290.21,30.44 290.37,30.61 290.37,30.92 290.36,30.93 290.36,31.23 UH2.BC14
  BOTTOM w0.14: v2(205.31,30.88) RD35.2 204.22,30.88 204.22,30.87 RD31.2 203.23,30.87 203.22,30.88 CD69.1 ; 289.88,28.48 289.86,28.46 289.86,28.39 289.31,27.84 v2(289.27,27.84)
H_PECI: length 4.4
  TOP w0.14: UE1.94 315.7,20.59 316.19,20.09 v1(316.4,20.09) 316.84,20.09 317.2,20.45 317.2,21.61 RE17.1
H_PM_DOWN: length 257.1
  TOP w0.14: v2(134.86,101.88) v1(133.86,101.88)
  IN4 w0.137: v2(134.86,101.88) 134.86,101.7 133.58,100.42 133.2,100.42 131.86,99.09 131.86,97.01 132.21,96.66 132.21,92.71 124.56,85.07 124.56,66.53 135.3,55.79 167.25,55.79 173.32,49.72 185.23,49.72 186.96,47.99 199.01,47.99 199.58,47.42 204.6,47.42 205.05,47.87 229.61,47.87 235.24,53.5 235.24,57.52 236.27,58.55 236.27,59.47 241.52,64.71 266.2,64.71 272.18,58.74 272.8,58.12 272.8,54.71 272.41,54.32 272.41,49.09 274.69,46.81 276.64,46.81 276.98,46.47 277.99,46.47 279.48,44.97 279.48,44.77 280.02,44.23 281.58,44.23 282.89,42.92 282.89,40.64 283.18,40.35 287.47,40.35 288.93,41.81 295.39,41.81 296.36,40.85 296.36,40.3 296.88,39.78 297.6,39.78 298.9,38.48 v2(298.9,37.96)
  BOTTOM w0.076: v2(298.9,37.96) 298.44,38.42 296.56,38.42 UH2.AH2
  BOTTOM w0.14: RH155.1 135.01,102.03 v2(134.86,101.88)
H_PM_DOWN_R: length 7.4
  BOTTOM w0.076: 138.79,100.64 140.16,100.64 140.2,100.68 140.68,100.68 UH1.BP31
  BOTTOM w0.114: 138.79,100.64 137.98,101.44
  BOTTOM w0.14: 137.98,101.44 137.39,102.03 RH155.2 135.87,102.56 v1(134.51,102.56)
H_PM_SYNC: length 5.5
  BOTTOM w0.076: UH2.AJ4 295.6,38.26 295.78,38.26 295.8,38.24 296.04,38.24 296.05,38.26 298.27,38.26 298.41,38.12 298.41,37.94 299.72,36.63 RH189.1
H_PM_SYNC_R: length 272.1
  TOP w0.14: v2(300.01,34.83) v1(300.93,34.83)
  IN4 w0.137: v2(141.94,102.33) 141.74,102.14 138.34,102.14 135.87,104.61 131.42,104.61 130.98,104.17 130.98,96.64 131.32,96.3 131.32,93.08 123.68,85.44 123.68,65.94 134.71,54.9 166.89,54.9 173.22,48.57 185.13,48.57 186.59,47.11 198.64,47.11 199.21,46.54 204.97,46.54 205.41,46.98 232.44,46.98 236.32,50.86 236.32,57.35 237.16,58.19 237.16,59.1 237.98,59.92 238.89,59.92 242.8,63.83 265.84,63.83 271.52,58.14 271.52,48.72 274.32,45.92 275.45,45.92 276.07,45.3 276.07,43.58 276.71,42.94 279.05,42.94 279.09,42.9 280.22,42.9 280.77,42.35 280.77,40.5 282.25,39.02 290.16,39.02 290.74,38.45 292.76,38.45 292.91,38.29 294.63,38.29 295.27,37.65 296.01,37.65 296.23,37.43 298.04,37.43 298.5,36.97 298.5,36.31 298.48,36.28 298.48,35.92 298.74,35.66 299.18,35.66 v2(300.01,34.83)
  BOTTOM w0.076: RH189.2 299.72,35.12 v2(300.01,34.83)
  BOTTOM w0.114: v2(141.94,102.33) 142.27,102 UH1.BM34
H_PROCHOT#: length 494.3
  TOP w0.14: v2(319.23,22.84) 319.23,24.98 316.6,27.61 315.56,27.61 CE86.1 314.25,28.04 314,27.79 UE6.4 ; PR24.2 PR25.1 27.73,36.69 v2(28.02,36.4) ; v2(61.44,24.68) v1(62.49,24.68) 64.58,24.68 64.9,25 PQ5.1
  IN1 w0.097: v2(133.24,98.47) 132.2,98.47 130.98,99.7 130.98,101.04 128.48,103.54 128.48,109.29 129.48,110.29 129.48,118.8 131.8,121.12 131.8,122.95 130.11,124.65 130.11,137.4 131.49,138.78 131.49,139.87 v2(134.2,142.58) ; v2(319.23,22.84) 319.23,20.17 311.86,12.8 311.86,11.43 311.25,10.82 308.74,10.82 308.32,11.24 308.32,12.7 306.96,14.06 305.12,14.06 302.89,16.29 300.28,16.29 299.26,17.31 293.51,17.31 292.72,16.52 289.26,16.52 288.65,15.9 277.34,15.9 275.98,17.26 271.41,17.26 267.16,21.5 262.91,21.5 256.58,27.83 250.62,27.83 249.76,28.69 243.41,28.69 241.79,30.32 225.36,30.32 225.01,30.66 206.44,30.66 205.85,30.07 172.81,30.07 171.43,31.46 142.4,31.46 142.15,31.71 119.65,31.71 118.95,31.02 113.25,31.02 112.32,31.94 108.61,31.94 108.4,31.73 108.04,31.73 107.34,32.43 106.67,32.43 106.22,32.87 100.06,32.87 99.47,33.47 v2(97.5,33.47)
  IN2 w0.097: v2(133.24,98.47) 132.62,98.47 130.52,96.37 130.52,94.12 128.69,92.29 128.69,83.4 131.42,80.67 131.42,78.77 130.66,78.01 125.26,78.01 122.05,74.8 122.05,69.47 116.77,64.19 116.77,57.62 100.5,41.34 100.22,41.07 100.22,36.19 v2(97.5,33.47) 97.5,32.9 96.99,32.39 96.99,23.83 95.54,22.38 63.74,22.38 v2(61.44,24.68)
  IN3 w0.124: v2(28.02,36.4) 28.02,36.96 28.3,37.24 29.92,37.24 30.75,36.41 30.75,33.62 30.07,32.95 30.07,30.61 36.31,24.38 61.14,24.38 v2(61.44,24.68)
  BOTTOM w0.14: v2(28.02,36.4) 28.17,36.25 29.34,36.25 30.99,37.9 PR729.1 ; RH158.1 136.27,99.28 135.34,99.28 RH165.2 135.12,99.04 134.55,98.47 v2(133.24,98.47) ; v2(134.2,142.58) PC5000.1 134.2,143.39 134.88,144.07 134.88,144.09 135.17,144.38 PR5000.1
H_PROCHOT#_R: length 4.3
  BOTTOM w0.076: CH211.1 137.41,99.97 RH158.2 137.85,99.06 138.67,99.88 140.04,99.88 UH1.BR30
H_THERMTRIP#: length 8.2
  BOTTOM w0.076: UH2.AJ3 296.25,38.8 296.54,38.8 296.75,38.59 298.67,38.59 v1(298.79,38.71) 298.91,38.83 298.91,39.2 298.98,39.27 299.63,39.27 299.76,39.14 299.76,36.92 299.96,36.72 300.55,36.72 300.62,36.64 RH191.1
H_THERMTRIP#_R: length 196.2
  TOP w0.102: 174.35,100.04 RH163.2
  TOP w0.114: v2(174.93,100.62) 174.35,100.04
  TOP w0.14: v2(301.23,35.91) 301.56,36.24 v1(301.56,36.68)
  IN1 w0.097: v2(301.23,35.91) 299.7,35.91 298.79,34.99 293.12,34.99 292.72,34.6 291.71,34.6 290.77,35.54 289.93,35.54 289.45,36.02 283.55,36.02 282.34,37.23 282.34,43.51 280.27,45.58 280.27,45.92 280.87,46.52 280.87,51.35 280.42,51.81 279.93,51.81 279.4,52.34 279.4,57.04 278.1,58.34 278.1,60.38 276.44,62.04 266.26,62.04 263.79,64.51 228.66,64.51 v2(228.45,64.72)
  IN4 w0.102: 182.29,98.77 181.9,98.77 181.08,99.6 181.08,99.81 180.79,100.1 175.36,100.1 174.93,100.54 v2(174.93,100.62)
  IN4 w0.137: v2(228.45,64.72) 228.45,63.76 225.93,61.24 225.02,61.24 222.19,58.41 222.19,57.5 221.45,56.76 218.88,56.76 217.51,55.38 207.71,55.38 206.71,56.39 203.41,56.39 202.55,57.24 200.44,57.24 199.73,57.96 199.73,57.96 199.1,58.58 197.1,58.58 194.47,61.22 194.47,66.05 195.3,66.88 195.3,68.48 195.16,68.62 194.92,68.86 194.92,70.77 194.57,71.12 194.57,73.42 193.71,74.28 193.71,74.99 193.21,75.5 193.21,76 193.44,76.24 193.44,79.8 189.97,83.28 189.97,94.9 186.09,98.77 182.29,98.77
  BOTTOM w0.076: UH1.J31 175.29,100.26 v2(174.93,100.62) ; 300.78,35.45 300.72,35.4 RH191.2
  BOTTOM w0.14: v2(301.23,35.91) 300.78,35.45
H_VCCST_PWRGD: length 51.5
  TOP w0.14: v2(183.24,82.2) 182.93,82.2 v1(182.7,81.97) 181.83,81.09 RH164.2 RH154.1 CH210.1 179.49,80.93 179.17,80.61 179.17,80.1 179.48,79.8 UC16.4 ; v2(205.08,55.79) 205.08,55.96 204.69,56.35 203.3,56.35 203.05,56.61 RH542.1
  IN4 w0.137: v2(183.24,82.2) 184.13,82.2 189.1,77.22 190.75,77.22 193.19,74.78 193.19,74.07 194.05,73.21 194.05,70.9 194.4,70.56 194.4,68.65 194.78,68.26 194.78,67.11 193.95,66.28 193.95,60.74 195.13,59.56 195.13,58.73 195.8,58.06 198.89,58.06 199.51,57.44 200.23,56.72 202.34,56.72 203.7,55.36 204.66,55.36 v2(205.08,55.79)
HDA_BITCLK: length 6.3
  BOTTOM w0.076: 294.43,28.48 294.43,28.6 293.24,29.78 293.24,30.58 293.14,30.68 293.14,32.13 UH2.BA9
  BOTTOM w0.14: RH572.2 294.43,28.3 294.43,28.48
HDA_BITCLK_AUDIO: length 60.4
  TOP w0.102: HDA1.6 v2(340.46,20.26)
  TOP w0.14: v2(297.37,27.16) 297.36,27.16 296.88,27.64 v1(296.88,27.77)
  IN4 w0.137: v2(297.37,27.16) 297.9,27.16 298.87,26.19 304.94,26.19 306.94,28.19 307.46,28.19 307.99,28.72 307.99,28.98 309.31,30.31 325.34,30.31 326.02,30.99 332.91,30.99 334.28,29.62 v2(334.68,29.62)
  IN5 w0.097: v2(334.68,29.62) 338.18,26.13 338.18,22.55 v2(340.46,20.26)
  BOTTOM w0.14: v2(340.46,20.26) 338.57,18.37 CA66.1 ; v2(297.37,27.16) 297.57,27.16 298.1,26.63 CH50.2 297.13,26.51 RH572.1
HDA_CODEC_SDIN0: length 5.7
  TOP w0.102: 339.21,18.98 339.88,18.98 340.3,19.4 340.97,19.4 341.04,19.46 HDA1.8
  TOP w0.14: 339.21,18.98 338.79,18.98 RA32.2 338.09,18.71 336.69,18.71 v1(336.35,18.37)
HDA_SDIN0_AUDIO: length 59.8
  TOP w0.14: RA32.1 337.36,19.19 v2(336.91,19.65) 336.34,19.65 v1(336.09,19.89)
  IN4 w0.137: v2(333.43,29.86) 332.61,29.04 329.38,29.04 328.64,29.77 311.04,29.77 310.23,28.96 309.23,28.96 307.94,27.67 307.15,27.67 305.15,25.67 298.65,25.67 297.91,26.41 297.28,26.41 296.9,26.79 296.9,27.33 297.31,27.74 v2(297.42,27.74)
  IN5 w0.097: v2(333.43,29.86) 333.62,29.86 337.55,25.92 337.55,20.3 v2(336.91,19.65)
  BOTTOM w0.102: 294.69,28.86 294.08,29.47 294.08,30.01 293.88,30.21 UH2.BE7
  BOTTOM w0.14: 294.69,28.86 295.81,27.74 v2(297.42,27.74)
HDA_SDOUT: length 14.1
  TOP w0.14: v1(298.46,25.61) 298.24,25.83 v2(297.63,25.83) ; v2(293.51,32.37) 293.54,32.34 CH51.2
  IN2 w0.097: v2(293.51,32.37) 293.58,32.37 293.84,32.11 293.84,31.28 294.18,30.94 294.18,28.33 295.48,27.03 296.43,27.03 v2(297.63,25.83)
  BOTTOM w0.089: UH2.BB7 293.8,32.08 v2(293.51,32.37)
  BOTTOM w0.14: RH18.2 299.75,25.96 297.75,25.96 v2(297.63,25.83) 297.91,25.55 RP15.8
HDA_SDOUT_AUDIO: length 56.6
  TOP w0.102: HDA1.5 340.85,20.66 v2(340.46,21.05) 340.46,21.3 v1(340.26,21.5)
  IN4 w0.137: v2(298.02,23.25) 298.06,23.29 305.75,23.29 306.79,24.33 306.79,25.77 309.45,28.43 319.43,28.43 320.24,29.25 328.42,29.25 329.16,28.51 331.73,28.51 v2(331.89,28.35)
  IN5 w0.097: v2(340.46,21.05) 338.74,22.77 338.74,26.55 334.72,30.56 332.51,30.56 331.89,29.94 v2(331.89,28.35)
  BOTTOM w0.14: RP15.1 297.91,23.36 v2(298.02,23.25)
HDA_SYNC: length 7.8
  BOTTOM w0.076: UH2.BD9 292.9,30.69 293.08,30.51 293.08,29.72 294.11,28.69 294.11,28.48
  BOTTOM w0.14: 294.11,28.48 294.11,27.79 296.15,25.75 296.75,25.75 296.91,25.59 RP15.6
HDA_SYNC_AUDIO: length 59.2
  TOP w0.14: v1(340.16,17.33) 340.16,18.01 v2(340.53,18.38) 340.81,18.66 HDA1.10
  IN4 w0.137: v2(332.59,28.41) 332.23,28.77 329.27,28.77 328.53,29.51 311.15,29.51 310.34,28.7 309.34,28.7 306.53,25.88 306.53,24.44 305.8,23.71 297.38,23.71 297.15,23.49 v2(297.15,23.2)
  IN5 w0.097: v2(340.53,18.38) 337.52,18.38 336.46,19.43 336.46,20.92 337.07,21.53 337.07,25.54 334.2,28.41 v2(332.59,28.41)
  BOTTOM w0.14: v2(297.15,23.2) 297.15,23.59 296.91,23.84 RP15.3
HDD_DEVSLP: length 31.7
  IN4 w0.137: v2(265.34,28.92) 265.66,28.92 266.36,29.62 266.36,36.16 267.1,36.9 272.21,36.9 v2(273.47,38.16)
  BOTTOM w0.076: 274.23,38.16 274.79,38.16 275.5,38.86 275.5,38.95 275.63,39.09 275.71,39.09 UH2.AG43
  BOTTOM w0.14: v2(265.34,28.92) 264.6,28.18 261.7,28.18 261.15,28.73 v1(260.41,28.73) 259.69,28.73 259.54,28.58 255.04,28.58 254.29,27.83 RD62.1 ; 274.23,38.16 v2(273.47,38.16)
HDD_DEVSLP_R: length 12.8
  BOTTOM w0.14: RD62.2 253.49,26.14 252.2,27.44 v2(252.2,28.77) 252.2,29.06 251.37,29.89 250.81,29.89 250.81,29.89 247.64,29.89 246.85,29.1 245.37,29.1 245.1,28.83 JHDD1.8
HDMI_CEC: length 69.9
  TOP w0.14: v2(344.9,55.33) 344.9,53.87 343.89,52.86 v1(343.89,52.17) 343.89,51.17 343.17,50.45 342.76,50.45 RP11.2
  IN1 w0.097: v2(344.9,55.33) 345.33,55.76 345.33,56.9 344.84,57.38 344.84,58.93 345.33,59.42 347.09,59.42 347.95,60.28 349.98,60.28 353.07,63.37 353.07,64.52 353.96,65.41 356.98,65.41 359.1,67.52 359.1,72.73 358.45,73.38 358.45,73.97 358.83,74.34 359.54,74.34 363.82,78.62 366.13,78.62 369.1,81.59 369.1,86.07 371.07,88.04 371.07,90.58 371.59,91.1 JHDMI1.13
  BOTTOM w0.14: JHDMI1.13 370.94,91.96 370.94,96.93 370.67,97.2 367.72,97.2 CV601.2
HDMI_HPD: length 78.7
  TOP w0.14: RP46.2 CP47.1 331.7,49.18 331.42,48.9 v2(331.42,48.61) ; UP2.21 v2(333.05,49.09)
  IN1 w0.097: JHDMI1.19 371.41,88.1 369.5,86.19 v2(369.5,83.47) 369.5,81.71 366.21,78.42 363.9,78.42 359.63,74.15 358.91,74.15 358.65,73.89 358.65,73.46 359.3,72.81 359.3,67.6 359.3,67.44 357.07,65.21 354.05,65.21 353.27,64.44 353.27,63.23 349.99,59.95 348.16,59.95 347.1,58.89 347.1,55.21 344.53,52.64 344.53,48.41 343.21,47.08 337.29,47.08 336.59,47.78 332.24,47.78 v2(331.42,48.61) 331.9,49.09 v2(333.05,49.09)
  BOTTOM w0.14: v2(369.5,83.47) 368.93,82.9 v1(368.68,82.9) CV599.2
HDMI_HPD_PCH: length 103.6
  TOP w0.14: v2(274.06,34.33) 273.79,34.06 273.32,34.06 273.08,34.31 273.08,34.98 272.91,35.14 271.12,35.14 268.51,37.75 268.51,47.21 270.12,48.82 270.12,53.9 v1(271.81,55.58) 272.21,55.98 275.18,55.98 v2(275.75,56.56) ; v2(317.76,49.03) 317.74,49.04 317.74,50.92 321.07,54.24 322.99,54.24 324.78,56.04 330.62,56.04 332.79,58.21 QP1.3
  IN3 w0.124: v2(317.76,49.03) 317.33,48.61 315.72,48.61 313.9,50.43 312.6,50.43 310.36,52.67 306.6,52.67 305.23,54.04 297.2,54.04 292.69,58.55 277.75,58.55 v2(275.75,56.56)
  BOTTOM w0.076: UH2.AT44 275.46,34.7 274.42,34.7 274.23,34.51 274.23,34.51
  BOTTOM w0.14: RH567.2 273.22,34.13 273.85,34.13 v2(274.06,34.33) 274.23,34.51
HDMI_RESERVED: length 4.9
  BOTTOM w0.14: JHDMI1.14 368.09,90.6 CV600.2 v1(367.2,92.94)
HOST_DEBUG_TX: length 79.8
  TOP w0.14: v2(316.13,15.36) 316.1,15.39 UE1.81 ; RN8.1 342.75,40.03 v2(343.19,40.48) 342.75,40.92 RN5.1
  IN1 w0.097: v2(320.27,12.98) 319.8,12.98 318.09,14.7 316.74,14.7 316.13,15.31 v2(316.13,15.36) ; v2(343.19,40.48) 342.49,41.18 341.1,41.18 340.59,41.68 333,41.68 330.8,43.88 330.8,44.9 328.08,47.62 326.13,47.62 323.58,50.16 v2(323.18,50.16)
  BOTTOM w0.14: JDEG1.8 321.75,7.39 v1(320.58,8.56) 320.02,9.12 RE64.2 320.5,11.93 320.5,12.75 v2(320.27,12.98) ; v2(323.18,50.16) 321.24,48.22 321.24,42.44 318.54,39.74 318.54,34.42 319.75,33.21 319.75,30.84 319.47,30.56 319.47,28.64 320.87,27.24 320.87,22.51 320.53,22.17 320.53,21.19 318.66,19.32 318.66,17.88 v2(316.13,15.36)
HPD_IFPC: length 34.6
  TOP w0.14: v1(203.16,58.92) v2(202.65,59.44) 202.65,59.44 202.09,59.99 QG9.1 202.09,61.65 RG572.1
  IN4 w0.089: v2(208.05,81.45) 206.92,80.32 206.92,78.79 207.52,78.19 207.58,78.19
  IN4 w0.137: v2(202.65,59.44) 202.86,59.44 204.14,58.15 206.91,58.15 207.57,58.81 207.57,60.12 209.23,61.78 209.23,66.3 208.85,66.68 208.85,73.16 208.14,73.86 208.14,77.63 207.58,78.19
  BOTTOM w0.114: UG9.BA4 v2(208.05,81.45)
HW_ACAV_IN: length 2.7
  TOP w0.14: v2(299.82,22.85) 299.98,23.01 UE1.128
  BOTTOM w0.14: RE138.2 300.31,23.35 v2(299.82,22.85) 299.43,22.85 v1(299.2,23.08)
I2C1_SCK_TP: length 135.4
  TOP w0.14: v2(277.47,34.8) 277.12,34.45 275.44,34.45 v1(275.26,34.62) 275.06,34.83 275.06,35.4 274.85,35.6 273.98,35.6 273.64,35.94 273.01,35.94 RH119.2
  IN5 w0.097: v2(160.71,21.57) 161.07,21.57 161.16,21.67 161.16,22.12 161.56,22.51 230.23,22.51 232.59,24.87 237,24.87 239.17,22.71 251.94,22.71 252.31,23.08 261.72,23.08 262.46,22.34 265.22,22.34 266.03,23.15 267.49,24.61 267.49,28.33 270.45,31.29 270.45,31.81 273.13,34.49 273.13,34.75 273.37,34.99 273.94,34.99 274.23,34.7 274.49,34.7 274.49,34.7 274.83,34.7 274.83,34.7 277.37,34.7 v2(277.47,34.8)
  BOTTOM w0.076: v2(277.47,34.8) 277.43,34.8 UH2.AR41
  BOTTOM w0.14: v2(160.71,21.57) 160.07,22.2 QE19.4
I2C1_SCK_TP_C: length 22.3
  BOTTOM w0.14: JTP.6 144.45,28.27 145.01,27.71 153.82,27.71 153.96,27.57 153.96,26.51 154.47,26 157.12,26 157.39,25.73 DE4.1 ; DE4.1 157.39,24.37 157.28,24.26 CE105.1 157.28,22.98 RE9.1 ; DE4.1 158.29,25.13 158.71,25.56 v1(159.08,25.56) 159.64,25.56 160.07,25.12 QE19.3
I2C1_SDA_TP: length 132.2
  IN5 w0.097: v2(273.53,34.59) 273.36,34.59 273.35,34.58 273.35,34.39 270.68,31.72 270.68,31.19 267.72,28.23 267.72,24.52 266.02,22.82 266.02,22.82 265.31,22.12 262.37,22.12 261.63,22.86 252.41,22.86 252.03,22.48 239.08,22.48 236.91,24.65 232.69,24.65 230.32,22.28 161.65,22.28 161.39,22.02 161.39,21.69 161.52,21.55 v2(161.71,21.55)
  BOTTOM w0.076: 274.23,35.46 274.33,35.56 274.7,35.56 275.05,35.21 275.27,35.21 275.52,35.46 UH2.AR44
  BOTTOM w0.14: QE19.1 158.77,23.54 159.04,23.27 159.68,23.27 159.81,23.14 160.69,23.14 v1(161.33,22.51) 161.71,22.13 v2(161.71,21.55) ; 274.23,35.46 274.03,35.26 274.03,35.08 v2(273.53,34.59) 273.31,34.81 273.31,34.97 RH120.2
I2C1_SDA_TP_C: length 29.9
  BOTTOM w0.14: CE80.1 155.49,21.75 155.89,21.35 158.34,21.35 v1(158.46,21.47) 158.77,21.78 QE19.6 ; CE80.1 156.35,22.94 RE7.1 ; CE80.1 154.29,22.94 154.09,23.14 154.09,24.09 154.47,24.48 155.23,24.48 155.49,24.73 DE4.3 154.49,25.13 152.4,23.04 144.12,23.04 143.45,23.71 JTP.7
I2C_EN8713: length 2
  BOTTOM w0.14: UI3.24 v1(10.69,52.5) 10.69,53.4 RI25.2
I2CC_SCL: length 22.4
  IN2 w0.097: v2(222.84,74.57) 222.47,74.95 222.04,74.95 221.46,74.38 221.46,73.05 220.88,72.47 211.74,72.47 210.71,71.44 207.99,71.44 v2(207.56,71.87)
  BOTTOM w0.127: v2(207.56,71.87) v1(206.49,71.87)
  BOTTOM w0.14: RG60.2 v2(222.84,74.57) 222.93,74.57 223.51,73.99 UG11.6 ; QG7.3 208.5,70.93 v2(207.56,71.87)
I2CC_SCL_R: length 17.3
  IN1 w0.097: v2(208.57,74.17) 208.57,74.17 208.57,74.2 208.32,74.45 208.32,77.31 207.72,77.9 207.72,80.04 207.13,80.64 207.13,83.77 205.78,85.12 203.68,85.12 v2(203.15,85.65)
  BOTTOM w0.089: UG9.BG9 v2(203.15,85.65)
  BOTTOM w0.14: QG7.4 208.5,73.48 RG167.2 208.42,74.03 208.56,74.17 v2(208.57,74.17)
I2CC_SDA: length 17.9
  IN2 w0.097: v2(222.84,75.46) 222.53,75.15 221.95,75.15 221.27,74.46 221.27,73.14 220.8,72.67 211.05,72.67 v2(210.22,71.85)
  BOTTOM w0.14: v2(210.22,71.85) 209.8,72.27 QG7.6 ; UG11.7 223.37,74.64 223.11,74.9 223.11,75.19 v2(222.84,75.46) 222.84,75.46 RG61.2
I2CC_SDA_R: length 22.4
  IN4 w0.089: 206.62,78.19 206.62,78.24 205.62,79.25 205.62,81.6 205.08,82.13 205.08,84.23 204.32,84.99 203.18,84.99 v2(202.55,85.63)
  IN4 w0.137: v2(208.36,69.89) 208.36,72.38 206.82,73.92 206.82,78 206.62,78.19
  BOTTOM w0.114: UG9.BH9 202.85,85.33 v2(202.55,85.63)
  BOTTOM w0.14: QG7.1 209.8,70.28 209.42,69.89 v2(208.36,69.89) 208.36,70 207.85,70.51 RG159.2
I_ADP: length 6.8
  TOP w0.14: v1(308.9,25.1) 308.9,24.97 v2(308.14,24.21) 308,24.07 UE1.110
  BOTTOM w0.14: CE87.1 RE36.1 308.41,26.85 308.9,26.36 308.9,24.99 308.14,24.22 v2(308.14,24.21)
I_ADP_R: length 322
  TOP w0.127: v1(25.5,35.08) 26.18,35.08 PR27.1
  TOP w0.254: PR27.1 27.1,34.16 v2(27.73,34.16) ; PR721.1 29.62,42.66 v2(29.06,43.22)
  IN3 w0.124: v2(27.73,34.16) 28.69,33.2 28.69,30.43 36.89,22.23 85.93,22.23 88.66,24.96 117.35,24.96 118.21,25.82 129.3,25.82 130.48,24.64 136.51,24.64 136.92,25.04 162.08,25.04 162.4,25.36 208.58,25.36 209.3,24.64 223.92,24.64 224.97,25.69 237.24,25.69 238.86,24.07 254.5,24.07 264.44,14.12 269.74,14.12 272.98,10.88 275.56,10.88 276.55,9.89 291.05,9.89 291.42,10.26 291.42,10.96 292.1,11.64 299.88,11.64 300.49,12.25 301.48,12.25 306.44,17.21 306.44,24.24 307.42,25.23 v2(308.14,25.23)
  IN4 w0.254: v2(29.06,43.22) 29.61,42.67 29.61,36.53 27.53,34.46 27.53,34.36 v2(27.73,34.16)
  BOTTOM w0.14: v2(308.14,25.23) 308.09,25.27 RE36.2
I_BATT: length 4.7
  TOP w0.14: UE1.114 306.4,24.67 v1(306.3,24.77) 306.3,25.68 RE147.1 305.66,25.56 v2(305.66,25.24)
  BOTTOM w0.14: v2(305.66,25.24) 305.98,25.56 CE107.1
I_BATT_CHG: length 3.7
  TOP w0.203: PU700.8 32.12,39.67 31.55,40.24 v2(31.33,40.24) 30.96,40.6 PC725.2
  BOTTOM w0.14: v1(30.91,39.93) 31.22,40.24 v2(31.33,40.24)
  BOTTOM w0.203: v2(31.33,40.24) 31.64,40.55 PR727.2
I_BATT_R: length 316.3
  TOP w0.14: RE147.2 306.05,27.46 v2(305.78,27.73) 305.28,27.73 v1(305.06,27.96)
  IN1 w0.097: v2(29.66,34.39) 30.65,35.38 30.65,39.3 31,39.65 v2(31.36,39.65)
  IN3 w0.124: v2(29.66,34.39) 29.02,33.76 29.02,30.42 36.99,22.46 85.65,22.46 88.38,25.18 117.25,25.18 118.17,26.1 135.45,26.1 136.55,25 136.82,25.27 161.98,25.27 162.3,25.59 208.67,25.59 209.35,24.91 223.87,24.91 224.91,25.95 237.41,25.95 239.07,24.29 254.65,24.29 264.6,14.35 269.84,14.35 271.69,12.5 272.68,12.5 273.55,11.62 285.37,11.62 286.8,10.19 287.9,10.19 289.13,11.42 291.56,11.42 292,11.87 298.94,11.87 300.28,13.21 301.65,13.21 302.06,13.62 306.21,17.77 306.21,24.39 306.54,24.72 306.54,26.96 v2(305.78,27.73)
  BOTTOM w0.203: PR727.1 31.37,39.64 v2(31.36,39.65)
IADP_CHG: length 5.6
  TOP w0.14: 30.53,42.32 PR721.2 v1(30.53,43.65)
  TOP w0.203: PU700.7 33.34,40.85 33.21,40.97 32.49,40.97 32.03,41.43 30.53,41.43
  TOP w0.254: 30.53,41.43 PC723.2 30.53,42.32
ICSP_CLK: length 23.5
  TOP w0.14: UE1.101 311.6,24.28 312.09,24.77 312.73,24.77 v1(312.96,24.53) 313.56,23.94 v2(314.67,23.94)
  IN4 w0.137: v2(314.67,23.94) 314.67,22.67 318.32,19.02 318.32,16.27 v2(319.22,15.37)
  BOTTOM w0.14: v2(319.22,15.37) 320.46,14.13 324.48,14.13 325.92,12.69 RE109.1
ICSP_CLR: length 15.1
  TOP w0.14: UE1.87 316.01,17.79 v2(316.13,17.67)
  BOTTOM w0.14: v2(316.13,17.67) 315.39,16.93 v1(315.39,16.16) 315.39,15.45 316.15,14.68 316.71,14.68 317.58,13.82 324.19,13.82 324.91,13.11 RE110.1
ICSP_DAT: length 19.5
  TOP w0.14: v2(311.54,21.75) 311.2,22.09 UE1.102
  BOTTOM w0.14: RE112.1 322.94,12.66 322.09,13.52 316.19,13.52 314.72,14.99 314.72,17.45 v1(314.19,17.99) 313.39,18.78 313.39,20.19 312.84,20.74 312.84,21.29 312.38,21.75 v2(311.54,21.75)
IFPAB_PLLVDD: length 0.5
  BOTTOM w0.089: UG9.BD21 205.65,93.68 v2(205.98,94)
IFPC_CLK_CN: length 5.7
  TOP w0.112: CP15.2 340.27,40.49 340.27,40.86 339.89,41.24 v3(338.27,41.24) 337.83,41.24 337.57,41.51 336.29,41.51 336.19,41.61 336.19,41.72 336.25,41.77 UP2.48
IFPC_CLK_CP: length 5.7
  TOP w0.112: UP2.47 335.85,41.79 335.91,41.73 335.91,41.48 336.16,41.22 v3(336.79,41.22) 337.45,41.22 337.72,40.96 339.77,40.96 339.89,40.84 339.89,40.49 CP16.2
IFPC_CLK_N: length 181.2
  TOP w0.112: v2(340.37,38.65) 340.27,38.75 340.27,39.07 CP15.1
  IN1 w0.089: v2(204.55,90.55) 204.72,90.55 204.88,90.71 204.88,90.84 204.69,91.04 202.55,91.04 202.22,90.71 201.59,90.71 200.78,89.9 200.78,83.05 200.05,82.32 200.05,81.62 199.18,80.74 199.18,76.21 200.32,75.07 200.32,73.75 201.61,72.46 204.66,72.46 206.15,70.96 209.86,70.96 210.06,70.77 216.76,70.77 217.36,71.36 223.58,71.36 224.29,72.08 248.67,72.08 249.58,71.16 267.2,71.16 269.81,68.55 273.71,68.55 274.54,69.38 281.68,69.38 287.77,63.28 288.51,63.28 293.01,58.78 299.96,58.78 302.48,56.26 305.27,56.26 306.8,54.73 318.07,54.73 329.34,43.47 330.36,43.47 333.54,40.29 339.76,40.29 340.05,40 340.05,39.75 340.14,39.66 340.3,39.66 340.39,39.57 340.39,39.45 340.3,39.36 340.11,39.36 340.05,39.3 340.05,38.95 340.36,38.65 v2(340.37,38.65)
  BOTTOM w0.089: UG9.BF17 v2(204.55,90.55)
IFPC_CLK_P: length 181.2
  TOP w0.112: CP16.1 339.89,39.07 339.89,38.75 v2(339.79,38.65)
  IN1 w0.089: v2(205.25,90.55) 205.14,90.66 205.14,90.96 204.89,91.21 202.36,91.21 202.12,90.97 201.48,90.97 200.52,90.01 200.52,83.15 199.79,82.42 199.79,81.72 198.92,80.85 198.92,76.11 200.06,74.96 200.06,73.65 201.51,72.2 204.55,72.2 206.05,70.7 209.76,70.7 209.95,70.51 216.87,70.51 217.46,71.1 223.68,71.1 224.4,71.82 248.56,71.82 249.47,70.9 267.09,70.9 269.7,68.29 273.82,68.29 274.65,69.12 281.57,69.12 287.67,63.03 288.4,63.03 292.91,58.52 299.86,58.52 302.38,56 305.17,56 306.69,54.47 317.97,54.47 329.23,43.21 330.26,43.21 333.43,40.03 339.66,40.03 339.79,39.9 v2(339.79,38.65)
  BOTTOM w0.089: UG9.BE17 v2(205.25,90.55)
IFPC_I2C_8409_CLK: length 180.2
  TOP w0.112: v2(190.74,60.3) 190.89,60.45 191.65,60.45 192.54,61.34 192.98,61.34 193.71,62.06 RP9.2 ; UP2.34 330.14,43.84 v2(330.11,43.87)
  IN1 w0.089: v2(240.89,68.99) 240.73,68.83 240.73,68.64 240.83,68.55 266.11,68.55 268.73,65.94 279.02,65.94 280.97,63.99 282.79,63.99 288.65,58.12 289.97,58.12 291.99,56.1 298.59,56.1 301.04,53.65 304.19,53.65 307.7,50.13 317.78,50.13 320.98,46.93 320.98,46.62 325.42,42.19 325.42,41.04 326.9,39.56 328.34,39.56 v2(328.5,39.72)
  IN2 w0.089: v2(190.74,60.3) 191.07,60.62 191.85,60.62 192.15,60.33 197.04,60.33 197.39,59.98 206.9,59.98 207.03,59.85 207.03,57.84 208.71,56.16 217.08,56.16 219.26,58.34 220.44,58.34 220.85,57.94 221.98,57.94 222.44,57.47 226.95,57.47 227.21,57.73 229.2,57.73 229.46,57.48 231.22,57.48 234.66,60.92 238.3,60.92 238.58,60.63 238.58,60.51 238.59,60.5 v2(238.59,60.44)
  BOTTOM w0.112: RP25.1 330.11,42.42 329.81,42.73 329.81,43.56 v2(330.11,43.87) 330.22,43.97 330.81,43.97 331.13,43.65 331.13,40.86 329.84,39.57 328.65,39.57 v2(328.5,39.72) ; v2(238.59,60.44) 238.83,60.44 239.02,60.26 240.1,60.26 240.76,60.92 240.76,68.86 v2(240.89,68.99)
IFPC_I2C_8409_DAT: length 182.3
  TOP w0.112: v2(329.52,43.94) 329.87,44.29 330.37,44.29 330.41,44.24 UP2.33 ; RP10.2 193.39,62.15 192.87,61.62 192.42,61.62 191.53,60.73 190.89,60.73 v2(190.74,60.88)
  IN1 w0.089: v2(328.5,39.13) 328.33,39.3 326.8,39.3 325.16,40.94 325.16,42.08 320.72,46.52 320.72,46.82 317.67,49.87 307.6,49.87 304.08,53.39 300.94,53.39 298.48,55.84 291.89,55.84 289.87,57.86 288.55,57.86 282.68,63.73 280.86,63.73 278.91,65.68 268.62,65.68 266.01,68.29 240.72,68.29 240.47,68.54 240.47,68.83 v2(240.31,68.99)
  IN2 w0.089: v2(239.03,60.89) 238.7,60.89 238.4,61.18 234.55,61.18 231.11,57.74 229.56,57.74 229.31,57.99 227.1,57.99 226.84,57.73 222.55,57.73 222.08,58.19 220.96,58.19 220.55,58.6 219.15,58.6 216.97,56.42 208.81,56.42 207.29,57.94 207.29,59.96 207.01,60.24 197.5,60.24 197.15,60.58 192.25,60.58 191.96,60.88 v2(190.74,60.88)
  BOTTOM w0.112: RP24.1 329.22,42.42 329.52,42.72 v2(329.52,43.94) 329.87,44.29 330.9,44.29 331.41,43.77 331.41,40.74 329.96,39.28 328.65,39.28 v2(328.5,39.13) ; v2(239.03,60.89) 239.03,60.65 239.13,60.54 239.98,60.54 240.48,61.04 240.48,68.82 v2(240.31,68.99)
IFPC_I2C_CLK: length 49.7
  TOP w0.112: RG571.2 191.76,62.03 QG8.4 190.25,61.23 190.12,61.32 190.09,61.45 190.09,61.54 189.6,62.03 189.26,62.03 188.95,62.34 188.95,66.39 189.12,66.55 191.36,66.55 194.02,69.21 195.17,69.21 v2(195.34,69.04)
  IN1 w0.089: v2(195.34,69.04) 195.5,69.2 195.94,69.2 196.37,69.63 196.37,70.84 196.13,71.08 196.13,72.16 195.72,72.57 195.72,72.9 196.15,73.33 196.15,78.73 192.64,82.24 192.64,85.79 192.64,85.9 193.32,86.58 195.39,86.58 196.38,85.59 196.38,85.52 197.12,84.78 197.67,84.78 198.1,85.21 198.1,86.45 197.58,86.96 196.93,86.96 v2(196.83,87.07)
  BOTTOM w0.112: 200.02,86.09 200,86.11 200,86.11 199.96,86.15 199.88,86.15 199.79,86.15 199.79,86.15 199.2,86.15 199.18,86.16 198.92,86.16 198.57,86.52 197.99,86.52 197.61,86.9 197,86.9 v2(196.83,87.07)
  BOTTOM w0.114: 200.02,86.09 200.51,85.6 201.1,85.6 UG9.BK9
IFPC_I2C_CLK_R: length 9.1
  TOP w0.112: QG8.3 190.31,59.53 191.39,59.53 192.47,60.61 193.59,60.61 v1(193.75,60.77) 194.67,61.69 RP9.1 194.67,63.34 194.81,63.48 194.81,64.36 RG578.1
IFPC_I2C_DAT: length 48.7
  TOP w0.112: v2(195.34,69.62) 195.21,69.5 193.9,69.5 191.24,66.84 189,66.84 188.67,66.5 188.67,62.23 189.14,61.75 189.48,61.75 189.81,61.42 189.84,61.27 189.75,61.14 QG8.1 188.19,60.29 RG156.2
  IN1 w0.089: v2(196.83,86.48) 197.05,86.71 197.47,86.71 197.84,86.34 197.84,85.31 197.56,85.04 197.23,85.04 196.64,85.63 196.64,85.7 195.5,86.84 193.43,86.84 193.21,86.84 192.38,86.01 192.38,85.69 192.38,82.13 195.89,78.62 195.89,73.44 195.46,73.01 195.46,72.46 195.87,72.06 195.87,70.97 196.11,70.73 196.11,69.73 195.84,69.46 195.5,69.46 v2(195.34,69.62)
  BOTTOM w0.112: 199.88,85.94 199.88,85.95 199.3,85.95 199.24,85.88 198.8,85.88 198.45,86.23 197.87,86.23 197.49,86.61 196.95,86.61 v2(196.83,86.48)
  BOTTOM w0.114: 199.88,85.94 200.46,85.36 200.64,85.36 UG9.BL9
IFPC_I2C_DAT_R: length 6.5
  TOP w0.102: 192.13,63.31 191,63.31 190.93,63.25 190.51,63.25
  TOP w0.112: QG8.6 190.21,63.05 v1(190.41,63.25) 190.51,63.25 ; RG577.1 194.22,64.25 194.52,63.95 194.52,63.6 194.27,63.34 RP10.1 194.01,63.31 192.13,63.31
IFPC_TX0_CN: length 4.4
  TOP w0.112: CP21.2 335.34,38.43 335.34,40.73 334.99,41.08 334.99,41.54 335.05,41.6 UP2.45
IFPC_TX0_CP: length 4.4
  TOP w0.112: UP2.44 334.65,41.6 334.71,41.54 334.71,40.96 335.06,40.61 335.06,38.33 CP22.2
IFPC_TX0_N: length 179.2
  TOP w0.112: v2(335.38,36.48) 335.32,36.54 335.32,36.78 CP21.1
  IN1 w0.089: v2(335.38,36.48) 335.52,36.61 335.52,36.78 335.42,36.88 335.28,36.88 335.21,36.88 335.12,36.97 335.12,38.96 334.56,39.53 333.38,39.53 330.09,42.81 329.04,42.81 318.76,53.1 307.51,53.1 305,55.6 302.21,55.6 299.76,58.06 292.81,58.06 288.24,62.63 287.5,62.63 281.58,68.55 275.42,68.55 274.77,67.9 269.54,67.9 266.93,70.51 249.31,70.51 248.4,71.42 226.52,71.42 224.95,69.85 216.56,69.85 216.12,69.41 204.07,69.41 202.78,70.7 202.43,70.7 198.11,75.02 198.11,80.6 199.4,81.89 199.4,82.59 200.13,83.32 200.13,90.59 200.96,91.43 201.99,91.43 202.29,91.72 202.86,91.72 203.1,91.49 203.59,91.49 v2(203.95,91.85)
  BOTTOM w0.089: UG9.BF18 v2(203.95,91.85)
IFPC_TX0_P: length 179.2
  TOP w0.112: v2(334.8,36.48) 335.03,36.71 335.03,36.94 CP22.1
  IN1 w0.089: v2(203.25,91.85) 203.28,91.85 203.43,92.01 203.43,92.13 203.29,92.28 203.16,92.28 202.78,91.9 202.1,91.9 201.89,91.69 200.86,91.69 199.87,90.7 199.87,83.42 199.14,82.69 199.14,81.99 197.85,80.71 197.85,74.91 202.33,70.44 202.68,70.44 203.96,69.15 216.23,69.15 216.67,69.6 225.05,69.6 226.62,71.16 248.29,71.16 249.2,70.25 266.82,70.25 269.43,67.64 274.88,67.64 275.53,68.29 281.48,68.29 287.4,62.37 288.13,62.37 292.7,57.8 299.65,57.8 302.11,55.35 304.9,55.35 307.41,52.84 318.65,52.84 328.93,42.55 329.99,42.55 333.27,39.27 334.45,39.27 334.86,38.85 334.86,36.86 334.96,36.76 334.96,36.64 334.8,36.48 v2(334.8,36.48)
  BOTTOM w0.089: UG9.BG18 v2(203.25,91.85)
IFPC_TX1_CN: length 4.7
  TOP w0.112: CP20.2 333.09,38.39 333.09,40.64 333.28,40.83 333.45,40.83 333.85,41.23 UP2.42
IFPC_TX1_CP: length 4.8
  TOP w0.112: UP2.41 333.45,41.78 333.64,41.59 333.64,41.32 333.36,41.04 333.19,41.04 332.81,40.66 332.81,38.37 CP19.2
IFPC_TX1_N: length 182.1
  TOP w0.112: CP20.1 333.1,36.86 333.1,36.59 v2(333.21,36.48)
  IN1 w0.089: v2(333.21,36.48) 333.38,36.64 333.38,36.81 333.3,36.88 333.01,36.88 332.89,37.01 332.89,39.1 329.82,42.16 328.77,42.16 318.49,52.44 307.24,52.44 304.73,54.95 301.58,54.95 299.13,57.41 292.53,57.41 290.25,59.7 288.93,59.7 282.13,66.5 281.84,66.5 281.72,66.62 281.43,66.62 281.01,67.03 281.01,67.45 280.71,67.75 275.55,67.75 275.04,67.24 269.27,67.24 266.66,69.85 249.04,69.85 248.22,70.68 237.9,70.68 237.23,70.01 234.18,70.01 233.51,70.68 227.61,70.68 226.14,69.2 216.93,69.2 216.48,68.76 199.33,68.76 198.18,69.91 198.18,70.88 197.46,71.6 197.46,80.87 198.26,81.68 198.26,82.98 199.47,84.2 199.47,90.94 200.19,91.66 200.19,92.74 200.33,92.88 201.82,92.88 201.96,92.74 203.16,92.74 v2(203.25,92.65)
  BOTTOM w0.089: UG9.BG20 v2(203.25,92.65)
IFPC_TX1_P: length 182.1
  TOP w0.112: v2(332.63,36.48) 332.81,36.67 332.81,36.86 CP19.1
  IN1 w0.089: v2(203.16,93.26) 202.9,93 202.07,93 201.92,93.14 200.22,93.14 199.93,92.85 199.93,91.77 199.22,91.05 199.22,84.3 198,83.09 198,81.78 197.2,80.98 197.2,71.49 197.92,70.77 197.92,69.8 199.22,68.5 216.59,68.5 217.04,68.94 226.24,68.94 227.72,70.42 233.4,70.42 234.07,69.75 237.34,69.75 238.01,70.42 248.11,70.42 248.93,69.6 266.55,69.6 269.16,66.98 275.15,66.98 275.65,67.49 280.6,67.49 280.75,67.34 280.75,66.92 281.32,66.36 281.61,66.36 281.73,66.24 282.02,66.24 288.82,59.44 290.14,59.44 292.43,57.15 299.02,57.15 301.48,54.69 304.62,54.69 307.13,52.18 318.38,52.18 328.66,41.9 329.71,41.9 332.63,38.99 v2(332.63,36.48)
  BOTTOM w0.089: v2(203.16,93.26) UG9.BH20
IFPC_TX2_CN: length 3.5
  TOP w0.112: UP2.39 332.65,41.87 332.59,41.81 332.59,41.56 332.25,41.22 330.94,41.22 330.65,40.93 330.65,40.65 CP18.2
IFPC_TX2_CP: length 3.6
  TOP w0.112: CP17.2 330.37,40.68 330.37,41.05 330.82,41.51 332.22,41.51 332.31,41.6 332.31,41.78 332.25,41.83 UP2.38
IFPC_TX2_N: length 185.9
  TOP w0.112: v2(330.79,38.51) 330.68,38.61 330.68,39.2 CP18.1
  IN1 w0.089: v2(330.79,38.51) 330.46,38.84 330.46,39.05 330.55,39.14 330.74,39.14 330.87,39.27 330.87,39.41 330.79,39.5 330.55,39.5 330.46,39.59 330.46,40.6 329.55,41.51 328.5,41.51 319.22,50.79 309.64,50.79 308.77,51.66 307.1,51.66 304.46,54.3 301.31,54.3 298.86,56.76 292.26,56.76 290.11,58.91 288.79,58.91 281.86,65.84 280.31,65.84 279.56,66.59 269,66.59 266.39,69.2 248.77,69.2 247.95,70.03 238.76,70.03 237.79,69.06 234.02,69.06 233.05,70.03 228.17,70.03 226.69,68.55 217.5,68.55 215.75,66.8 214.15,66.8 214.13,66.78 213.21,66.78 211.89,68.11 199.03,68.11 198.27,68.86 197.52,69.61 197.52,69.97 197.52,69.97 197.52,70.61 196.8,71.33 196.8,83.26 197.67,84.12 198.48,84.12 198.79,84.44 198.79,93.33 200.04,94.57 202.99,94.57 204.18,93.39 204.51,93.39 204.83,93.07 204.83,92.74 204.74,92.65 v2(204.55,92.65)
  BOTTOM w0.089: UG9.BF20 v2(204.55,92.65)
IFPC_TX2_P: length 185.9
  TOP w0.112: v2(330.2,38.51) 330.24,38.55 330.24,39.34 330.13,39.45 CP17.1
  IN1 w0.089: v2(330.2,38.51) 330.2,40.49 329.44,41.25 328.39,41.25 319.11,50.53 309.54,50.53 308.66,51.4 306.99,51.4 304.35,54.04 301.21,54.04 298.75,56.5 292.16,56.5 290,58.65 288.68,58.65 281.75,65.59 280.2,65.59 279.46,66.33 268.89,66.33 266.28,68.94 248.66,68.94 247.84,69.77 238.86,69.77 237.89,68.8 233.91,68.8 232.94,69.77 228.27,69.77 226.8,68.29 217.6,68.29 215.86,66.54 214.25,66.54 214.24,66.53 213.1,66.53 211.78,67.85 198.92,67.85 198.16,68.6 197.26,69.5 197.26,70.07 197.27,70.5 196.55,71.22 196.55,83.36 197.57,84.38 198.37,84.38 198.54,84.55 198.54,93.44 199.93,94.83 203.1,94.83 204.29,93.65 204.62,93.65 205.08,93.18 205.08,92.82 v2(205.25,92.65)
  BOTTOM w0.089: UG9.BE20 v2(205.25,92.65)
IFPCD_RSET: length 1.7
  TOP w0.089: RG37.1 205.86,92.74 v2(205.95,92.65) 205.95,92.57 v1(206.29,92.23)
  BOTTOM w0.114: UG9.BD20 v2(205.95,92.65)
IFPEF_PLLVDD: length 0.4
  BOTTOM w0.089: UG9.BD15 v2(205.95,89.75)
ILIM_CHG: length 8.5
  TOP w0.14: PQ706.3 41.72,32.92 v1(42.34,32.3)
  TOP w0.203: PU700.21 35.74,36.09 36.27,35.55 37.85,35.55 PR715.1
  TOP w0.254: PR715.1 38,35.36 PR714.1 40.44,32.92 PQ706.3
ILIM_HI1: length 4.3
  BOTTOM w0.14: US1.16 10.03,39.26 10.5,39.73 v1(11.24,39.73) 11.74,39.73 RI45.1
ILIM_LO1: length 5.2
  BOTTOM w0.127: 9.53,39.24 v1(9.53,40.01)
  BOTTOM w0.14: v1(9.53,40.01) 9.69,40.17 12.19,40.17 RI49.1 ; US1.15 9.53,39.24
ILIM_SEL_R: length 4.3
  BOTTOM w0.127: RI30.2 v1(12.5,33.89)
  BOTTOM w0.14: RI30.2 11.22,34.98 11.47,35.23 11.47,36.03 11.28,36.22 US1.4
ILMT_1.8V: length 3.8
  TOP w0.14: PR18V06.1 268.83,78.32 v1(269.08,78.08)
  TOP w0.254: v2(268.14,78.77) 268.45,78.77 PR18V06.1
  BOTTOM w0.254: PR18V07.2 267.88,78.51 v2(268.14,78.77) 268.52,79.15 PU18V00.13
ILMT_1V: length 7.1
  TOP w0.14: v1(256.29,38.09) 255.95,38.43 v2(255.67,38.43)
  TOP w0.254: v2(251.05,38.06) 251.05,38.13 250.92,38.27 PU100.13 ; PR108.2 v2(255.67,38.43)
  BOTTOM w0.254: v2(255.67,38.43) 255.64,38.46 PR109.1 251.45,38.46 v2(251.05,38.06)
ILMT_VCCIO: length 3.4
  BOTTOM w0.254: PU4000.13 126.74,102.79 126.93,102.98 126.93,103.24 v1(127.15,103.46) 127.44,103.74 PR4011.2 128.05,104.67 PR4008.1
IMVP_VR_ON: length 38.9
  TOP w0.14: RE135.2 CE82.1 RE23.1 318.25,10.67 318.68,10.24 v2(318.73,10.24) ; UZ21.1 300.07,29.97 300.38,29.66 304.12,29.66 v1(304.53,29.24) v2(305,28.77)
  IN5 w0.097: v2(318.73,10.24) 317.81,11.17 317.81,15.24 317.81,15.41 315.53,17.69 313.01,17.69 312.44,17.12 307.91,17.12 304.97,20.05 304.97,22.91 304.66,23.22 304.66,26.81 305,27.16 v2(305,28.77)
IMVP_VR_PG: length 296.5
  TOP w0.14: UH14.1 310.95,32.7 v1(310.08,33.57) 309.8,33.85 v2(308.98,33.85) ; v2(134.5,145.21) 134.23,144.94 134.23,144.24 PR5020.1
  IN2 w0.097: v2(125.39,109.82) 125.94,109.82 126.15,110.02 126.15,117.27 130.66,121.78 130.66,123.91 132.5,125.75 134.43,125.75 134.63,125.94 134.63,134.85 135.05,135.27 135.05,138.81 133.83,140.03 132.28,140.03 129.74,142.57 129.74,144.71 130.68,145.65 134.06,145.65 v2(134.5,145.21)
  IN3 w0.124: v2(125.39,109.82) 125.52,109.82 126.24,109.1 134,109.1 136.6,111.69 158.2,111.69 158.66,112.15 167.34,112.15 167.57,112.38 175.9,112.38 176.6,111.69 180.92,111.69 181.92,110.68 184.94,110.68 189.03,106.6 190.03,106.6 192.53,104.1 192.53,89.47 194.35,87.66 197.13,87.66 200.76,84.03 200.76,83.15 201.14,82.77 202.16,82.77 202.86,83.47 203.37,83.47 203.87,82.96 203.87,81.75 203.24,81.12 203.24,78.39 204.38,77.24 205.72,77.24 206.35,76.61 211.94,76.61 213.85,74.7 216.32,74.7 216.96,74.07 216.96,73.66 221.18,69.43 222.23,69.43 222.67,68.99 229.02,68.99 231.35,66.66 236.32,66.66 236.72,66.26 266.2,66.26 272.58,59.88 272.58,53.4 273.07,52.91 273.07,46.78 273.4,46.45 273.4,44.08 274.11,43.38 274.11,42.13 274.32,41.91 274.93,41.91 275.35,41.49 275.35,40.57 276.39,39.53 281.43,39.53 282,38.95 288.8,38.95 289.58,38.17 295.39,38.17 296.1,37.45 299.85,37.45 300.01,37.62 305.98,37.62 308.98,34.62 v2(308.98,33.85)
INTRUDER#: length 4.6
  TOP w0.14: RH143.1 294.27,27.73 294.01,27.99 293.08,27.99 v1(292.63,28.44) 292.55,28.53 292.55,28.73 291.73,29.55 v2(291.73,29.86)
  BOTTOM w0.076: v2(291.73,29.86) 291.76,29.89 UH2.BE11
INV_PWM: length 9
  TOP w0.14: v1(88.79,48.86) v2(89.94,48.86) 89.94,48.46 DV2.1
  BOTTOM w0.14: RV537.1 v2(89.94,48.86) 90.57,48.86 90.68,48.75 JEDP1.16
IR_CAM_DET#: length 3.6
  TOP w0.14: v2(274.42,36.52) v1(274.93,36.52) 275.77,36.52 RZ96.2
  BOTTOM w0.076: v2(274.42,36.52) 274.42,36.44 275.02,35.84 275.87,35.84 UH2.AN43
ISEN1: length 2.6
  TOP w0.203: PU6000.20 156.54,141.38 v1(157.01,141.85) 157.67,142.51 PR6027.2
ISEN1_GT: length 29.3
  TOP w0.203: PU5000.9 134.19,137.73 133.85,137.39 v2(133.54,137.39)
  TOP w0.254: v2(128.04,121.96) PR5211.2 127.33,122.06 PR5208.2
  IN4 w0.254: v2(133.54,137.39) 132.87,137.39 132.09,136.62 130.28,136.62 130.09,136.81 127.31,136.81 126.02,135.52 126.02,122.52 126.58,121.96 v2(128.04,121.96)
  BOTTOM w0.127: PC5029.2 132.84,136.21 v1(132.58,135.94)
  BOTTOM w0.254: PC5029.2 132.98,137.39 v2(133.54,137.39)
