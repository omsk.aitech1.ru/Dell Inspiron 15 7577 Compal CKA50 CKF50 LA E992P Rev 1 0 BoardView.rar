# Allegro board Dell_Inspiron_15_7577_Compal_CKA50_CKF50_LA_E992P_Rev_1_0_BoardView.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+1V_PCH_PRIM on BOTTOM (solid shape): 285.77,38.79 285.99,38.66 286.2,38.79 286.55,38.79 286.76,38.66 286.97,38.79 287.26,38.79 287.59,38.46 287.59,38.45 287.64,38.33 287.74,38.24 287.77,38.22 287.77,37.85 287.62,37.7 285.15,37.7 285,37.85 285,38.24 285.07,38.3 285.12,38.37 285.12,38.38 285.54,38.79
+1V_PCH_PRIM on IN1 (solid shape): outline of 348 points within 283.58,37.89 287.45,42.79
+1V_PCH_PRIM on VCC: 280.12,38.19 278.23,40.07 278.23,44.56 278.66,44.99 291.93,44.99 294.53,47.59 297.56,47.59 297.98,47.17 297.98,39.76 296.42,38.19
+1V_PCH_USBPLL on TOP (solid shape): 294.88,37.73 294.88,37.29 295.05,37.12 297.12,37.12 297.18,37.06 297.18,36.52 297.18,36.51 297.14,36.36 297.18,36.21 297.18,36.2 297.18,35.99 297.1,35.92 294.07,35.92 293.98,36 293.98,37.44 294.09,37.58 294.12,37.75 294.15,37.83 294.22,37.86 294.76,37.86
+1V_VCCDSW on IN2 (solid shape): outline of 319 points within 281.56,32.26 286.81,36.91
+1VALW on TOP (solid shape): outline of 2488 points within 266.39,39.53 298.27,59.69
+1VALW on BOTTOM (solid shape): 267.62,43.41 267.62,37.48 267.44,37.3 265.09,37.3 264.96,37.43 264.96,37.94 265.47,37.94 265.47,38.76 264.96,38.76 264.96,39.14 265.47,39.14 265.47,39.97 264.96,39.97 264.96,43.4 265.15,43.59 267.44,43.59
+1VALW on BOTTOM (solid shape): 184.82,111.66 184.82,111.22 185.65,110.39 185.65,109.63 185.4,109.38 185.03,109.38 184.82,109.17 184.82,108.81 184.82,108.23 184.97,108.08 185,108.05 185.04,108.02 185.08,107.98 185.1,107.98 185.19,107.95 185.27,107.94 186.32,107.94 186.98,107.28 186.98,104.38 186.77,104.17 186.76,104.17 186.45,104.63 186.14,104.17 184.57,104.17 184.32,104.42 184.32,105.44 184.6,105.72 185.04,105.72 185.21,105.89 185.21,105.94 185.21,105.95 185.21,106.48 185.36,106.99 184.93,107.31 184.73,107.31 184.59,107.29 184.46,107.22 184.29,107.22 184.24,107.18 184.22,107.18 184.04,107.14 183.87,107.03 183.86,107.02 183.73,107.02 183.57,106.86 182.96,106.86 182.76,107.06 182.76,107.41 183.05,107.7 183.05,111.73 183.12,111.81 184.68,111.81
+1VALW on VCC: 264.88,39.27 259.03,45.11 246.27,45.11 242.9,48.48 239.29,48.48 236.24,51.53 231.35,51.53 226.39,56.48 204.87,56.48 200.87,60.48 195.03,60.48 191.49,64.01 191.49,73.73 189.82,75.4 187.28,75.4 184.82,77.86 184.82,81.97 185.59,82.73 185.59,92.59 183.69,94.49 183.69,94.64 183.68,105.59 183.68,106.11 182.73,107.07 182.73,107.87 182.96,108.11 187.13,108.11 190.22,105.02 190.22,102.64 190.24,84.97 190.24,82.4 194.78,77.85 194.78,77.8 194.93,77.65 194.98,77.65 197.91,74.73 197.91,67.74 202.75,62.89 232.66,62.89 244.03,51.53 263.03,51.53 273.07,61.56 289.24,61.56 297.98,52.82 297.98,48.52 297.56,48.1 294.32,48.1 291.72,45.49 269.62,45.49 268.33,44.2 268.33,40.71 266.89,39.27 ; 1 cut-out
+1VALWP on TOP (solid shape): 263.18,42.7 263.18,39.84 262.87,39.53 260.9,39.53 260.83,39.59 260.83,42.89 261.02,43.08 262.8,43.08
+1VALWP on BOTTOM (solid shape): 264.71,47.08 264.71,39.72 265.28,39.72 265.28,39.4 264.71,39.4 264.71,38.51 265.28,38.51 265.28,38.19 264.71,38.19 264.71,37.49 264.52,37.3 263.12,37.3 262.61,37.81 259.94,37.81 259.75,38 259.75,39.18 262.12,39.18 262.12,39.13 262.12,39.08 262.14,39.03 262.16,38.98 262.19,38.94 262.23,38.91 262.27,38.87 262.32,38.85 262.37,38.83 262.42,38.83 262.47,38.83 262.52,38.83 262.57,38.85 262.62,38.87 262.66,38.91 262.7,38.94 262.73,38.98 262.75,39.03 262.77,39.08 262.78,39.13 262.78,39.18 262.77,39.23 262.75,39.28 262.73,39.33 262.7,39.37 262.66,39.41 262.62,39.44 262.57,39.46 262.52,39.48 262.47,39.49 262.42,39.49 262.37,39.48 262.32,39.46 262.27,39.44 262.23,39.41 262.19,39.37 262.16,39.33 262.14,39.28 262.12,39.23 262.12,39.18 259.75,39.18 259.75,46.83 260.26,47.34 264.45,47.34
+2.5V_MEM on TOP (solid shape): 247.97,43.71 247.97,40.13 247.63,39.78 246.55,39.78 246.42,39.9 246.42,43.65 246.68,43.91 247.78,43.91
+2.5V_MEM on TOP (solid shape): 172.37,45.13 172.37,44.01 172.25,43.89 172.25,42.13 172.12,42 170.47,42 170.16,42.32 170.16,45.18 170.35,45.37 172.13,45.37
+2.5V_MEM on BOTTOM (solid shape): 172.89,43.65 172.89,42.51 172.37,41.99 168.78,41.99 168.66,42.11 168.66,43.74 168.87,43.95 168.88,43.95 168.93,44.01 172.53,44.01
+2.5V_MEM on BOTTOM (solid shape): 167.74,23.89 167.74,21.81 167.27,21.34 165,21.34 164.33,22.01 164.33,23.9 164.61,24.19 165.54,24.19 165.54,23.66 166.09,23.66 166.09,24.19 166.34,24.19 166.34,23.66 166.89,23.66 166.89,24.19 167.28,24.19 167.3,24.21 167.43,24.21
+2.5V_MEM on BOTTOM (solid shape): 246.29,44.67 246.29,43.97 246.46,43.8 247.39,43.8 247.49,43.79 247.58,43.8 247.75,43.8 248.01,43.55 248.01,40.73 247.76,40.49 246.81,40.49 246.16,41.14 245.16,42.13 245.16,44.87 245.28,44.99 245.97,44.99
+2.5V_MEMP on BOTTOM (solid shape): 165.13,29.83 165.13,29.27 164.82,28.97 163.96,28.97 163.8,28.81 163.8,27.45 163.94,27.31 165.85,27.31 166.31,27.78 166.31,27.86 166.61,28.16 168.15,28.16 168.35,27.95 168.35,27.6 168.19,27.44 166.98,27.44 166.24,26.69 166.24,25.9 167.28,24.86 167.28,24.37 167.23,24.31 166.76,24.31 166.76,23.79 166.47,23.79 166.47,24.31 165.96,24.31 165.96,23.79 165.67,23.79 165.67,24.31 164.6,24.31 161.91,27 161.91,29.25 162.57,29.91 165.05,29.91
+3.3V_FLASH on BOTTOM (solid shape): 364.88,98.8 364.88,97.56 364.58,97.26 364.58,96.12 364.37,95.91 363.23,95.91 363.04,96.09 363.04,97.74 362.32,98.47 362.32,99.01 362.5,99.2 364.48,99.2
+3.3V_FLASH on BOTTOM (solid shape): 354.76,69.5 354.79,69.43 354.76,69.35 354.64,69.07 354.8,68.81 354.83,68.8 354.83,68.63 354.66,68.33 354.83,68.04 354.83,67.46 354.69,67.32 354.68,67.32 354.53,67.21 354.49,67.03 354.49,67.03 354.49,66.19 354.37,66.07 353.94,66.07 353.89,66.12 353.89,67.28 354.13,67.52 354.13,69.13 354.14,69.18 354.13,69.23 354.13,69.4 354.17,69.41 354.29,69.48 354.37,69.59 354.67,69.59
+3.3V_FLASH on IN1 (solid shape): 363.13,88.86 363.13,88.2 363.02,88.09 361.35,88.09 361.24,88.2 361.24,89.48 361.44,89.67 362.32,89.67
+3.3V_FLASH on IN1 (solid shape): 364.31,98.85 364.31,97.69 364.03,97.41 363.04,97.41 362.75,97.7 362.75,98.82 362.95,99.02 364.14,99.02
+3.3V_LC on BOTTOM (solid shape): 368.44,77.86 368.44,77.35 368.37,77.28 365.69,77.28 365.61,77.2 365.61,76.09 365.59,76.06 365.07,76.06 365.04,76.1 365.04,77.69 365.29,77.94 368.36,77.94
+3.3V_TBT_S0 on TOP (solid shape): 361.3,58.51 361.3,58.5 361.31,58.5 361.43,58.38 361.48,58.38 361.48,57.96 361.22,57.7 361.22,55.98 361.61,55.59 361.61,55.15 361.48,55.02 361.37,55.02 360.66,55.74 360.32,55.74 359.84,56.22 359.84,58.93 359.87,58.96 360.86,58.96
+3.3V_TBT_S0 on IN1 (solid shape): outline of 2426 points within 350.51,49.62 362.5,58.64
+3.3VDX_SSD on TOP (solid shape): 281.1,23.19 281.1,22.51 282.53,22.51 282.53,22.51 283.06,22.51 283.95,21.62 283.95,19.78 283.82,19.65 282.64,19.65 282.6,19.67 282.55,19.68 282.5,19.69 282.45,19.69 282.4,19.68 282.35,19.67 282.32,19.65 281.03,19.65 280.87,19.5 280.86,19.5 280.86,19.48 280.84,19.46 280.84,18.32 280.33,17.81 275.95,17.81 275.57,18.19 275.57,23.17 279.89,23.17 279.89,23.12 279.9,23.06 279.91,23.01 279.94,22.96 279.97,22.92 280,22.88 280.04,22.85 280.09,22.82 280.14,22.8 280.19,22.79 280.24,22.79 280.3,22.79 280.35,22.8 280.4,22.82 280.45,22.85 280.49,22.88 280.52,22.92 280.55,22.96 280.58,23.01 280.59,23.06 280.6,23.12 280.6,23.17 280.59,23.22 280.58,23.27 280.55,23.32 280.52,23.36 280.49,23.4 280.45,23.44 280.4,23.46 280.35,23.48 280.3,23.49 280.24,23.5 280.19,23.49 280.14,23.48 280.09,23.46 280.04,23.44 280,23.4 279.97,23.36 279.94,23.32 279.91,23.27 279.9,23.22 279.89,23.17 275.57,23.17 275.57,24.67 275.88,24.98 279.31,24.98
+3.3VDX_SSD on BOTTOM (solid shape): outline of 86 points within 276.07,7.27 284.33,25.75
+3V3_SYS on TOP (solid shape): 209.54,60.76 209.54,58.37 209.43,58.26 207.07,58.26 206.97,58.36 206.97,59.49 207.78,59.49 207.78,59.44 207.78,59.39 207.8,59.34 207.82,59.29 207.85,59.25 207.89,59.21 207.93,59.18 207.98,59.16 208.03,59.14 208.08,59.13 208.13,59.13 208.18,59.14 208.23,59.16 208.28,59.18 208.32,59.21 208.36,59.25 208.39,59.29 208.41,59.34 208.43,59.39 208.44,59.44 208.44,59.49 208.43,59.54 208.41,59.59 208.39,59.64 208.36,59.68 208.32,59.71 208.28,59.75 208.23,59.77 208.18,59.78 208.13,59.79 208.08,59.79 208.03,59.78 207.98,59.77 207.93,59.75 207.89,59.71 207.85,59.68 207.82,59.64 207.8,59.59 207.78,59.54 207.78,59.49 206.97,59.49 206.97,60.09 206.54,60.52 206.54,60.9 206.7,61.05 209.26,61.05
+3V3_SYS on BOTTOM (solid shape): 221.6,75.84 221.6,72.28 222.6,71.29 224.15,71.29 224.16,71.27 224.16,70 224.03,69.87 222.56,69.87 220.72,71.72 220.72,75.78 220.91,75.97 221.46,75.97
+3V_DVDD on TOP (solid shape): 339.83,18.44 339.83,18.32 339.71,18.2 339.71,18.07 339.64,18 339.64,15.91 340.14,15.41 340.14,13.49 340.15,13.49 340.15,13.36 340.13,13.35 338.82,13.35 338.81,13.36 338.75,13.36 338.68,13.43 338.68,14.19 338.3,14.57 338.3,18.29 338.52,18.51 339.76,18.51
+3V_DVDD on TOP (solid shape): 340.85,23.63 340.85,23.07 341.28,22.63 341.76,22.63 341.85,22.55 341.85,22.22 341.79,22.15 340.95,22.15 340.69,22.41 339.3,22.41 339.13,22.58 339.13,23.12 339.16,23.13 339.34,23.46 339.04,23.68 338.99,23.68 338.94,23.67 338.91,23.66 338.56,24.01 337.95,24.01 337.84,24.12 337.84,25.7 337.91,25.78 338.7,25.78
+3V_DVDD on IN2 (solid shape): 340.27,22.82 340.27,21.68 339.89,21.3 339.89,17.05 339.64,16.79 338.62,16.79 338.37,17.05 338.37,22.76 338.56,22.95 340.15,22.95
+3V_FPSW on BOTTOM (solid shape): 217.31,28.91 217.31,26.98 216.34,26.01 216.34,23.4 216.16,23.22 215.5,23.22 215.27,23.45 215.27,26.39 215.28,26.39 216.5,27.62 216.5,28.9 216.6,29 217.22,29
+3V_PCH_DSW on TOP (solid shape): 290.04,24.26 290.04,23.74 290.24,23.54 290.43,23.54 290.62,23.35 290.62,22.4 290.64,22.38 290.64,22.06 291.51,22.06 291.59,22.12 291.68,22.09 291.73,22.04 291.73,21.22 291.52,21.01 289.14,21.01 288.96,21.19 288.96,24.22 289.12,24.39 289.91,24.39
+3V_PCH_DSW on IN2 (solid shape): outline of 863 points within 285.52,32.11 291.63,43.06
+3V_PCH_DSW on IN5 (solid shape): outline of 596 points within 285.19,22.86 290.6,33.13
+3V_TPM on TOP (solid shape): 286.72,14.57 286.72,14.56 286.84,14.44 286.84,10.48 286.64,10.28 285.1,10.28 284.95,10.43 284.95,13.51 284.96,13.6 284.95,13.7 284.95,14.44 285.4,14.89 286.4,14.89
+3V_TPM on BOTTOM (solid shape): 286.13,11.46 286.13,10.95 286.69,10.39 287.48,10.39 287.85,10.02 287.85,9.27 287.69,9.12 286.28,9.12 284.94,10.46 284.94,11.37 285.07,11.51 286.08,11.51
+3V_TPM on BOTTOM (solid shape): 285.55,15.84 285.79,15.78 286.04,15.84 286.87,15.84 287.5,15.2 288.58,15.2 288.65,15.14 288.65,14.76 288.58,14.7 287.63,14.7 287.44,14.51 287.44,13.88 287.28,13.72 285.93,13.72 285.71,13.93 285.71,13.95 285.47,14.19 285.02,14.19 284.95,14.26 284.95,14.47 284.95,14.53 284.95,14.81 285.03,14.89 285.22,14.89 285.34,15.01 285.34,15.71 285.47,15.84 285.54,15.84
+3V_TPM on IN5 (solid shape): 287.07,15.85 287.07,14.1 286.76,13.79 285.79,13.79 285.62,13.96 285.62,15.81 285.76,15.95 286.97,15.95
+3VALW on TOP (solid shape): 311.59,27.06 311.59,26.66 311.44,26.51 310.01,26.51 309.83,26.69 309.83,27.21 311.44,27.21
+3VALW on TOP (solid shape): 296.46,6.66 296.46,4.24 296.39,4.17 295.41,4.17 295.31,4.27 295.31,6.63 295.44,6.76 296.36,6.76
+3VALW on TOP (solid shape): 344.41,37.92 344.41,35.77 344.17,35.52 343.38,35.52 343.32,35.59 343.32,36.04 343.32,36.04 343.32,37.8 343.32,38 343.45,38.13 344.21,38.13
+3VALW on TOP (solid shape): 268.64,80.93 268.64,80.67 268.77,80.55 268.9,80.55 269.15,80.29 269.15,79.78 269.03,79.66 268.52,79.66 268.39,79.53 268.39,79.28 268.26,79.15 267.37,79.15 267.25,79.28 267.25,80.55 267.76,81.05 268.52,81.05
+3VALW on TOP (solid shape): 58.84,27.69 59.21,27.69 59.35,27.55 59.35,26.77 59.23,26.66 57.96,26.66 57.85,26.77 57.85,27.28 57.64,27.49 56.53,27.49 56.28,27.73 56.28,27.95 56.58,28.25 58.28,28.25
+3VALW on TOP (solid shape): 264.27,31.95 264.27,30.76 264.79,30.24 264.79,28.58 264.38,28.16 263.68,28.16 262.84,29.01 262.84,29.97 262.84,30.01 262.75,30.1 262.17,30.1 261.95,30.32 261.95,32.12 262,32.17 264.05,32.17
+3VALW on TOP (solid shape): 358.81,62.24 358.81,62.23 358.87,62.11 358.97,62.02 358.97,60.94 358.84,60.81 358.2,60.81 357.99,61.03 357.99,61.14 357.89,61.14 357.89,61.38 357.24,61.38 357.24,61.88 357.32,61.96 357.32,61.97 357.37,62.03 357.38,62.03 357.53,62.19 357.55,62.41 357.54,62.42 357.54,62.49 357.67,62.61 358.43,62.61
+3VALW on TOP (solid shape): 216.5,144.69 216.5,143.46 216.13,143.09 215.83,143.09 215.4,143.52 214.89,143.52 214.34,143.68 214,143.21 214,143.11 214.04,142.94 214.13,142.78 214.13,140.67 213.9,140.45 213.2,140.45 213.02,140.63 213.02,144.47 213.73,145.18 216.01,145.18
+3VALW on TOP (solid shape): outline of 89 points within 292.47,16.68 295.47,21.93
+3VALW on TOP (solid shape): 88.53,56.96 89.41,56.96 89.7,56.67 89.7,55.27 88.88,54.45 88.57,54.45 88.56,54.46 87.57,54.46 87.47,54.52 87.49,54.63 87.54,54.93 87.32,55.15 87.25,55.21 87.26,55.29 87.3,55.5 87.22,55.69 87.2,55.76 87.22,55.82 86.95,56.41 86.67,55.82 86.69,55.76 86.67,55.69 86.61,55.35 86.86,55.12 86.93,55.06 86.93,54.98 86.9,54.8 86.96,54.63 86.97,54.52 86.88,54.46 83.11,54.46 78.78,50.13 70.65,50.13 70.46,50.32 70.46,51.91 70.59,52.03 77.13,52.03 82.27,57.18 88.32,57.18
+3VALW on BOTTOM (solid shape): 217.34,144.31 217.34,143.35 217.18,143.19 215.82,143.19 215.66,143.35 215.66,144.24 215.82,144.4 217.25,144.4
+3VALW on BOTTOM (solid shape): 271.76,44.92 271.76,40.29 271.63,40.16 270.04,40.16 269.91,40.29 269.91,44.8 270.17,45.05 271.63,45.05
+3VALW on BOTTOM (solid shape): 313.2,19.43 313.2,18.57 313.06,18.42 311.17,18.42 310.93,18.66 310.93,19.45 311.03,19.55 313.08,19.55
+3VALW on BOTTOM (solid shape): 255.42,139.82 256.92,139.82 257.1,139.64 257.1,139.06 256.91,138.86 255.14,138.86 254.37,139.64 254.37,139.92 254.7,140.25 254.99,140.25
+3VALW on BOTTOM (solid shape): 310.43,22.83 310.43,21.2 310.19,20.96 308.75,20.96 308.56,21.14 308.56,21.29 308.46,21.4 308.46,22.74 308.66,22.95 310.31,22.95
+3VALW on BOTTOM (solid shape): 268.64,80.93 268.64,80.75 268.85,80.55 268.94,80.55 269.39,80.09 269.39,80 269.3,79.91 268.01,79.91 267.88,80.04 267.88,80.67 268.26,81.05 268.52,81.05
+3VALW on BOTTOM (solid shape): 352.63,70.82 353.19,70.82 353.19,70.83 353.29,70.83 353.42,70.7 353.42,69.43 353.48,69.37 353.47,69.18 353.48,69.12 353.48,68.69 353.21,68.42 352.91,68.42 352.4,68.93 352.4,70.64 352.59,70.83 352.63,70.83
+3VALW on BOTTOM (solid shape): 72.37,54.89 73.51,54.89 74.14,54.26 74.14,47.46 73.95,47.27 71.67,47.27 71.48,47.08 71.48,46.83 71.29,46.64 70.21,46.64 70.21,47.15 70.78,47.15 70.78,49.18 70.21,49.18 70.21,50.64 69.25,51.59 69.25,52.48 69.83,52.48 69.83,54.51 69.25,54.51 69.25,55.02 72.24,55.02
+3VALW on BOTTOM (solid shape): 126.59,101.95 126.59,101.63 126.68,101.54 126.68,101.53 126.74,101.47 126.74,101.45 126.85,101.35 126.85,101.18 127.04,100.99 127.04,100.74 127.29,100.49 127.74,100.49 127.8,100.42 127.8,99.53 127.74,99.47 126.66,99.47 126.53,99.6 126.53,100.61 125.96,101.18 125.96,101.5 125.64,101.82 125.64,101.92 125.74,102.02 126.52,102.02
+3VALW on BOTTOM (solid shape): 11.67,33.23 11.67,31.49 11.57,31.38 8.36,31.38 8.11,31.64 8.11,33.19 8.25,33.33 9.95,33.33 9.95,32.62 9.97,32.62 9.97,32.24 10.18,32.03 10.47,32.03 10.68,32.24 10.68,32.62 10.71,32.62 10.71,33.33 10.18,33.33 9.95,33.33 8.25,33.33 8.36,33.44 11.46,33.44
+3VALW on BOTTOM (solid shape): 177.27,33.63 177.27,28.67 177.84,28.1 177.84,25.17 177.59,24.92 176.88,24.92 175.93,24.92 175.87,24.98 175.87,25.56 175.3,25.56 175.3,25.75 175.87,25.75 175.87,26.38 175.3,26.38 175.3,26.57 175.87,26.57 175.87,27.14 176.19,27.46 176.19,27.78 176.57,28.16 176.57,32.79 176.57,32.79 176.57,33.58 176.72,33.73 177.17,33.73
+3VALW on BOTTOM (solid shape): 311.77,15.67 311.77,14.35 311.78,14.35 311.78,12.67 311.59,12.49 308.13,12.49 308.08,12.43 308.03,12.48 308.03,12.51 307.5,12.79 307.63,12.2 307.7,12.13 307.68,12.03 307.33,11.68 305.45,11.68 303.91,13.22 302.8,13.22 302.6,13.42 302.6,14.02 302.66,14.08 303.87,14.08 304.06,13.99 304.26,14.08 307.09,14.08 308.18,15.16 310.49,15.16 311.1,15.78 311.66,15.78
+3VALW on IN1 (solid shape): outline of 1074 points within 343.33,36.68 358.92,62.77
+3VALW on IN2 (solid shape): 38.37,34.88 38.37,33.74 38.18,33.55 36.79,33.55 36.53,33.8 36.53,34.5 37.04,35.01 38.25,35.01
+3VALW on IN2 (solid shape): 257.14,139.74 257.14,138.37 257.04,138.27 255.88,138.27 255.63,138.52 255.63,139.75 255.77,139.89 256.99,139.89
+3VALW on IN2 (solid shape): 268.66,80.95 268.66,80.37 268.07,79.78 267.53,79.78 266.92,80.39 266.92,80.98 267.42,81.49 268.12,81.49
+3VALW on IN2 (solid shape): 358.69,63.34 358.69,62.07 358.56,61.94 357.93,61.94 357.61,62.26 357.61,62.5 357.54,62.57 357.54,63.34 357.61,63.4 358.62,63.4
+3VALW on IN2 (solid shape): 353.54,69.38 353.52,69.34 353.47,69.16 353.53,68.99 353.54,68.98 353.54,68.93 353.59,68.93 353.61,68.92 353.78,68.85 353.97,68.89 354,68.91 354.67,68.25 354.67,68.23 354.73,68.13 354.81,68.05 354.81,67.27 354.75,67.21 353.67,67.21 352.85,68.04 352.85,69.26 353.08,69.5 353.42,69.5
+3VALW on IN2 (solid shape): 346.11,37.49 346.11,33.64 346.08,33.57 346.01,33.54 345.69,33.21 346.01,32.88 346.08,32.85 346.11,32.78 346.11,32.2 346.07,32.12 345.97,32.11 345.49,31.82 345.97,31.52 346.07,31.51 346.11,31.43 346.11,29.49 345.67,29.05 344.15,29.05 343,30.19 343,36.7 343.22,36.91 343.22,37.8 343.36,37.94 345.67,37.94
+3VALW on IN3 (solid shape): outline of 151 points within 121.07,99.4 130.03,105.08
+3VALW on IN3 (solid shape): outline of 269 points within 70.4,50.09 89.89,56.67
+3VALW on IN4 (solid shape): 37.44,33.81 37.25,33.62 35.79,33.62 35.47,33.94 35.47,34.83 35.73,35.08 37.44,35.08
+3VALW on IN4 (solid shape): 74.59,51.97 74.59,49.81 73.95,49.18 70.4,49.18 69.83,49.75 69.83,51.97 70.33,52.48 74.08,52.48
+3VALW on IN4 (solid shape): 21.82,52.3 21.82,51.28 21.82,51.27 21.76,51.21 20.23,51.21 20.17,51.27 20.17,52.23 20.36,52.42 21.7,52.42
+3VALW on IN4 (solid shape): 60.01,28.08 60.01,27.47 59.79,27.25 57.58,27.25 57.47,27.36 57.47,28.2 57.6,28.33 59.75,28.33
+3VALW on IN4 (solid shape): 164.95,82.39 164.96,82.35 164.97,82.3 164.99,82.25 165.02,82.21 165.06,82.18 165.1,82.15 165.14,82.13 165.19,82.11 165.23,82.1 165.33,82.01 165.9,82.01 165.96,81.95 165.96,81.4 165.93,81.37 164.03,81.37 163.81,81.59 163.81,81.86 164.02,81.86 164.02,81.81 164.03,81.76 164.05,81.71 164.07,81.67 164.1,81.63 164.13,81.59 164.17,81.56 164.22,81.54 164.27,81.53 164.32,81.52 164.37,81.52 164.41,81.53 164.46,81.54 164.51,81.56 164.55,81.59 164.58,81.63 164.61,81.67 164.63,81.71 164.65,81.76 164.66,81.81 164.66,81.86 164.65,81.91 164.63,81.96 164.61,82 164.58,82.04 164.55,82.08 164.51,82.11 164.46,82.13 164.41,82.15 164.37,82.15 164.32,82.15 164.27,82.15 164.22,82.13 164.17,82.11 164.13,82.08 164.1,82.04 164.07,82 164.05,81.96 164.03,81.91 164.02,81.86 163.81,81.86 163.81,82.35 163.82,82.38 163.82,82.44 163.82,82.49 163.81,82.53 163.81,82.69 163.89,82.77 164.57,82.77
+3VALW on IN5 (solid shape): 311.56,28.17 311.56,25.42 311.44,25.3 310.55,25.3 310.3,25.56 310.3,28.02 310.56,28.29 311.45,28.29
+3VALW on IN5 (solid shape): 345.92,29.62 345.92,28.22 345.61,27.9 344.65,27.9 344.21,28.35 344.21,29.68 344.34,29.81 345.73,29.81
+3VALW on IN5 (solid shape): 310.3,22.7 310.3,21.93 309.29,20.92 308.74,20.92 308.56,21.1 308.56,21.31 308.46,21.42 308.46,22.51 308.84,22.89 310.11,22.89
+3VALW on BOTTOM: 23.98,55.03 24.87,55.03 25.06,54.84 25.06,53.14 24.82,52.9 22.64,52.9 22.32,52.58 22.32,51.64 22.59,51.37 22.59,50.89 22.53,50.83 20.54,50.83 20.12,51.25 20.12,52.26 21.93,54.08 23.46,54.08 23.84,54.46 23.84,54.89
+3VALW on IN2: 58.29,28.3 58.53,28.06 58.53,27.64 58.21,27.33 56.35,27.33 56.27,27.41 56.27,28.21 56.36,28.3
+3VALW on VCC: 306.7,10.34 302,15.04 289.3,15.04 288.58,15.75 288.58,17.53 288.99,17.94 293.36,17.94 295.14,19.71 300.78,19.71 302.43,21.36 302.43,25.08 301.87,25.63 300.19,25.63 299.54,24.98 285.26,24.98 284.77,25.47 284.77,27.57 283.04,29.3 278.83,29.3 278.3,28.77 278.3,27.12 277.87,26.7 261.83,26.7 260.45,28.07 260.45,32.65 259.86,33.24 256.47,33.24 252.28,29.05 85.23,29.05 80.73,33.56 70.5,33.56 70.08,33.98 70.08,51.87 70.44,52.23 76.39,52.23 76.94,51.68 76.94,39.1 77.98,38.06 100.45,38.06 103.5,35.02 231.94,34.95 244.56,34.95 246.42,36.82 246.42,44.61 258.82,44.61 264.67,38.76 267.1,38.76 268.83,40.5 268.83,43.99 269.83,44.99 277.3,44.99 277.72,44.56 277.72,39.86 279.91,37.68 296.63,37.68 298.34,39.4 299.65,39.4 313.16,25.89 313.21,13.22 313.21,10.46 313.09,10.34
+3VALW_EC on IN2: 322.87,22.01 323.12,22.56 323.11,22.67 323.2,22.73 324.14,22.73 327.83,19.03 327.83,16.91 328.18,16.56 328.18,10.35 325.86,8.03 315.88,8.03 315.37,8.54 315.37,22.36 315.74,22.73 322.55,22.73 322.64,22.67 322.62,22.56
+3VALWP on BOTTOM (solid shape): 69.06,51.27 70.02,50.32 70.02,46.64 68.24,46.64 67.86,47.02 67.86,48.48 67.19,49.15 63.06,49.15 62.08,48.16 62.08,44.61 61.7,44.22 58.65,44.22 58.65,50.51 59.54,51.4 61.32,51.4 63.67,53.75 63.67,54.32 64.36,55.02 69.06,55.02
+3VALWP on IN1 (solid shape): 69.7,51.4 69.7,50.26 69.38,49.94 63.98,49.94 63.86,50.07 63.86,51.53 63.92,51.59 69.51,51.59
+3VLP on TOP (solid shape): 85.31,43.22 85.31,42.52 85.18,42.39 84.04,42.39 83.72,42.71 82.32,42.71 82.26,42.77 82.26,42.9 82.32,42.96 83.72,42.96 84.1,43.34 85.18,43.34
+3VLP on BOTTOM (solid shape): 268.2,18.7 268.2,17.43 268.01,17.24 267.37,17.24 267.31,17.3 267.31,17.62 267.88,17.62 267.88,18.13 267.31,18.13 267.31,19.14 267.37,19.21 267.69,19.21
+3VS on TOP (solid shape): 168.76,44.61 168.76,44.03 168.63,43.91 166.28,43.91 166.03,44.16 166.03,44.67 166.16,44.8 168.57,44.8
+3VS on TOP (solid shape): 104.81,62.58 104.81,61.62 104.56,61.37 104.31,61.37 103.61,62.07 103.1,62.07 102.97,62.19 102.97,62.7 103.1,62.83 104.56,62.83
+3VS on TOP (solid shape): 312.98,28.94 312.98,27.02 312.83,26.87 312.58,26.87 312.06,27.4 311.06,27.4 310.74,27.72 310.74,29 311.08,29.34 312.57,29.34
+3VS on TOP (solid shape): 286.3,21.24 286.3,20.41 286.7,20.01 286.7,18.68 286.47,18.44 284.52,18.44 284.14,18.82 284.14,20.03 284.76,20.03 284.76,21.43 284.82,21.49 286.05,21.49
+3VS on TOP (solid shape): 358.9,41.1 358.9,40.82 359.12,40.61 360.14,40.61 360.21,40.54 360.21,39.78 360.08,39.64 356.74,39.64 356.59,39.8 356.59,41.2 356.66,41.27 358.73,41.27
+3VS on TOP (solid shape): 270.55,12.22 270.55,7.78 270.44,7.67 269.9,7.67 269.79,7.78 269.79,10.89 269.66,11.01 269.66,11.46 269.53,11.59 268.9,11.59 268.77,11.46 268.77,10.82 268.33,10.82 268.26,10.89 268.26,11.97 268.64,12.35 270.42,12.35
+3VS on TOP (solid shape): 313.47,34.64 314.36,34.64 314.36,34.72 314.81,34.72 314.81,34.64 315.7,34.64 315.7,34.72 315.89,34.72 316.01,34.6 316.01,32.83 315.8,32.62 314.22,32.62 314.19,32.65 314.19,32.67 314.14,32.8 314.06,32.91 313.41,33.56 312.81,33.56 312.51,33.87 312.51,34.64 312.59,34.72 313.47,34.72
+3VS on TOP (solid shape): 343.19,37.75 343.19,36.1 343.03,35.93 342.97,35.92 342.94,35.97 342.94,36.03 342.05,36.03 342.05,36.03 341.99,35.93 341.88,35.95 341.83,36 341.83,37.79 342.17,38.13 342.81,38.13
+3VS on TOP (solid shape): 208.22,64.8 209.43,64.8 209.64,64.59 209.64,63.25 209.47,63.08 209.21,63.08 208.77,62.64 208.77,61.41 208.65,61.29 205.88,61.29 205.84,61.32 205.84,62.96 205.87,62.98 206.9,62.98 207.21,63.3 207.21,63.66 207.26,63.71 207.5,63.94 207.45,64.27 207.45,64.78 207.54,64.88 208.14,64.88
+3VS on TOP (solid shape): 308.74,33.62 308.98,33.52 309.22,33.62 309.79,33.62 309.8,33.6 309.8,33.57 309.89,33.37 310.1,33.29 310.12,33.29 310.62,32.79 310.62,32.16 310.49,32.03 309.67,32.03 309.66,32.04 309.54,32.04 309.09,32.49 309.09,32.51 309.01,32.73 308.8,32.81 308.77,32.81 308.66,32.92 307.5,32.92 307.31,32.73 307.31,32.22 307.22,32.13 306.63,32.13 306.53,32.23 306.53,33.33 306.82,33.62
+3VS on TOP (solid shape): 268.33,36.53 268.33,32.1 266.82,30.59 266.82,29.89 266.71,29.78 265.96,29.78 265.79,29.96 265.79,30.75 265.69,30.85 265.69,32.3 267.54,32.3 267.54,32.24 267.54,32.19 267.56,32.14 267.58,32.1 267.61,32.05 267.65,32.02 267.69,31.99 267.74,31.96 267.79,31.95 267.84,31.94 267.89,31.94 267.94,31.95 267.99,31.96 268.04,31.99 268.08,32.02 268.12,32.05 268.15,32.1 268.17,32.14 268.19,32.19 268.2,32.24 268.2,32.3 268.19,32.35 268.17,32.4 268.15,32.44 268.12,32.48 268.08,32.52 268.04,32.55 267.99,32.58 267.94,32.59 267.89,32.6 267.84,32.6 267.79,32.59 267.74,32.58 267.69,32.55 267.65,32.52 267.61,32.48 267.58,32.44 267.56,32.4 267.54,32.35 267.54,32.3 265.69,32.3 265.69,32.82 266.15,33.29 266.2,33.29 266.2,33.33 266.23,33.37 266.23,33.89 266.26,33.93 266.78,33.93 266.79,33.95 266.79,34.64 266.77,34.66 266.26,34.66 266.24,34.68 266.24,35.11 266.25,35.12 266.77,35.12 266.79,35.14 266.79,35.84 266.77,35.86 266.26,35.86 266.25,35.87 266.25,36.56 266.35,36.66 268.19,36.66
+3VS on TOP (solid shape): outline of 201 points within 278.83,24.97 282.6,30.53
+3VS on BOTTOM (solid shape): 311.25,32.98 311.25,32.29 310.95,31.99 309.39,31.99 308.84,32.54 308.84,33.18 308.97,33.3 310.94,33.3
+3VS on BOTTOM (solid shape): 21.88,34.87 21.88,33.68 21.71,33.5 19.48,33.5 19.21,33.78 19.21,34.99 19.37,35.15 21.61,35.15
+3VS on BOTTOM (solid shape): 18.52,51.37 18.52,50.71 18.43,50.61 17.97,50.61 17.8,50.45 16.89,50.45 16.83,50.5 16.83,51.4 16.9,51.46 18.43,51.46
+3VS on BOTTOM (solid shape): 94.41,66.8 94.41,66.34 94.84,65.9 94.84,65.23 94.69,65.08 93.32,65.08 93.26,65.14 93.26,65.92 92.74,66.44 92.74,66.84 92.79,66.89 94.31,66.89
+3VS on BOTTOM (solid shape): 260.82,27.77 260.82,27.13 260.38,26.69 255.24,26.69 255.1,26.83 255.1,27.31 255.84,28.05 259.76,28.05 259.85,28.14 260.45,28.14
+3VS on BOTTOM (solid shape): 302.12,25.64 302.12,24.6 302,24.49 302,24.24 301.85,24.09 300.35,24.09 300.19,24.26 300.19,24.59 300.53,24.94 300.53,25.64 300.59,25.7 302.06,25.7
+3VS on BOTTOM (solid shape): 29.44,38.71 29.44,37.64 29.12,37.32 28.27,37.32 27.94,37.65 27.94,37.86 28.21,38.13 28.49,38.13 28.68,38.32 28.68,38.7 28.79,38.81 29.35,38.81
+3VS on BOTTOM (solid shape): 247.24,37.56 247.24,37.18 247.25,37.17 247.25,36.36 246.46,35.57 246.46,33.91 246.36,33.81 246.03,33.81 245.93,33.91 245.93,36.07 246.58,36.73 246.58,37.46 246.74,37.62 247.18,37.62
+3VS on BOTTOM (solid shape): 90.36,66.23 90.36,65.86 90.4,65.86 90.4,65.56 90.27,65.43 90.02,65.43 89.94,65.51 89.94,65.52 89.86,65.65 89.72,65.74 89.71,65.74 89.64,65.81 87.73,65.81 87.61,65.69 86.53,65.69 86.27,65.94 86.27,66.77 86.46,66.96 89.64,66.96
+3VS on BOTTOM (solid shape): 286.92,12.93 286.92,12.59 286.91,12.58 286.92,12.28 287.17,12.11 287.19,12.11 287.52,12.11 287.61,12.05 287.6,11.95 287.88,11.44 288.17,11.95 288.16,12.05 288.25,12.11 288.95,12.11 289.14,11.92 289.14,11.14 289.08,11.08 288.39,11.08 287.88,10.57 286.72,10.57 286.31,10.98 286.31,11.5 285.88,11.93 285.88,13.01 286.04,13.17 286.68,13.17
+3VS on BOTTOM (solid shape): outline of 94 points within 266.93,32.37 272.22,39.53
+3VS on IN1 (solid shape): 260.85,27.45 260.85,26.69 260.61,26.44 259.78,26.44 258.61,27.61 258.61,28.16 258.87,28.41 259.89,28.41
+3VS on IN1 (solid shape): 94.59,66.45 94.59,66.07 94.15,65.62 92.71,65.62 92.44,65.76 92.17,65.62 90.46,65.62 90.27,65.43 90.02,65.43 89.94,65.51 89.94,65.52 89.86,65.65 89.72,65.74 89.7,65.75 89.38,65.75 89.13,66 89.13,66.51 89.51,66.89 94.15,66.89
+3VS on IN1 (solid shape): 246.54,37.52 247.05,37.52 247.05,34.93 247.05,34.92 247.05,34.75 246.75,34.45 245.86,34.45 245.35,34.95 245.35,35.54 245.65,35.84 245.65,36.26 245.72,36.34 245.76,36.43 245.81,36.49 245.88,36.5 246.29,36.82 245.89,37.14 245.81,37.16 245.76,37.22 245.72,37.32 245.65,37.4 245.65,37.52 245.84,37.71 246.36,37.71
+3VS on IN1 (solid shape): outline of 599 points within 265.53,17.78 286.17,36.22
+3VS on IN1 (solid shape): outline of 1514 points within 277.02,22.88 315.4,29.49
+3VS on IN2 (solid shape): 22.42,35.05 22.42,33.9 22.22,33.71 20.09,33.71 19.83,33.97 19.83,35.08 20.02,35.27 22.2,35.27
+3VS on IN2 (solid shape): 301.85,24.86 301.85,24.09 301.6,23.84 300.52,23.84 300.2,24.16 300.2,24.67 300.65,25.11 301.6,25.11
+3VS on IN2 (solid shape): 30.07,38.76 30.07,37.87 29.38,37.18 28.13,37.18 27.68,36.72 26.99,36.72 26.51,37.2 26.51,37.58 28.01,39.08 29.76,39.08
+3VS on IN2 (solid shape): 18.58,51.13 18.58,50.73 18.46,50.61 18.15,50.61 18.01,50.47 18.01,50.41 18.01,50.4 17.98,50.25 18.01,50.11 18.01,50.1 18.01,50.04 18.14,49.91 18.14,49.01 17.95,48.83 17.28,48.83 17.09,49.01 17.09,51.17 17.41,51.49 18.23,51.49
+3VS on IN2 (solid shape): 90.53,66.32 90.53,65.69 90.27,65.43 89.96,65.43 89.95,65.48 89.62,65.75 89.3,65.48 89.29,65.43 88.43,65.43 88.24,65.62 88.24,66.64 88.37,66.77 90.08,66.77
+3VS on IN3 (solid shape): 104.81,62.26 104.81,60.48 104.56,60.23 103.8,60.23 103.48,60.54 103.48,62.39 103.67,62.58 104.5,62.58
+3VS on IN3 (solid shape): 167.17,44.54 167.17,43.53 166.47,42.83 165.39,42.83 165.01,43.21 165.01,43.78 166.09,44.86 166.85,44.86
+3VS on IN3 (solid shape): 261.13,28.58 261.13,27.24 260.96,27.08 260.2,27.08 259.74,27.54 259.74,28.5 259.91,28.67 261.04,28.67
+3VS on IN3 (solid shape): 119.42,32.29 119.42,31.46 119.04,31.08 114.53,31.08 114.34,31.27 114.34,31.72 117.12,31.72 117.12,31.66 117.13,31.61 117.14,31.56 117.17,31.51 117.2,31.47 117.23,31.43 117.27,31.4 117.32,31.37 117.37,31.35 117.42,31.34 117.48,31.33 117.53,31.34 117.58,31.35 117.63,31.37 117.68,31.4 117.72,31.43 117.75,31.47 117.78,31.51 117.81,31.56 117.82,31.61 117.83,31.66 117.83,31.72 117.82,31.77 117.81,31.82 117.78,31.87 117.75,31.91 117.72,31.95 117.68,31.98 117.63,32.01 117.58,32.03 117.53,32.04 117.48,32.05 117.42,32.04 117.37,32.03 117.32,32.01 117.27,31.98 117.23,31.95 117.2,31.91 117.17,31.87 117.14,31.82 117.13,31.77 117.12,31.72 114.34,31.72 114.34,32.22 114.66,32.54 119.17,32.54
+3VS on IN3 (solid shape): outline of 221 points within 265.53,25.12 286.61,36.41
+3VS on IN3 (solid shape): outline of 709 points within 242.42,35.35 248.13,45.75
+3VS on IN4 (solid shape): 168.17,43.82 168.17,43.04 167.98,42.85 167.12,42.85 165.99,43.98 165.99,44.61 166.18,44.8 167.2,44.8
+3VS on IN4 (solid shape): 245.21,45.88 245.21,45.13 245.05,44.96 244.39,44.96 244.22,45.13 243.74,45.13 243.55,44.94 243.55,43.89 243.31,43.65 242.66,43.65 242.34,43.97 242.34,45.65 243,46.31 244.78,46.31
+3VS on IN4 (solid shape): outline of 1224 points within 266.99,25.94 281.15,36.37
+3VS on IN5 (solid shape): 94.72,66.2 94.72,65.24 94.4,64.93 93.45,64.93 93.19,65.18 93.19,66.32 93.38,66.51 94.4,66.51
+3VS on IN5 (solid shape): 104.88,62.39 104.88,61.43 104.69,61.24 103.04,61.24 102.72,61.56 102.72,63.53 102.78,63.59 103.67,63.59
+3VS on IN5 (solid shape): 234.49,61.52 234.49,60.26 234.34,60.11 233.59,60.11 233.48,60.23 233.48,61.57 233.73,61.83 234.19,61.83
+3VS on IN5 (solid shape): 245.03,46.31 245.03,45.17 244.76,44.9 244.27,44.9 244.26,44.93 243.96,45.11 243.66,44.93 243.65,44.9 242.98,44.9 242.73,45.16 242.73,46.33 243.01,46.62 244.72,46.62
+3VS on IN5 (solid shape): 287.51,12.09 287.6,12.04 287.6,11.94 287.59,11.62 287.85,11.45 287.92,11.41 287.95,11.35 287.95,10.11 287.84,10.01 286.28,10.01 285.96,10.32 285.96,11.78 286.28,12.09
+3VS on IN5 (solid shape): 280.9,28.51 280.9,28.4 280.89,28.38 280.82,28.26 280.79,28.13 280.56,27.76 280.86,27.44 280.9,27.43 280.9,24.73 279.82,23.65 279.82,23.5 279.81,23.49 279.69,23.11 279.85,22.75 282.2,20.4 282.31,20.4 282.36,20.35 285.41,20.35 285.85,19.9 285.85,18.7 285.6,18.44 284.46,18.44 283.88,19.01 283.05,19.01 283.05,19.02 282.91,19.05 282.77,19.02 282.76,19.01 282.7,19.01 282.7,19.09 282.71,19.1 282.52,19.66 282.19,19.17 282.19,19.07 282.1,19.01 282.04,19.01 279.36,21.7 279.36,21.71 279.27,21.88 279.1,21.97 279.09,21.97 278.74,22.32 278.74,24.09 278.77,24.13 278.77,25.27 279.24,25.74 279.25,25.74 279.81,26.16 279.82,26.86 279.82,26.88 279.82,27.02 279.69,27.14 279.61,27.14 279.6,27.15 279.3,27.3 278.98,27.32 278.95,27.31 278.68,27.59 278.68,28.76 278.98,29.06 280.35,29.06
+3VS on IN5 (solid shape): outline of 790 points within 296.05,24.19 311.32,34.37
+3VS on VCC: 282.36,18.44 281.34,19.46 281.34,20.9 278.8,23.44 278.8,28.56 279.04,28.79 282.83,28.79 284.27,27.36 284.27,25.26 285.05,24.48 299.75,24.48 300.4,25.12 301.66,25.12 301.92,24.87 301.92,21.57 300.57,20.22 294.93,20.22 293.15,18.44
+3VS on IN3: outline of 218 points within 290.77,24.7 359.07,44.13
+3VS_CAM on BOTTOM (solid shape): 293.03,64.86 293.03,64.48 292.39,63.85 292.2,63.85 289.63,66.42 288.86,66.42 288.52,66.77 288.52,67.27 288.58,67.34 290.55,67.34
+3VS_CR on BOTTOM (solid shape): 18.67,35.13 18.69,35.02 18.6,34.95 18.57,34.95 18.57,34.06 18.89,34.06 18.89,30.99 18.68,30.79 18,30.79 17.2,29.98 17.2,29.57 17.13,29.5 16.49,29.5 16.41,29.58 16.41,31.13 16.9,31.62 16.9,32.3 16.9,32.3 16.9,33.34 17.4,33.85 17.4,34.19 17.46,34.38 17.4,34.58 17.4,34.94 17.61,35.15 18.65,35.15
+3VS_CR on IN2 (solid shape): outline of 182 points within 15.6,27.46 19.03,31.91
+3VS_OUT on TOP (solid shape): 266.1,36.4 266.1,35.74 266.12,35.72 266.64,35.72 266.65,35.71 266.65,35.26 266.64,35.26 266.13,35.26 266.1,35.23 266.1,34.53 266.11,34.52 266.64,34.52 266.65,34.51 266.65,34.07 266.64,34.06 266.1,34.06 266.1,34.06 266.1,33.43 266.02,33.36 263.26,33.36 263.2,33.42 262.01,33.42 261.94,33.49 261.94,34.23 262.38,34.67 262.38,36.16 262.45,36.22 263.25,36.22 263.48,36.46 266.05,36.46
+3VS_TBT on TOP (solid shape): 358.56,44.08 358.65,44.1 358.76,44.1 358.89,43.96 360.19,43.96 360.35,43.8 360.35,41.52 360.18,41.34 359.28,41.34 358.84,41.79 358.84,42.7 358.2,43.34 358.18,43.35 358.05,43.4 357.87,43.4 357.67,43.6 357.67,43.97 357.8,44.1 358.47,44.1
+3VS_TBT on TOP (solid shape): 361.99,61.75 361.99,59.43 361.99,59.4 362.05,59.34 362.05,58.57 361.99,58.51 361.48,58.51 361.02,58.97 361.02,59.02 360.97,59.02 360.77,59.22 359.55,59.22 359.25,59.53 359.25,60.7 360.62,60.7 360.62,60.64 360.63,60.59 360.64,60.54 360.66,60.49 360.69,60.45 360.73,60.41 360.77,60.38 360.82,60.35 360.87,60.33 360.92,60.32 360.97,60.31 361.03,60.32 361.08,60.33 361.13,60.35 361.17,60.38 361.22,60.41 361.25,60.45 361.28,60.49 361.31,60.54 361.32,60.59 361.33,60.64 361.33,60.7 361.32,60.75 361.31,60.8 361.28,60.85 361.25,60.89 361.22,60.93 361.17,60.97 361.13,60.99 361.08,61.01 361.03,61.02 360.97,61.03 360.92,61.02 360.87,61.01 360.82,60.99 360.77,60.97 360.73,60.93 360.69,60.89 360.66,60.85 360.64,60.8 360.63,60.75 360.62,60.7 359.25,60.7 359.25,61.5 359.69,61.94 361.8,61.94
+3VS_TBT on BOTTOM (solid shape): 360.12,60.39 360.12,59.93 359.53,59.34 359.53,59.16 359.44,59.07 359.26,59.07 359.17,58.97 359.17,58.79 359.03,58.65 358.92,58.65 358.87,58.71 358.87,59.38 359.2,59.71 359.2,60.5 359.37,60.68 359.83,60.68
+3VS_TBT on IN2 (solid shape): outline of 2204 points within 352.34,41.05 359.83,62.7
+3VS_WLAN on TOP (solid shape): 344.37,35.2 344.37,33.31 344.2,33.15 340.1,33.15 339.2,33.25 338.78,32.45 338.75,32.37 338.67,32.34 338.38,32.34 338.2,32.52 337.76,32.52 336.97,33.31 336.97,34.96 337.29,35.28 338.21,35.28 338.53,34.97 340.66,34.97 340.91,35.21 341.89,35.21 342.02,35.35 344.22,35.35
+3VS_WLAN on BOTTOM (solid shape): 338.96,33.86 338.96,33.06 338.81,32.79 338.77,32.47 338.75,32.4 338.67,32.36 338.36,32.36 338.14,32.58 336.89,32.58 336.51,32.96 336.51,34.12 336.6,34.22 338.61,34.22
+3VS_WLAN on BOTTOM (solid shape): 338.2,52.61 338.29,52.59 338.39,52.61 338.52,52.61 338.52,52.56 338.76,51.87 339.39,51.51 339.43,51.5 339.43,50.99 339.3,50.87 338.97,50.87 338.68,51.02 338.4,50.87 335.41,50.87 335.18,51.1 335.18,52.45 335.34,52.61
+3VS_WLAN on IN2 (solid shape): 338.52,52.48 338.52,52.41 338.54,52.32 338.57,52.22 338.6,52.13 338.64,52.04 338.69,51.97 338.74,51.89 338.8,51.82 338.87,51.76 338.94,51.7 339.02,51.65 339.1,51.6 339.18,51.56 339.24,51.55 339.47,51.31 339.47,49.91 339.33,49.77 337.6,49.77 337.26,50.1 337.26,50.72 338.35,50.72 338.35,50.67 338.36,50.62 338.38,50.57 338.4,50.52 338.43,50.48 338.47,50.44 338.51,50.41 338.56,50.39 338.61,50.37 338.66,50.36 338.71,50.36 338.76,50.37 338.81,50.39 338.86,50.41 338.9,50.44 338.94,50.48 338.97,50.52 338.99,50.57 339.01,50.62 339.02,50.67 339.02,50.72 339.01,50.77 338.99,50.82 338.97,50.87 338.94,50.91 338.9,50.95 338.86,50.98 338.81,51 338.76,51.02 338.71,51.02 338.66,51.02 338.61,51.02 338.56,51 338.51,50.98 338.47,50.95 338.43,50.91 338.4,50.87 338.38,50.82 338.36,50.77 338.35,50.72 337.26,50.72 337.26,52.05 337.27,52.05 337.27,52.21 337.64,52.58 338.42,52.58
+3VS_WLAN on IN2 (solid shape): outline of 244 points within 337.51,32.32 340.42,40.53
+5V_AVDD on TOP (solid shape): 348.7,17.51 348.7,17.18 348.7,17.18 348.7,17.08 348.97,16.82 349.58,16.82 349.63,16.77 351.02,16.77 351.22,16.58 351.22,15.73 351.07,15.59 349.55,15.59 349.32,15.82 348.46,15.82 347.91,16.37 347.91,17.51 348.02,17.62 348.6,17.62
+5V_AVDD on BOTTOM (solid shape): 351.19,16.6 351.19,15.71 351.07,15.59 349.48,15.59 349.48,16.35 349.86,16.73 351.07,16.73
+5V_AVDD on BOTTOM (solid shape): 342.31,14.87 342.31,14.2 342.03,13.92 340.65,13.92 340.51,14.06 340.51,14.99 340.59,15.06 342.12,15.06
+5V_CHGUSB_1 on TOP (solid shape): 365.99,25.3 367.07,25.3 367.53,24.84 367.53,24.32 366.93,23.73 365.44,23.73 363.71,22 359.89,22 359.71,22.18 359.71,25.44 359.83,25.56 360.95,25.56 362.48,27.08 364.21,27.08
+5V_CHGUSB_1 on BOTTOM (solid shape): 354.31,39.4 354.31,37.86 353.75,37.3 352.78,37.3 352.72,37.37 352.72,38.76 352.27,38.76 352.27,39.42 352.45,39.6 354.11,39.6
+5V_CHGUSB_1 on BOTTOM (solid shape): 365.74,38.51 365.74,35.52 365.35,35.14 363.26,35.14 363.2,35.21 363.2,37.81 363.45,38.06 363.45,38.76 363.51,38.83 365.42,38.83
+5V_CHGUSB_1 on BOTTOM (solid shape): 366,25.31 367.08,25.31 367.53,24.86 367.53,24.18 367.08,23.73 365.62,23.73 365.62,23.72 365.48,23.72 365.43,23.72 364.28,22.57 362.97,22.57 362.87,22.67 362.87,24.57 362.24,25.2 362.24,26.79 362.54,27.09 364.22,27.09
+5V_CHGUSB_1 on IN2 (solid shape): outline of 366 points within 352.27,24.48 367.64,46.45
+5V_CHGUSB_1_OUT on BOTTOM (solid shape): 352.01,39.28 352.01,38.76 351.96,38.76 351.96,37.37 352.01,37.37 352.01,36 351.8,35.79 351.09,35.79 350.31,36.57 350.31,39.27 350.43,39.4 351.89,39.4
+5V_CHGUSB_3 on TOP (solid shape): 18.82,69.69 18.82,67.74 19.09,67.47 19.09,63.02 18.71,62.64 17.69,62.64 17.5,62.83 17.5,66.96 16.83,67.63 16.83,69.73 16.15,70.41 15.78,70.41 15.75,70.44 15.07,70.44 14.5,71.02 14.5,71.62 14.65,71.78 16.73,71.78
+5V_CHGUSB_3 on BOTTOM (solid shape): 8.17,38.26 8.17,37.62 8.04,37.49 7.99,37.49 7.98,37.51 7.86,37.57 7.73,37.6 7.11,37.6 7,37.49 6.45,37.49 5.75,38.19 5.75,39.02 5.88,39.14 7.28,39.14
+5V_CHGUSB_3 on IN1 (solid shape): outline of 1117 points within 3.09,37.05 20.17,71.78
+5V_PVDD on TOP (solid shape): 341.92,27.97 341.92,27.46 341.1,26.63 341.1,25.05 341.54,24.6 342.11,24.6 343.16,23.56 343.16,22.73 343.09,22.67 343.01,22.67 342.94,22.73 342.94,23.52 342.43,24.03 340.97,24.03 338.94,26.06 338.94,26.65 338.81,26.79 335.29,26.79 335.19,26.89 335.19,27.78 338.43,27.78 338.43,28.03 341.86,28.03
+5V_PVDD on IN2 (solid shape): 345.99,26.19 345.99,24.79 345.86,24.67 345.54,24.67 345.42,24.79 345.42,25.56 344.91,26.06 339.13,26.06 338.94,26.25 338.94,26.7 339.07,26.83 345.35,26.83
+5VALW on TOP (solid shape): 43.87,55.13 43.87,53.65 43.73,53.51 42.89,53.51 42.77,53.62 42.77,55.08 43.03,55.34 43.66,55.34
+5VALW on TOP (solid shape): 228.73,50.35 228.73,49.79 228.62,49.68 227.36,49.68 227.33,49.71 227.33,50.2 227.32,50.22 227.32,50.4 227.41,50.49 228.59,50.49
+5VALW on TOP (solid shape): 239.82,55.27 240.7,55.27 241.09,54.89 241.72,54.89 241.85,54.77 241.85,53.88 241.72,53.75 240.96,53.75 239.69,55.02 238.93,55.02 238.82,55.13 238.82,55.29 238.89,55.37 239.72,55.37
+5VALW on TOP (solid shape): 367.45,70.19 367.45,69.73 366.94,69.22 366.94,67.85 365.73,66.63 364.35,66.63 364.02,66.96 364.02,67.73 364.36,68.07 364.68,68.07 365.92,69.31 365.92,69.96 366.7,70.74 366.9,70.74
+5VALW on TOP (solid shape): 207.21,65 207.21,64.43 207.19,64.4 207.15,64.4 207.15,64.41 207.11,64.4 206.82,64.14 206.94,63.78 206.94,63.26 206.88,63.21 206.46,63.21 206.39,63.27 206.39,63.7 206.27,63.82 206.18,63.82 206.15,63.83 206.04,63.94 206.04,64.33 206.05,64.4 206.04,64.48 206.04,64.97 206.13,65.06 207.15,65.06
+5VALW on TOP (solid shape): 260.56,32.13 260.56,31.52 260.52,31.48 260.52,31.29 260.44,31.08 260.52,30.87 260.52,30.76 260.64,30.64 261.09,30.64 261.15,30.7 261.15,31.33 261.13,31.36 261.13,32.12 261.18,32.17 261.32,32.17 261.36,32.13 261.36,32.05 261.35,32.03 261.29,31.92 261.27,31.81 261.27,30.04 260.72,29.49 257.51,29.49 257.27,29.72 257.27,32.09 257.39,32.2 259.58,32.2 259.59,32.2 260.48,32.2
+5VALW on BOTTOM (solid shape): 239.89,55.26 240.73,55.26 240.99,55 240.99,54.59 240.87,54.47 239.33,54.47 238.89,54.91 238.89,55.31 239.05,55.46 239.69,55.46
+5VALW on BOTTOM (solid shape): 351.81,34.05 351.81,33.14 350.74,32.07 350.74,30.42 350.51,30.19 349,30.19 348.79,30.4 348.79,32.47 349.38,33.06 349.38,34.03 349.56,34.2 351.66,34.2
+5VALW on BOTTOM (solid shape): 117.17,99.12 117.17,98.42 117.07,98.33 115.93,98.33 115.67,98.07 115.29,98.07 115.29,98.64 114.72,98.64 114.72,98.14 114.66,98.07 114.28,98.07 114.21,98.14 114.21,99.15 114.34,99.28 117.01,99.28
+5VALW on BOTTOM (solid shape): 186.48,112.11 186.48,108.87 186.35,108.74 185.08,108.74 184.95,108.87 184.95,109.12 185.08,109.25 185.52,109.25 185.78,109.5 185.78,110.58 185.01,111.34 185.01,112.11 185.15,112.24 186.34,112.24
+5VALW on BOTTOM (solid shape): 185.08,106.25 185.08,106.05 184.98,105.95 184.64,105.95 184.63,105.95 183.94,105.25 183.94,104.93 183.81,104.8 182.28,104.8 182.2,104.89 182.2,105.63 182.3,105.74 183.41,105.74 183.94,106.27 184.78,106.27 184.83,106.32 185.01,106.32
+5VALW on BOTTOM (solid shape): 365.43,67.99 366.17,67.99 366.56,67.59 366.56,64.79 366.37,64.6 365.31,64.6 365.15,64.77 365.15,66.46 364.97,66.64 364.34,66.64 363.72,67.26 363.72,69.32 363.81,69.4 364.01,69.4
+5VALW on BOTTOM (solid shape): 79.54,36.48 79.54,30.38 78.21,29.05 75.99,29.05 75.92,29.11 75.92,29.62 76.49,29.62 76.49,31.65 75.92,31.65 75.86,31.71 75.86,34.95 76.43,34.95 76.43,36.99 75.92,36.99 75.92,37.37 76.05,37.49 78.53,37.49
+5VALW on BOTTOM (solid shape): 173.76,26.49 173.76,25.54 174.5,24.79 175.66,24.79 175.66,24.79 176.82,24.79 177.14,24.48 177.14,23.7 176.94,23.5 172.72,23.5 172.61,23.61 172.61,25.28 172.6,25.28 172.6,25.44 172.13,25.91 171.91,25.91 171.59,26.23 171.59,26.69 171.78,26.87 173.37,26.87
+5VALW on BOTTOM (solid shape): 12.23,38.64 12.23,38.32 12.42,38.13 13.06,38.13 13.18,38 13.18,37.43 13.06,37.3 12.13,37.3 11.95,37.48 11.71,37.48 11.58,37.6 10.83,37.6 10.75,37.59 10.67,37.56 10.66,37.56 10.52,37.56 10.39,37.68 10.39,38.45 10.96,39.02 11.85,39.02
+5VALW on IN1 (solid shape): outline of 559 points within 91.1,21.36 177.9,26.78
+5VALW on IN2 (solid shape): 117.51,98.9 117.51,97.82 117.2,97.5 116.18,97.5 115.74,97.95 115.74,98.9 115.99,99.15 117.26,99.15
+5VALW on IN2 (solid shape): outline of 188 points within 76.56,23.33 95.35,33.11
+5VALW on IN3 (solid shape): 13.82,38.95 13.82,38 13.12,37.3 11.15,37.3 10.77,37.68 10.77,38.83 11.15,39.21 13.56,39.21
+5VALW on IN3 (solid shape): 43.79,56.35 43.79,54.45 43.47,54.13 42.9,54.13 42.65,54.38 42.65,56.35 42.71,56.42 43.73,56.42
+5VALW on IN4 (solid shape): 43.85,55.97 43.85,54.51 43.47,54.13 42.97,54.13 42.58,54.51 42.58,55.91 42.77,56.1 43.73,56.1
+5VALW on IN4 (solid shape): 79.41,33.3 79.41,30.51 79.03,30.13 75.99,30.13 75.6,30.51 75.6,33.43 75.86,33.68 79.03,33.68
+5VALW on IN5 (solid shape): 364.36,72.42 364.37,72.39 364.37,72.04 364.37,72.04 364.35,71.92 364.37,71.81 364.37,71.8 364.37,71.46 364.37,71.45 364.35,71.34 364.37,71.23 364.37,71.22 364.37,71.05 365.33,70.09 365.33,66.95 365.04,66.65 364.4,66.65 363.92,67.13 363.92,67.25 363.43,67.75 363.43,71.17 363.19,71.42 363,71.42 362.93,71.42 362.79,71.42 362.67,71.54 362.67,72.48 362.69,72.5 364.12,72.5 364.2,72.58
+5VALW on IN2: outline of 83 points within 172.89,23.43 260.39,32.16
+5VALW on VCC: outline of 112 points within 1.17,4.17 368.34,68.04
+5VALWP on BOTTOM (solid shape): outline of 170 points within 59.03,29.11 75.73,39.78
+5VALWP on IN4 (solid shape): 75.41,31.65 75.41,28.92 75.22,28.73 73.32,28.73 73.06,28.98 73.06,31.59 73.19,31.71 75.35,31.71
+5VS on TOP (solid shape): 111.48,30.89 111.48,29.76 111.28,29.56 109.77,29.56 109.56,29.77 109.56,31.06 109.7,31.21 111.16,31.21
+5VS on TOP (solid shape): 202.31,31.04 202.31,29.86 201.87,29.43 201.33,29.43 200.76,30 200.76,31.02 200.95,31.21 202.13,31.21
+5VS on TOP (solid shape): 287.19,70.96 287.19,69.24 286.87,68.93 280.9,68.93 280.71,69.12 280.71,70.64 282.42,72.35 285.79,72.35
+5VS on TOP (solid shape): 337.69,32.39 338.14,32.39 338.49,32.04 338.49,28.62 335.13,28.62 335.13,31.71 336.21,32.79 337.29,32.79
+5VS on TOP (solid shape): 266.26,48.26 266.26,44.7 265.53,43.97 259.63,43.97 258.61,44.99 258.61,48.02 259.09,48.5 260.66,48.5 260.67,48.51 266.01,48.51
+5VS on TOP (solid shape): 325.94,42.31 326.48,42.31 326.68,42.51 327,42.51 327.06,42.45 327.06,41.3 326.4,40.64 322.83,40.64 322.48,40.29 321.95,40.29 321.75,40.09 321.56,40.09 321.49,40.15 321.49,40.93 321.56,41 321.78,41 322.27,41.49 322.27,41.78 323.01,42.52 325.73,42.52
+5VS on TOP (solid shape): 256.43,36.73 256.43,35.8 256.2,35.56 256.2,35.02 255.63,35.02 255.63,34.19 256.2,34.19 256.2,33.81 255.63,33.81 255.63,32.98 256.2,32.98 256.2,32.41 256.45,32.16 256.9,32.16 257.02,32.03 257.02,31.02 256.9,30.89 254.42,30.89 254.17,31.14 254.17,35.21 255.42,36.46 255.42,36.77 255.53,36.88 256.28,36.88
+5VS on TOP (solid shape): 102.66,63.97 102.66,63.66 101.39,62.39 101.39,62.28 101.38,62.27 101.32,62.08 101.38,61.89 101.39,61.88 101.39,61.8 101.14,61.8 101.14,61.51 101.07,61.43 100.69,61.43 100.5,61.62 100.5,62.7 101,63.21 101,63.27 101.19,63.27 101.19,64.16 101,64.16 101,64.23 101.07,64.29 102.34,64.29
+5VS on TOP (solid shape): 310.01,50.92 310.09,50.86 310.18,50.83 310.19,50.83 310.27,50.75 310.27,49.65 309.76,49.65 309.76,48.76 310.27,48.76 310.27,47.73 309.74,47.73 309.23,48.24 307.3,48.24 307.16,48.38 307.16,50.52 307.38,50.74 307.42,50.71 307.77,50.61 308.02,50.88 308.03,50.92
+5VS on BOTTOM (solid shape): 369.8,114.2 369.8,112.8 369.67,112.68 368.4,112.68 368.34,112.74 368.34,114.65 368.4,114.71 369.29,114.71
+5VS on BOTTOM (solid shape): 257.02,32.54 257.02,30.95 256.64,30.57 249.02,30.57 248.96,30.63 248.96,32.03 249.09,32.16 252.64,32.16 253.21,32.73 256.83,32.73
+5VS on BOTTOM (solid shape): 339.8,14.96 339.8,14.07 339.04,13.31 338.06,13.31 337.88,13.48 337.88,14.25 337.99,14.36 338.49,14.36 339.16,15.03 339.73,15.03
+5VS on BOTTOM (solid shape): 86.45,62.89 86.45,61.68 86.46,61.68 86.46,61.59 86.54,61.5 86.54,60.48 86.42,60.35 85.53,60.35 85.43,60.45 85.43,61.64 85.51,61.72 85.51,62.87 85.63,62.99 86.35,62.99
+5VS on BOTTOM (solid shape): 172.36,131.09 173.39,131.09 173.52,130.97 173.52,130.84 173.39,130.71 172.06,130.71 171.87,130.9 171.04,130.9 170.79,130.65 170.79,129.19 170.73,129.12 170.28,129.12 170.06,129.35 170.06,131.63 170.09,131.66 171.78,131.66
+5VS on BOTTOM (solid shape): 172.12,139.92 172.95,139.92 173.08,139.79 173.08,139.6 173.01,139.54 171.81,139.54 171.43,139.92 170.66,139.92 170.47,139.73 170.47,139.22 170.16,138.9 169.84,138.9 169.71,139.03 169.71,140.62 169.84,140.74 171.3,140.74
+5VS on BOTTOM (solid shape): 201.4,32.07 201.4,31.52 201.65,31.27 202.1,31.27 202.29,31.08 202.29,29.95 202.05,29.71 201.42,29.71 201.27,29.56 199.1,29.56 198.89,29.77 198.89,31.91 199.11,32.13 201.33,32.13
+5VS on BOTTOM (solid shape): 363.83,87.28 364.97,87.28 365.13,87.12 365.13,85.47 364.97,85.31 364.9,85.31 364.89,85.31 364.74,85.34 364.6,85.31 364.59,85.31 364.31,85.31 364.3,85.31 364.16,85.34 364.01,85.31 364,85.31 363.2,85.31 363.01,85.5 363.01,87.53 363.13,87.66 363.45,87.66
+5VS on BOTTOM (solid shape): 173.46,119.09 173.97,118.58 174.1,118.58 174.92,118.58 175.04,118.46 175.04,118.26 174.98,118.2 173.77,118.2 173.65,118.33 173.51,118.33 172.9,118.33 172.76,118.33 172.63,118.2 172.63,116.7 172.57,116.64 171.94,116.64 171.79,116.48 171.79,115.22 171.78,115.21 172.28,114.71 174.35,114.71 174.6,114.46 174.67,114.45 175.3,114.45 175.43,114.33 175.43,113.44 175.36,113.38 173.85,113.38 173.83,113.4 173.58,113.55 173.34,113.4 173.32,113.38 171.3,113.38 170.84,113.83 170.84,117.82 171.68,118.66 172.08,118.66 172.52,119.09 172.96,119.09
+5VS on IN1 (solid shape): 323.13,42.26 323.13,40.73 322.56,40.16 321.92,40.16 320.84,41.24 320.84,42.45 321.16,42.76 322.62,42.76
+5VS on IN1 (solid shape): 309.92,49.11 309.92,47.15 309.6,46.83 307.32,46.83 307.06,47.08 307.06,49.11 307.25,49.3 309.73,49.3
+5VS on IN2 (solid shape): 257.02,31.33 257.02,30.57 256.39,29.94 255.06,29.94 254.99,30 254.99,31.08 255.37,31.46 256.9,31.46
+5VS on IN2 (solid shape): 202.73,32.48 202.73,30.7 202.6,30.57 201.21,30.57 201.14,30.64 201.14,32.41 201.33,32.6 202.6,32.6
+5VS on IN2 (solid shape): outline of 414 points within 321.6,40.03 340.21,56.73
+5VS on IN3 (solid shape): 111.29,31.97 111.29,30.7 110.85,30.25 109.7,30.25 109.58,30.38 109.58,31.91 109.89,32.22 111.04,32.22
+5VS on IN3 (solid shape): 262.99,48.35 262.99,46.19 262.17,45.37 259.12,45.37 258.55,45.94 258.55,48.16 259.25,48.86 262.48,48.86
+5VS on IN3 (solid shape): 258.99,34.38 258.99,34.19 257.13,32.33 257.13,31.16 256.99,31.02 254.74,31.02 253.98,31.78 253.98,34.32 254.93,35.27 258.1,35.27
+5VS on IN3 (solid shape): 103.23,63.72 103.23,61.5 102.97,61.24 100.81,61.24 100.56,61.5 100.56,62.11 101.35,62.11 101.35,62.05 101.36,62 101.37,61.95 101.39,61.91 101.43,61.87 101.46,61.83 101.5,61.8 101.55,61.77 101.6,61.76 101.65,61.75 101.7,61.75 101.75,61.76 101.8,61.77 101.85,61.8 101.89,61.83 101.93,61.87 101.96,61.91 101.98,61.95 102,62 102.01,62.05 102.01,62.11 102,62.16 101.98,62.21 101.96,62.25 101.93,62.3 101.89,62.33 101.85,62.36 101.8,62.39 101.75,62.4 101.7,62.41 101.65,62.41 101.6,62.4 101.55,62.39 101.5,62.36 101.46,62.33 101.43,62.3 101.39,62.25 101.37,62.21 101.36,62.16 101.35,62.11 100.56,62.11 100.56,63.4 101.13,63.97 102.97,63.97
+5VS on IN5 (solid shape): 339.38,56.54 339.38,54.19 339.32,54.13 337.16,54.13 336.84,54.45 336.84,56.42 337.03,56.61 339.32,56.61
+5VS on IN5 (solid shape): 363.7,87.53 363.7,85.5 363.45,85.25 360.85,85.25 360.72,85.37 360.72,87.72 360.85,87.85 363.39,87.85
