# Allegro board Dell_Inspiron_15_7577_Compal_CKA50_CKF50_LA_E992P_Rev_1_0_BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
XDP_TMS: length 268.9
  IN1 w0.097: v2(304.15,28.74) 304.15,28.93 303.35,29.73 298.52,29.73 298.01,29.22 293.74,29.22 292.2,30.75 288.89,30.75 288.7,30.94 283.58,30.94 281.78,32.74 281.78,33.92 280.9,34.8 280.9,36.13 280.6,36.43 280.6,37.03 280.95,37.38 280.95,38.06 280.66,38.35 280.41,38.35 280.05,38.71 280.05,43.01 279.12,43.94 278.75,43.94 278.33,44.36 278.33,46.06 277.93,46.46 277.93,49.53 276.59,50.87 276.59,59.1 275.94,59.75 274.74,60.96 265.82,60.96 263.34,63.44 227.94,63.44 227.35,64.03 226.54,64.03 225.23,62.72 220.66,62.72 219.39,61.46 214.63,61.46 213.97,60.8 212.74,60.8 212.18,60.25 209.39,60.25 208.87,60.76 195.7,60.76 191.41,65.06 190.97,65.49 190.97,66.32 190.36,66.93 v2(190.36,67.83)
  IN3 w0.124: v2(190.36,67.83) 190.36,65.75 184.44,59.83 182.46,59.83 v2(182.41,59.78)
  IN4 w0.137: v2(133.07,95.79) 133.07,92.62 125.24,84.79 125.24,66.89 132.35,59.78 v2(182.41,59.78)
  BOTTOM w0.127: v1(132.55,96.38) 133.07,95.86 v2(133.07,95.79)
  BOTTOM w0.14: JXDP1.58 196.87,66.56 196.65,66.33 195.7,66.33 195.45,66.59 195.45,68.33 194.38,69.39 191.92,69.39 v2(190.36,67.83) ; RH535.1 133.33,95.53 v2(133.07,95.79) ; RH538.1 300.98,29.76 301.5,29.24 303.82,29.24 304.15,28.91 v2(304.15,28.74)
XDP_TRST#: length 123.2
  IN3 w0.124: v2(190.96,67.83) 190.97,67.83 191.43,67.37 191.43,66.17 184.24,58.99 v2(183.36,58.99)
  IN4 w0.137: v2(132.63,98.96) 132.3,98.64 132.3,97.19 132.65,96.85 132.65,92.53 125,84.89 125,66.71 132.72,58.99 v2(183.36,58.99)
  BOTTOM w0.14: v2(190.96,67.83) 190.96,67.83 191.71,67.83 192.55,68.66 194.43,68.66 194.97,68.13 194.97,66.39 195.5,65.85 197.05,65.85 197.87,66.67 JXDP1.54 ; v2(132.63,98.96) RH536.1 132.39,99.9 v1(131.7,99.22)
XTAL24_IN: length 6.4
  BOTTOM w0.14: UH2.A6 294.45,52.25 v2(295.54,53.35) 295.88,53.69 299.86,53.69 RH569.1
XTAL24_IN_R: length 5.8
  BOTTOM w0.14: YH2.1 302.91,50.74 301.84,50.74 301.38,51.2 CH47.1 300.03,52.17 RH72.1 RH569.2
XTAL24_OUT: length 7.8
  BOTTOM w0.14: RH570.1 299.67,49.9 299.38,50.19 299.38,51.89 299.37,51.91 299.37,52.3 298.81,52.86 295.76,52.86 UH2.A5
XTAL24_OUT_R: length 3.5
  BOTTOM w0.14: RH72.2 299.95,51.2 RH570.2 300.86,50.49 CH48.1 301.33,50.34 302.02,49.64 YH2.3
XTALIN: length 6.2
  BOTTOM w0.14: YG1.1 195.62,84.78 CG75.2 197.57,84.78 RG99.1 199.09,84.81 UG9.BL6
XTALOUT: length 7.2
  BOTTOM w0.14: YG1.3 194.68,83.92 CG76.2 197.57,83.92 RG99.2 199.3,83.9 UG9.BM6
XTALOUTBUFF_R: length 10.7
  BOTTOM w0.089: 199.18,82.5 199.42,82.5 199.75,82.83 201.14,82.83 201.45,83.14 UG9.BK6
  BOTTOM w0.14: RG98.1 196.13,77.07 196.13,80.99 197.64,82.5 199.18,82.5
XTALSSIN: length 1.6
  TOP w0.089: v1(201.36,83.31) 201.49,83.45 v2(201.85,83.45) 201.86,83.46 RG101.1
  BOTTOM w0.114: UG9.BJ6 v2(201.85,83.45)
XTLI: length 3.7
  BOTTOM w0.14: YL2.1 21.85,45.61 CL36.1 21.93,45.54 UL1.29
XTLO: length 6.1
  BOTTOM w0.14: YL2.3 18.91,43.41 19.98,44.48 21.65,44.48 CL37.1 22.31,45.14 v1(22.99,45.14) UL1.28
N06177: length 3
  TOP w0.14: UP2.36 330.53,43.04 v1(329.55,42.07) RP32.1
N10178: length 2.4
  TOP w0.14: UP2.40 333.05,41.51 331.9,40.36 RP45.1
N16840: length 6.7
  TOP w0.14: UP2.9 337.78,46.24 338.6,47.06 338.86,47.06 339.47,47.67 v1(339.47,48.02) 339.47,48.84 340.46,49.82 341.22,49.82 RP11.1
N16946088: length 5.4
  TOP w0.089: v1(211.18,82.93) 211.04,82.79 RG546.2 209.79,82.01 209.35,82.45 QG23.5 QG23.6 208.37,82.78 RG584.2
N17036389: length 4.3
  TOP w0.127: v1(62.46,57.14) R2.1
  TOP w0.254: QZ13.6 65.58,57.14 R2.1
N17731278: length 30.8
  TOP w0.14: QG502.3 227.55,65.25 227.73,65.08 227.73,62.3 227.45,62.03 RG505.2 226.73,62.03 226.71,62.04 DG3.1 225.73,62.04 225.59,62.18 225.59,62.25 226.07,62.73 226.07,65.85 224.99,66.92 222.39,66.92 219.55,69.76 217.46,69.76 215.56,71.67 215.56,73.99 214.05,75.5 RG580.2 215.06,78.13 v1(215.23,77.97)
N18094620: length 14.5
  TOP w0.508: CL33.1 22.01,78.7 v1(22.01,75.94) RL40.2 RL39.2 RL20.2 RL19.2
N18094850: length 5.4
  BOTTOM w0.127: v1(20.63,48.35) 21.11,48.83 22.3,48.83 RL31.2
  BOTTOM w0.203: UL1.31 23.86,46.34 23.66,46.54 23.66,46.54 23.61,46.6 23.61,47.53 RL31.2
N18095026: length 5.2
  BOTTOM w0.14: UL1.27 23.73,44.74 22.37,43.37 22.37,42.23 21.55,41.42 T944.1
N18702920: length 5.2
  TOP w0.127: PR6070.2 v1(150.42,135.17)
  TOP w0.254: PR6070.2 152.82,135.17 PC6008.1 153.06,134.57 v2(152.76,134.27)
  BOTTOM w0.254: PC6006.1 PR6022.2 152.81,134.22 v2(152.76,134.27)
N18703353: length 1.5
  BOTTOM w0.14: v1(117.45,98.97) 117.45,98.35 116.85,97.75 PL10V01.1
N19074610: length 10.1
  TOP w0.14: PC813.1 v1(240.93,50.43)
  TOP w0.254: PR810.2 PR811.1 233.67,49.25 233.96,48.96 237.15,48.96 PQ802.2 238.62,50.43 PC813.1
N19094984: length 2.1
  TOP w0.14: PR815.1 234.54,49.82 v1(234.15,49.43)
  TOP w0.254: PC814.2 PR815.1
N19094987: length 4.7
  TOP w0.14: PR814.1 233.67,53.28 233.35,53.6 232.61,53.6 v1(232.11,54.1)
  TOP w0.254: PR815.2 PR807.2 233.7,52.2 PR813.2 233.67,53.1 PR814.1
N19147847: length 3.5
  TOP w0.14: v1(236.77,49.39) PQ802.1
  TOP w0.254: PR812.2 236.77,52.86 PQ802.1
N19180417: length 3.7
  TOP w0.254: PR5227.1 168.67,117.88 v2(169.63,117.88)
  BOTTOM w0.254: PL5203.2 167.97,118.24 168.33,117.88 v2(169.63,117.88)
N19180429: length 4.3
  TOP w0.254: v2(169.67,117.26) 168.54,117.26 PR5228.2
  BOTTOM w0.254: v2(169.67,117.26) 168.28,117.26 167.97,116.96 PL5203.3
N19209507: length 4.9
  TOP w0.127: R1.2 68.86,55.03 v1(69.46,55.63)
  TOP w0.14: QZ13.3 67.73,55.35 R1.2 68.05,55.02 R5.1 67.08,55.11 QZ13.2
N19212978: length 4.5
  TOP w0.14: RG543.2 195.33,61.67 195.33,63.06 v1(195.54,63.27) 195.86,63.59 QG509.6 196.62,63.29 196.76,63.15 197.08,63.15 197.27,63.34 QG509.5
N19213038: length 1
  BOTTOM w0.14: 241.31,71.47 241.31,71.11 v1(240.87,70.67)
N19213048: length 2.6
  BOTTOM w0.14: QG513.3 242.62,75.35 RG582.2 242.43,75.72 v1(241.48,76.67)
N19213104: length 3
  TOP w0.14: QG503.6 QG503.5 218.08,65.21 RG509.2 218.24,66.49 v1(218.16,66.56)
N19213111: length 1.1
  TOP w0.14: QG503.3 218.73,61.63 RG510.2
N19213121: length 2.8
  TOP w0.14: QG504.6 QG504.5 215.49,64.42 RG511.2 215.88,65.75 v1(216.41,65.75)
N19213130: length 2.4
  TOP w0.14: v1(216.68,60.33) 216.44,60.56 RG512.2 216.07,61.82 QG504.3
N19213140: length 2.8
  TOP w0.14: QG505.5 QG505.6 212.1,65.11 RG513.2 211.66,65.55 210.93,65.55 v1(210.92,65.56)
N19213149: length 2.3
  TOP w0.14: v1(213.68,60.39) 213.22,60.85 RG514.2 213.4,61.62 QG505.3
N19213165: length 2.1
  TOP w0.14: QG509.3 197.92,60.8 RG544.2 198.04,59.83 v1(197.91,59.69)
N19616464: length 20
  TOP w0.381: v2(206.65,87.65) 206.65,87.19 CG230.1
  IN5 w0.381: v2(206.65,87.65) 206.65,84.91 205.4,83.66 205.4,79.53 205.97,78.96 v2(207.3,78.96)
  BOTTOM w0.14: v1(211.65,77.28) 211.25,76.88 LG4.2
  BOTTOM w0.25: UG9.BC12 v2(206.65,87.65)
  BOTTOM w0.381: LG4.2 210.53,76.3 210.33,76.5 CG232.1 209.04,76.5 208.89,76.35 CG231.1 208.07,76.55 208.74,77.22 208.74,77.74 208.01,78.46 207.79,78.46 v2(207.3,78.96)
N19616930: length 65.6
  TOP w0.089: v2(218.5,87) 218.25,87 v1(217.98,87.26)
  TOP w0.254: CG233.1 207.4,95.88 v2(207.4,96) ; CG234.1 218.5,87.16 v2(218.5,87) ; v2(224.8,108) 225.35,107.45 CG237.1
  TOP w0.457: CG239.1 201.18,86.39 201.88,86.39 202.33,86.84 CG238.1 CG236.1 204.05,87.03 CG235.1 205.95,87.07 v2(205.95,87.65)
  TOP w0.508: LG5.2 200.47,85.68 CG239.1
  IN1 w0.381: v2(207.4,96) 208.42,97.02 208.42,107.05 209.28,107.91 211.18,107.91 212.14,106.96 223.76,106.96 v2(224.8,108)
  IN4 w0.381: v2(205.95,87.65) 205.95,87.53 206.33,87.15 206.43,87.15 206.44,87.14 206.86,87.14 206.87,87.15 207.11,87.15 208.07,88.11 208.07,95.27 207.4,95.95 v2(207.4,96)
  BOTTOM w0.25: UG9.BB24 207.3,96 v2(207.4,96)
  BOTTOM w0.254: v2(224.8,108) 224.55,108.25 UG9.U42
  BOTTOM w0.381: UG9.BD12 205.65,87.09 205.98,86.77 206.6,86.77 207.07,87.24 208.02,87.24 208.31,87.53 218.14,87.53 218.42,87.24
N19810901: length 48.2
  TOP w0.14: RG160.1 223.41,63.24 v2(223.5,63.33)
  IN4 w0.137: v2(202.57,71.6) 201.64,71.6 200.57,70.53 199.9,70.53 199.58,70.21 199.58,68.46 200.19,67.85 200.19,66.01 199.87,65.69 199.87,62.08 201.23,60.72 201.23,60.25 202.47,59.01 202.95,59.01 204.04,57.91 207.49,57.91 208.34,57.07 211.63,57.07 212.57,58.02 216.95,58.02 217.29,57.68 217.64,57.68 219.43,59.47 219.43,60.66 222.09,63.33 v2(223.5,63.33)
  BOTTOM w0.14: v2(202.57,71.6) 202,72.16 201.46,72.16 v1(201.18,72.44) 200.08,73.55 UG10.4 200.07,73.63 200.76,74.32 200.76,74.57 200.76,74.58 200.76,75.62 RG537.1
N19810924: length 2.1
  TOP w0.089: RG19.1 203.85,84.37 v2(203.85,84.25) 203.85,84.1 v1(204.29,83.66)
  BOTTOM w0.114: UG9.BG8 v2(203.85,84.25)
N19810925: length 2.5
  TOP w0.089: v2(204.55,84.25) 204.68,84.12 RG20.1 v1(205.18,82.69)
  BOTTOM w0.114: UG9.BF8 v2(204.55,84.25)
N19825042: length 3.1
  TOP w0.102: 299.06,13.39 UE1.21
  TOP w0.14: 299.06,13.39 296.31,13.39 T4939.1
N19842722: length 1.8
  TOP w0.089: RG130.1 256.68,84.71 v2(256,84.71) v1(255.64,84.35)
  BOTTOM w0.089: UG5.J13 v2(256,84.71)
N19842724: length 2.2
  TOP w0.089: v2(256.4,74.13) v1(256.4,73.45)
  TOP w0.254: RG126.1 256.73,74.47 v2(256.4,74.13)
  BOTTOM w0.254: UG5.J1 v2(256.4,74.13)
N19842731: length 2
  TOP w0.089: RG128.1 256.96,80.75 v2(256.35,81.36) v1(255.8,81.36)
  BOTTOM w0.089: UG5.J10 256.4,81.41 v2(256.35,81.36)
N19862793: length 4.7
  BOTTOM w0.089: 246.46,136.35 244.9,136.35 UG4.J13
  BOTTOM w0.14: v1(249.06,136.35) RG120.1 246.46,136.35
N19862795: length 2.1
  TOP w0.089: 233.82,135.95 v2(234.3,135.95) 234.65,135.95 v1(234.79,135.81)
  TOP w0.114: 233.65,135.79 233.82,135.95
  TOP w0.14: 233.65,135.79 233.59,135.72 RG116.1
  BOTTOM w0.254: UG4.J1 234.33,135.98 v2(234.3,135.95)
N19862800: length 1.8
  TOP w0.089: RG118.1 241.49,135.84 v2(241.58,135.93) v1(242.09,135.93)
  BOTTOM w0.089: UG4.J10 241.63,135.98 v2(241.58,135.93)
N19863158: length 3.1
  BOTTOM w0.14: RG122.1 v1(261.05,124.05) 261.48,124.47 QG3.1
N19863255: length 3
  TOP w0.089: v2(258.03,119.57) 258.86,120.4 258.86,120.65
  TOP w0.14: 258.86,120.65 v1(258.86,120.67) 258.86,121.5 RG119.1
  BOTTOM w0.089: UG3.J13 v2(258.03,119.57)
N19863256: length 1.5
  TOP w0.089: v2(258.43,108.99) 258.43,108.38
  TOP w0.14: RG115.1 258.43,108.03 258.43,108.38
  BOTTOM w0.254: v2(258.43,108.99) 258.43,108.99 UG3.J1
N19863260: length 3.6
  TOP w0.254: RG117.1 v1(257.98,114.29) 257.98,115.79 v2(258.43,116.23)
  BOTTOM w0.254: UG3.J10 v2(258.43,116.23)
N19864349: length 2.5
  TOP w0.254: RG109.1 v1(210.97,135.97) 210.65,135.97 v2(210.26,135.58)
  BOTTOM w0.254: UG2.J13 v2(210.26,135.58)
N19864351: length 1.9
  TOP w0.089: v2(199.61,135.95) v1(200.14,135.95)
  TOP w0.254: RG105.1 199.49,135.84 v2(199.61,135.95)
  BOTTOM w0.254: UG2.J1 199.63,135.98 v2(199.61,135.95)
N19864356: length 1.9
  TOP w0.089: v1(206.91,135.42) v2(206.91,135.93)
  TOP w0.381: RG107.1 206.41,136.43 v2(206.91,135.93)
  BOTTOM w0.254: UG2.J10 206.96,135.98 v2(206.91,135.93)
N19864714: length 3.4
  BOTTOM w0.14: v1(216.85,136.72) 216.85,137.28 QG2.1 215.17,136.55 RG111.1
N19864859: length 2.1
  TOP w0.089: RG108.1 v1(218.85,135.8) 219.1,135.8 v2(219.33,135.58)
  BOTTOM w0.089: UG1.J13 v2(219.33,135.58)
N19864860: length 3
  TOP w0.14: v2(229.93,135.98) 230.22,136.27 v1(230.72,136.27) 231.08,136.27 231.49,135.86 RG104.1
  BOTTOM w0.254: UG1.J1 229.92,135.98 v2(229.93,135.98)
N19864864: length 2.2
  TOP w0.089: v1(223.21,135.93) v2(222.68,135.93)
  TOP w0.381: 222.36,135.61 RG106.1
  TOP w0.4: v2(222.68,135.93) 222.36,135.61
  BOTTOM w0.089: UG1.J10 222.62,135.98 v2(222.68,135.93)
N20335974: length 3.8
  BOTTOM w0.14: UL2.3 22.63,51.59 22.86,51.36 22.86,50.78 RL41.1 21.21,50.21 v1(20.88,49.88)
N20539566: length 8.8
  BOTTOM w0.089: UG9.BK23 201.3,95.05 200.95,94.71 200.65,94.71 199.49,93.55 199.49,93.47 199.18,93.16 ; RG26.1 197.72,90.62
  BOTTOM w0.14: RG26.1 198.34,90.62 198.86,91.14 198.86,91.85 199.08,92.08 199.08,93.06 199.18,93.16 ; v1(197.68,88.76) 197.38,89.06 197.38,90.38 197.63,90.62 197.72,90.62
N20810959: length 2.3
  TOP w0.14: PR34.2 v1(62.82,22.46)
  TOP w0.254: PR34.2 62.75,23.5 PQ9.1
N20810969: length 5.4
  TOP w0.14: v1(57.28,23.22) 57.28,23.51 57.99,24.22 PR35.2
  TOP w0.254: PC16.2 61,25.83 60,24.83 60,24.26 59.88,24.15 PQ9.2 58.48,24.15 PR35.2
N20810972: length 4.8
  TOP w0.254: PC16.1 60.06,25.86 59.81,25.61 v1(59.02,25.61) 58.8,25.61 58.28,26.13 PC15.1 57.47,26.5 57.47,26.93 PR32.2 56.8,27.08 56.79,27.08 PQ7.3
N20905578: length 7.8
  TOP w0.14: v2(361.71,71.72) 361.71,71.28 v1(361.48,71.06)
  IN3 w0.124: v2(361.71,71.72) 361.71,72.06 362.9,73.26 363.21,73.26 364.41,74.47 364.41,75.14 v2(363.77,75.78)
  BOTTOM w0.076: v2(361.71,71.72) 361.8,71.72 361.94,71.58 UT4.H7
  BOTTOM w0.14: v2(363.77,75.78) 363.91,75.78 CT104.1
N21092291: length 21
  TOP w0.127: v2(25.57,37.75) 25.57,38.12 v1(25.43,38.26)
  TOP w0.254: PR24.1 26.24,37.75 v2(25.57,37.75) ; PQ8.1 v2(34.39,49.84)
  IN4 w0.254: v2(34.39,49.84) 34.16,49.61 32.77,49.61 30.07,46.92 29.63,46.92 28.77,46.05 28.77,44.69 28.23,44.16 28.23,43.08 27.76,42.61 27.76,38.48 27.03,37.75 v2(25.57,37.75)
N21092399: length 42.6
  TOP w0.254: v2(54.9,27.97) 54.95,28.02 PQ7.6 ; v2(24.88,35.11) 24.88,36.17 v1(25.4,36.69) PR25.2
  IN2 w0.254: v2(24.88,35.11) 27.57,35.11 28.32,34.36 28.32,32.39 36.4,24.31 53.86,24.31 55,25.45 55,27.87 v2(54.9,27.97)
N21092759: length 2.3
  TOP w0.203: PR732.2 31.37,36.9 v1(31.46,36.99) 31.71,37.24 31.71,37.32 32.07,37.67 PU700.13
N21092763: length 4
  TOP w0.14: PR733.2 30.56,36.01 v1(30.56,34.83)
  TOP w0.203: PU700.14 32.22,37.27 32.09,37.14 32.09,36.53 31.6,36.03 PR733.2
N21092894: length 2.7
  TOP w0.14: v1(80.44,51.17) 80.8,50.81 PQ305.3 81.95,50.63 PR315.2
N21094566: length 3.2
  TOP w0.203: PU5000.46 136.47,142.46 v2(136.08,142.85)
  BOTTOM w0.127: v2(136.08,142.85) 136.08,142.73 v1(135.57,142.22)
  BOTTOM w0.254: PR5000.2 135.27,143.46 135.88,142.85 v2(136.08,142.85)
N21094590: length 4.5
  TOP w0.203: v2(138.93,142.97) 138.59,142.63 138.59,142.42 138.47,142.31 PU5000.41
  BOTTOM w0.14: v1(140.15,141.37) 139.6,141.91 PC5003.1
  BOTTOM w0.254: PR5005.1 v2(138.93,142.97) 138.93,141.93 PC5003.1
N21094642: length 2.9
  TOP w0.254: PR5006.1 PR5007.1 v2(136.18,145)
  BOTTOM w0.127: v2(136.18,145) v1(135.71,145.47)
  BOTTOM w0.254: PR5007.1 v2(136.18,145)
N21094652: length 2.8
  TOP w0.254: PR5008.1 137.9,144.38 PR5009.1 v2(137.07,144.99)
  BOTTOM w0.127: v1(137.31,145.48) 137.07,145.24 v2(137.07,144.99)
  BOTTOM w0.254: PR5009.1 v2(137.07,144.99)
N21094662: length 3.7
  TOP w0.102: 139.23,145.16 v2(139.17,145.1)
  TOP w0.14: v1(139.88,145.44) 139.51,145.44 139.23,145.16
  TOP w0.254: v2(139.17,145.1) 139.03,144.96 PR5012.1
  BOTTOM w0.254: v2(139.17,145.1) 139.64,145.1 139.84,144.9 PR5003.2 140.25,144.08 PR5011.1
N21094718: length 1.8
  TOP w0.203: PU5000.44 137.27,143.26 PR5009.2
N21094756: length 6.8
  TOP w0.14: v1(129.86,144.68) 130.01,144.68 130.91,143.78 PR5028.2
  TOP w0.203: 134.31,141.14 134.51,140.93 PU5000.1
  TOP w0.254: 134.31,141.14 133.73,141.72 133.57,141.72 132.86,142.43 132.86,142.82 132.55,143.13 131.83,143.13 131.25,143.71 PR5028.2
N21094764: length 5
  TOP w0.14: PR5015.2 133.01,143.56 v1(132.12,143.56)
  TOP w0.203: PR5015.2 PR5020.2 134.81,142.71 135.58,142.71 136.07,142.21 PU5000.47
N21094776: length 4.3
  TOP w0.203: PU5000.48 135.67,142.01 135.56,142.13 133.92,142.13 v2(133.52,142.53)
  BOTTOM w0.127: v2(133.52,142.53) 133.61,142.53 134.06,142.08 v1(134.12,142.08)
  BOTTOM w0.254: v2(133.52,142.53) 133.26,142.79 PR5023.2
N21094960: length 1.6
  BOTTOM w0.254: PR5102.2 149.39,129.12 149.65,128.87 PU5101.1
N21094970: length 1.6
  BOTTOM w0.254: PR5104.2 150.29,129.45 150.15,129.31 PU5101.2
N21095023: length 3
  BOTTOM w0.127: v1(138.98,129.56) PR5114.2
  BOTTOM w0.254: PR5114.2 141.05,128.5 PU5102.1
N21232186: length 2.1
  BOTTOM w0.508: v2(335.48,10.68) v1(335.48,9.87) RA2.2
N21239155: length 3.5
  TOP w0.14: RA58.2 333.13,22.48 v1(333.95,21.67)
  TOP w0.508: RA58.2 333.13,24.12 QA1.3
N26668634: length 3
  TOP w0.14: v1(216.51,132.04) 216.54,132.08 RG523.2 RG102.2 216.13,134.43 CG313.1
N26671206: length 3.2
  TOP w0.14: v1(213.97,135.22) 213.74,134.99 RG524.2 RG103.2 213.74,132.19 CG314.1
N26672234: length 3.9
  TOP w0.14: v1(256.71,124.37) 256.97,124.11 256.97,123.4 256.78,123.2 RG113.2 RG525.2 257.88,122.58 CG315.1
N26672631: length 2.8
  BOTTOM w0.14: v1(249.85,133.18) RG114.2 RG526.2 248.83,134.1 CG316.1
N26673021: length 3
  TOP w0.14: v1(259.44,87.85) 259.32,87.97 CG317.1 257.5,87.97 RG527.2 RG124.2
N26673418: length 3.1
  TOP w0.14: RG125.2 RG528.2 254.42,91.02 CG318.1 253.49,91.14 v1(253.16,90.81)
N26979734: length 2.1
  BOTTOM w0.14: RG133.1 v1(258.22,91.15) 258.61,90.75 QG4.1
N27381541: length 3.5
  BOTTOM w0.14: UG11.9 224.88,76.9 224.33,77.45 v1(223.44,77.45) 222.66,77.45 RG529.1
N29418337: length 2.2
  TOP w0.14: PC5009.2 127.74,137.32 v1(127.18,136.76)
  TOP w0.254: PC5009.2 128.23,137.27 PR5025.1
N29418339: length 9
  TOP w0.14: v2(130.67,137.24) 130.67,136.49 v1(130.58,136.4)
  TOP w0.203: PU5000.5 134.04,139.33 133.83,139.54 v2(133.54,139.54)
  TOP w0.254: v2(130.67,137.24) 130.08,137.24 PR5025.2 130,137.31 PR5031.1 130.03,138.22 PR5022.1
  IN2 w0.254: v2(133.54,139.54) 133.53,139.55 132.27,139.55 130.67,137.95 v2(130.67,137.24)
N29418355: length 0.9
  TOP w0.254: PR5046.2 135.59,132.67 PC5034.2
N29418359: length 6.9
  TOP w0.203: PU5000.17 137.27,135.07 137.07,134.87 137.07,134.27 136.87,134.06 136.07,134.06 PR5046.1
  TOP w0.254: PR5046.1 PR5050.2 134,133.59 v2(133.99,133.58)
  BOTTOM w0.14: PR5049.1 v1(134.63,134.98)
  BOTTOM w0.254: PR5049.1 v2(133.99,133.58)
N29418369: length 2.2
  TOP w0.14: PC5015.1 v1(145.99,137.96)
  TOP w0.254: PR5032.2 143.82,137.96 PC5015.1
N29418371: length 14
  TOP w0.254: PR5048.2 135.57,130.85 PR5045.1 136.48,130.84 v1(137.45,130.84) 138,130.84 v2(138.08,130.91)
  IN2 w0.254: v2(147.93,131.22) 147.04,132.11 139.27,132.11 v2(138.08,130.91)
  BOTTOM w0.254: PH5004.2 v2(147.93,131.22)
N29418373: length 4.6
  TOP w0.203: PU5000.30 141.44,138.53 141.56,138.42 142.15,138.42 v2(142.19,138.38)
  TOP w0.254: PR5033.1 PR5032.1 142.69,137.95 142.25,138.38 v2(142.19,138.38)
  BOTTOM w0.14: v2(142.19,138.38) 142.08,138.38 141.82,138.13 v1(141.82,138.03)
  BOTTOM w0.254: PR5036.1 142.6,138.38 v2(142.19,138.38)
N29418377: length 7.9
  TOP w0.203: v2(135.93,134.52) 135.93,134.66 136.47,135.21 PU5000.15
  TOP w0.254: PR5045.2 136.81,131.77 v2(137.25,131.32)
  IN1 w0.254: v2(135.93,134.52) 135.93,134.2 136.56,133.57 136.56,131.65 136.89,131.32 v2(137.25,131.32)
  BOTTOM w0.127: v2(137.25,131.32) 137.8,131.32 v1(137.84,131.37)
  BOTTOM w0.254: v2(137.25,131.32) 136.86,130.93 PC5037.2
N29418393: length 23.7
  TOP w0.254: PR5014.1 130,142.83 PR5013.2 128.44,142.12 128.44,140.93 126.21,138.71 v1(125.44,138.71) v2(124.37,138.71)
  IN1 w0.254: v2(121.9,125.31) 122.91,126.33 122.91,135.41 124.37,136.87 v2(124.37,138.71)
  BOTTOM w0.254: v2(121.9,125.31) 122.34,125.31 122.66,125 PH5000.2
N29418395: length 5.6
  TOP w0.203: PC5006.2 132.21,141.89 v1(132.37,141.72) 133.35,140.74 133.64,140.74 134.25,140.13 PU5000.3
  TOP w0.254: PC5006.2 130.92,141.94 PR5014.2
N29418397: length 5.1
  TOP w0.203: PR5021.2 132.48,140.06 132.64,140.22 v1(133.36,140.22) 133.66,140.22 134.14,139.73 PU5000.4
  TOP w0.254: PC5005.2 130.06,140.06 PR5021.2
N29418405: length 5.8
  TOP w0.14: PR5026.1 v1(145.31,143.41)
  TOP w0.203: PU5000.36 141.17,140.93 141.3,141.06 141.3,141.62 141.75,142.07 142.23,142.07 143.08,142.92 143.24,142.92 PR5026.1
N29418417: length 3.4
  TOP w0.203: PU5000.33 141.56,139.73 v1(142.02,140.2) 142.28,140.2 PR5024.1 PC5010.2
N29418423: length 5.2
  TOP w0.203: PU5000.29 141.35,138.13 141.43,138.05 141.79,138.05 v2(142.24,137.6)
  BOTTOM w0.127: PC5021.2 140.54,137.65 v1(140.54,136.78)
  BOTTOM w0.254: PR5037.1 142.88,137.13 142.4,137.6 v2(142.24,137.6) 141.19,137.6 PC5021.2
N29418425: length 5.3
  TOP w0.14: v1(143.83,134.69) 143.05,135.46 v2(142.99,135.46)
  TOP w0.203: PC5020.1 142.34,136.65 142.34,136.85 141.46,137.73 PU5000.28
  TOP w0.254: v2(142.99,135.46) 142.89,135.56 PC5020.1
  BOTTOM w0.254: PC5020.1 142.89,135.56 v2(142.99,135.46)
N29418441: length 2.3
  TOP w0.203: PR5019.1 139.57,143.22 139.57,142.97 138.87,142.27 PU5000.40
N29418445: length 2.6
  TOP w0.203: PR5018.1 140.36,142.89 139.93,142.89 139.27,142.24 PU5000.39
N29418451: length 3.1
  TOP w0.203: PU5000.38 139.67,142.2 140.03,142.56 140.5,142.56 140.87,142.93 141.35,142.93 PR5017.1
N29418455: length 3.8
  TOP w0.203: PU5000.37 140.07,142.1 140.2,142.23 140.68,142.23 140.9,142.45 v1(141.97,142.45) 142.18,142.45 142.79,143.06 PR5016.1
N29418473: length 4.2
  TOP w0.203: PU5000.16 136.87,135.14 136.56,134.83 v2(136.56,134.52)
  BOTTOM w0.127: v2(136.56,134.52) 136.56,134.75 v1(135.98,135.33)
  BOTTOM w0.254: v2(136.56,134.52) 136.49,134.45 PR5051.1 136.47,133.61 PC5038.1
N29419473: length 4.3
  TOP w0.203: PU5000.2 134.37,140.53 133.67,141.24 v2(133.53,141.24)
  BOTTOM w0.127: v2(133.53,141.24) 133.67,141.24 v1(134.14,140.77)
  BOTTOM w0.254: v2(133.53,141.24) 133.53,141.09 133.27,140.84 PR5010.2 132.79,140.84 PC5004.2
N29419486: length 3.2
  TOP w0.203: PR5040.2 133.16,137.87 v1(133.74,137.87) 133.86,137.87 134.12,138.13 PU5000.8
  TOP w0.254: PC5019.2 132.83,139.11 PR5040.2
N29419576: length 2.1
  TOP w0.14: v1(131.97,140.45) 131.44,140.98 PR5021.1
  TOP w0.254: PC5007.2 130.09,140.98 PR5021.1
N29419623: length 2.8
  TOP w0.14: PR5034.2 v1(127.94,129.67)
  TOP w0.254: v2(128.21,127.76) 127.94,128.03 PR5034.2
  BOTTOM w0.254: PH5002.1 127.81,127.76 v2(128.21,127.76)
N29419647: length 3
  BOTTOM w0.14: PR5037.2 143.3,136.62 v1(141.9,136.62)
  BOTTOM w0.254: PR5037.2 PC5022.1
N29419655: length 2.2
  BOTTOM w0.14: v1(143.38,139.25) 143.81,138.82 PR5036.2
  BOTTOM w0.254: PR5036.2 PC5023.1
N29419663: length 2.3
  BOTTOM w0.14: PR5030.1 163.86,118.71 v1(164.33,119.18)
  BOTTOM w0.254: PR5030.1 PH5001.2
N29419667: length 2.6
  TOP w0.14: v2(154.79,118.96) v1(153.98,118.96)
  TOP w0.254: PR5044.1 154.99,119.17 v2(154.79,118.96)
  BOTTOM w0.254: PR5044.1 154.99,119.17 v2(154.79,118.96)
N29419693: length 0.9
  TOP w0.254: PC5019.1 131.88,139.11 PR5038.2
N29419730: length 2.7
  TOP w0.14: v1(145.54,142.05) 145.2,142.05 144.84,141.7 v2(144.55,141.7)
  TOP w0.254: PC5010.1 144.43,141.76 144.49,141.7 v2(144.55,141.7)
  BOTTOM w0.254: PR5027.2 144.22,141.37 v2(144.55,141.7)
N29419832: length 4.4
  TOP w0.203: PU5000.42 138.07,142.55 v2(138.13,142.61)
  BOTTOM w0.14: v1(136.25,141.1) 136.49,141.1 PC5002.1
  BOTTOM w0.254: PC5002.1 138,142.61 v2(138.13,142.61) 138.13,143.04 138.01,143.16 PR5004.2
N29419860: length 5.2
  TOP w0.203: PU5000.14 136.07,135.3 136.06,135.28 136.06,135.26 135.78,134.98 135.72,134.98 135.4,134.65 v1(134.63,134.65) 134.06,134.65 133.86,134.85 133.33,134.85 PC5036.2
  TOP w0.254: PR5047.1 132.83,135.35 PC5036.2
N29419910: length 0.9
  BOTTOM w0.254: PR5051.2 PC5040.2
N29419918: length 0.9
  BOTTOM w0.254: PC5039.1 PR5049.2
N29419943: length 3.3
  TOP w0.203: v1(138.49,134.55) 138.47,134.57 PU5000.20
  TOP w0.254: v1(138.49,134.55) 138.49,134.13 PC5033.1 139.04,133.58 PR5041.1
N29419947: length 3.2
  TOP w0.254: PC5033.2 138.7,132.67 138.42,132.39 v2(138.42,131.99)
  BOTTOM w0.14: v1(139.17,131.6) 138.81,131.6 v2(138.42,131.99)
  BOTTOM w0.254: PR5043.1 139.19,132.58 138.61,131.99 v2(138.42,131.99)
N29426641: length 3.2
  BOTTOM w0.14: v1(156.34,129.15) 157.06,129.15 PR5126.2
  BOTTOM w0.254: PR5126.2 157.82,129.43 157.82,129.16 158.32,128.66 PU5103.1
N29426805: length 2.1
  TOP w0.14: v1(152.9,120.86) 153.39,121.35 PR5106.2
N29426831: length 2.7
  TOP w0.14: PR5121.2 144.18,121.07 v1(144.87,120.39)
N29426855: length 1.7
  TOP w0.14: PC5134.1 162.41,119.73 v1(162.51,119.62)
N29435109: length 3.1
  TOP w0.14: v1(165.16,119.27) 165.84,119.94 PR5226.1
  vias: v2(166.85,121.82) v2(166.85,121.19) v2(167.44,121.19)
N29435335: length 1.7
  TOP w0.14: v1(166.98,120.17) 167.49,120.68 PC5232.1
N29436709: length 1.6
  TOP w0.14: PR5218.2 v1(125.64,128.59)
N29436789: length 4.8
  TOP w0.14: PR5206.2 123.29,118.27 v1(122.95,117.92)
  TOP w0.508: PR5206.2 125.07,118.77 v2(125.9,119.6)
  BOTTOM w0.508: PC5209.1 v2(125.9,119.6)
N29438561: length 2.7
  TOP w0.203: PU5000.43 137.67,142.81 137.94,143.07 138.37,143.07 138.88,143.58 PR5012.2
N29438571: length 2
  TOP w0.203: PR5007.2 136.87,142.77 PU5000.45
N29599145: length 2.7
  TOP w0.254: PR5022.2 128.67,139.1 v2(128.46,138.89)
  BOTTOM w0.127: PC5008.1 v1(129.13,140.31)
  BOTTOM w0.254: v2(128.46,138.89) 128.66,139.09 PC5008.1
N30070819: length 2.2
  TOP w0.089: v1(256.67,92.87) RG131.1 256.13,93.82 v2(256,93.95)
  BOTTOM w0.089: UG6.J13 256.39,94.35 v2(256,93.95)
N30070822: length 2
  TOP w0.089: RG127.1 256.27,104.68 v2(256.35,104.6) v1(256.35,104.09)
  BOTTOM w0.254: v2(256.35,104.6) 256.4,104.55 UG6.J1
N30070830: length 2.3
  TOP w0.089: v2(256.35,97.3) 256.35,97.92 RG129.1 v1(255.27,97.94)
  BOTTOM w0.254: UG6.J10 256.4,97.25 v2(256.35,97.3)
N30314421: length 4.2
  BOTTOM w0.14: UG12.12 216.73,73.4 216.75,73.42 216.75,74.82 CG64.1 216.65,74.97 217.15,75.47 217.15,76.52 v1(217.45,76.83)
N30314423: length 2.1
  BOTTOM w0.14: CG65.1 215.74,74.16 v1(215.6,74.02) 215.6,73.78 215.93,73.44 UG12.10
N30316777: length 3.7
  TOP w0.14: v1(223.09,66.04) 223.09,65.7 222.93,65.55 RG506.2 223.31,65.09 223.7,65.47 DG4.2 224.55,65.47 224.76,65.25 QG502.4
N30316795: length 5.8
  TOP w0.14: QG502.6 225.08,63.95 224.96,63.83 224.96,63.53 v2(225.07,63.41) ; v2(222.14,62.32) RG516.2 221.36,62.51 UG22.2
  BOTTOM w0.14: v2(225.07,63.41) 224.49,62.83 222.65,62.83 v2(222.14,62.32)
N30365509: length 2.6
  TOP w0.14: QG502.5 224.93,64.6 224.68,64.35 224.68,63.63 224.67,63.62 224.67,63.58 224.52,63.43 224.52,63.08 224.72,62.88 RG554.2
N30365512: length 8.2
  TOP w0.14: UG22.4 222.01,65.96 222.47,66.41 v1(224.61,66.41) 225.15,66.41 225.83,65.73 225.83,63.29 225.82,63.28 225.82,63.19 225.5,62.88 RG554.1
N30365520: length 22
  TOP w0.14: QG502.2 227.2,64.6 226.72,65.08 226.72,65.63 226.95,65.85 228.7,65.85 229.69,64.86 229.69,59.45 v1(229.37,59.13) 229.37,59.13 228.64,58.4 v2(228.43,58.4) ; v2(220.78,58.97) 220.66,58.85 219.62,58.85 219.05,58.28 RG553.2
  IN1 w0.097: v2(220.78,58.97) 220.89,58.85 227.92,58.85 228.37,58.4 v2(228.43,58.4)
N30373122: length 1.4
  TOP w0.14: RG545.1 204.65,64.07 UG26.4
N31306212: length 5.7
  TOP w0.254: PR5223.2 163.17,128.87 164.1,127.94 v1(164.16,127.94) 164.26,128.04 166.8,128.04 v2(166.94,127.9)
  BOTTOM w0.254: v2(166.94,127.9) 166.94,127.75 167.5,127.19 PU5203.1
N31425872: length 0.8
  TOP w0.127: v2(151.93,129.06) v1(151.93,128.29)
N31425874: length 1.8
  TOP w0.14: PC5102.1 150.93,131.22 150.32,131.83 v1(149.77,131.83)
N31425876: length 1.5
  TOP w0.127: PR5105.2 v1(154.12,129.82)
  vias: v2(152.57,129.06)
N31426527: length 5.1
  TOP w0.14: PR5101.2 146.57,128.52 146.57,129.16 v1(146.1,129.63)
  TOP w0.254: v2(148.15,127.24) 148.15,127.26 147.98,127.42 PC5101.1 147.98,127.98 PR5101.2
  BOTTOM w0.254: v2(148.15,127.24) 148.15,126.66 148.33,126.48 PU5101.24
N31427446: length 3.4
  TOP w0.127: v1(150.37,128.31) 150.66,128.6 v2(150.66,129.06)
  TOP w0.254: v2(150.66,129.06) 150.28,129.44 PC5100.2
  BOTTOM w0.254: PU5101.3 150.65,128.71 150.66,128.73 v2(150.66,129.06) 150.66,129.19 151.18,129.7 PR5100.1
N31433757: length 1.5
  TOP w0.14: v1(145.26,131.57) 144.65,131.57 144.3,131.22 PR5118.1
N31433760: length 1.7
  TOP w0.14: v1(141.42,128.93) 142.3,129.82 PC5115.2
  vias: v2(143.23,128.93)
N31433761: length 1
  TOP w0.14: v2(143.83,128.84) 143.23,128.23 v1(143.08,128.23)
N31434994: length 4
  BOTTOM w0.14: v1(140.47,131.55) 140.47,129.96 140.87,129.56 PR5117.2
  BOTTOM w0.254: PR5117.2 140.95,129.25 141.55,128.65 PU5102.2
N31436196: length 1.5
  TOP w0.14: v1(162.55,130.91) 162.24,131.22 PR5130.1
N31436215: length 0.9
  TOP w0.14: v1(159.84,128.55) 160.06,128.55 v2(160.57,129.06)
N31436218: length 2
  TOP w0.14: v2(161.2,129.06) 161.2,128.91 160.57,128.27 v1(160.57,127.31)
N31436380: length 1.6
  BOTTOM w0.254: PR5129.2 158.48,129.27 158.82,128.93 PU5103.2
N31438582: length 4
  TOP w0.14: v1(159.2,127.36) 158.84,127.71 PR5125.2
  TOP w0.254: v2(156.76,126.56) 157.29,126.56 PC5124.1 158.22,127.49 PR5125.2
  BOTTOM w0.254: PU5103.24 156.83,126.49 v2(156.76,126.56)
N31438896: length 3.5
  TOP w0.14: PC5125.2 v1(157.65,129.68)
  TOP w0.254: v2(159.32,129.06) 158.7,129.68 PC5125.2
  BOTTOM w0.254: PU5103.3 v2(159.32,129.06) 159.32,129.52 PR5127.1
N31439632: length 1.7
  BOTTOM w0.14: v1(114.03,118.74) 114.03,119.32 PC5202.1
N31439653: length 0.8
  TOP w0.14: v1(116.28,119.9) 116.6,120.22 v2(116.94,120.22)
N31439658: length 0.8
  TOP w0.14: v2(117.03,121.35) v1(116.26,121.35)
N31439736: length 2.5
  TOP w0.14: v2(116.96,118.38) 117.35,118.38 v1(117.62,118.11)
  BOTTOM w0.254: PU5201.2 117.38,118.68 117.08,118.38 v2(116.96,118.38) 116.57,117.99 PR5204.2
N31439790: length 2.9
  TOP w0.14: v1(116.22,117.15) v2(116.93,117.15)
  BOTTOM w0.254: PU5201.1 117.46,118.18 117.34,118.05 117.34,117.55 v2(116.93,117.15) 116.85,117.07 PR5202.2
N31442956: length 3.5
  TOP w0.14: v1(117.83,119.54) 117.26,118.96 v2(116.94,118.96)
  TOP w0.254: v2(116.94,118.96) 116.45,118.96 PC5200.2
  BOTTOM w0.254: PU5201.3 117.29,119.18 117.08,118.96 v2(116.94,118.96) 116.28,118.96 PR5200.1
N31442990: length 5.7
  TOP w0.14: v2(120.73,114.94) v1(121.69,114.94)
  TOP w0.254: PR5201.2 118.94,114.94 PC5201.1 v2(120.73,114.94)
  BOTTOM w0.254: PU5201.24 119.54,116.12 v2(120.73,114.94)
N31443441: length 4.3
  BOTTOM w0.127: PC5114.2 v1(142.91,131.78)
  BOTTOM w0.254: PU5102.3 142.05,129 141.9,129.15 PR5115.1 142.81,130.47 PC5114.2
N31452288: length 1.5
  BOTTOM w0.14: PC5213.1 114.06,127.27 v1(114.06,126.93)
N31452390: length 3.1
  TOP w0.14: v1(117.58,126.49) 117.27,126.49 v2(117.03,126.25)
  BOTTOM w0.254: PR5215.2 116.83,126.06 v2(117.03,126.25) 117.03,126.88 117.57,127.41 PU5202.2
N31459450: length 4.2
  TOP w0.14: v1(118.85,126.06) 118.58,125.8 v2(117.51,125.8)
  BOTTOM w0.254: PU5202.1 117.65,126.91 117.51,126.77 v2(117.51,125.8) 116.82,125.1 PR5213.2
N31459506: length 3.9
  TOP w0.14: v1(119,127.63) 118.81,127.43 PC5212.2
  TOP w0.254: PC5212.2 117.38,127.43 v2(117.13,127.69)
  BOTTOM w0.254: PR5214.1 116.49,127.01 117.13,127.64 v2(117.13,127.69) 117.34,127.69 117.56,127.91 PU5202.3
N31460044: length 7.2
  TOP w0.14: v2(118.17,125.33) 119.59,125.33 v1(120.11,125.85)
  TOP w0.254: PR5212.2 PC5211.1 117.01,125.31 118.15,125.31 v2(118.17,125.33)
  BOTTOM w0.254: v2(118.17,125.33) 119.37,125.33 119.69,125.65 PU5202.24
N31494164: length 0.8
  TOP w0.14: v2(167.5,129.4) 167.67,129.4 v1(168.14,128.93)
N31494196: length 1.1
  TOP w0.14: v1(169.66,127.31) 169.3,127.31 v2(168.81,127.8)
N31494209: length 1.1
  TOP w0.14: v2(169.55,127.96) v1(169.55,129.02)
N31494627: length 3
  TOP w0.14: v1(167.73,127.36) 167.73,127.32 166.8,126.39 PR5224.1
  TOP w0.254: PR5224.1 166.03,126.39 v2(166.03,126.39)
  BOTTOM w0.254: v2(166.03,126.39) 166.03,126.39 166.16,126.39 166.43,126.12 PU5203.12
N31495785: length 6.4
  TOP w0.254: PR5229.1 164.06,128.7 164.31,128.45 v1(166.6,128.45) 167.17,128.45 167.54,128.08 v2(167.54,127.92)
  BOTTOM w0.254: PC5230.2 167.43,128.25 167.43,128.03 v2(167.54,127.92) 167.54,127.7 168,127.24 PU5203.2
N31495969: length 3
  TOP w0.254: v2(165.98,125.81) 166.15,125.81 166.45,125.52 PR5230.2 166.75,125.52 PC5231.2
  BOTTOM w0.254: PU5203.11 166.3,125.62 166.1,125.81 v2(165.98,125.81)
N31528975: length 0.9
  TOP w0.14: v1(117.87,129.33) 117.46,128.92 v2(117.16,128.92)
N31528977: length 0.8
  TOP w0.14: v1(116.5,130.18) 116.5,130.1 v2(117.02,129.58)
N31565200: length 3.6
  TOP w0.14: v2(148.63,129.5) 148.63,129.53 v1(148.12,130.04)
  TOP w0.254: v2(148.63,129.5) 148.64,129.5 148.9,129.25 PR5103.1
  BOTTOM w0.254: v2(148.63,129.5) 148.63,128.84 148.9,128.58 PU5101.26
N31565645: length 3.5
  TOP w0.254: PR5116.1 137.4,127.29 v1(138.82,127.29) v2(139.49,127.29)
  BOTTOM w0.254: v2(139.49,127.29) PU5102.26
N31565698: length 5.4
  TOP w0.254: PR5113.2 136.06,126.84 PC5113.1 136.45,126.46 v1(137.38,126.46) v2(139.49,126.46)
  BOTTOM w0.254: v2(139.49,126.46) 139.65,126.29 PU5102.24
N31566286: length 3
  TOP w0.14: PR5128.1 156.93,128.1 v1(156.33,128.1)
  TOP w0.254: v2(156.76,127.16) 156.96,127.16 157.31,127.5 PR5128.1
  BOTTOM w0.254: PU5103.26 157.11,127.49 156.78,127.16 v2(156.76,127.16)
N31567454: length 2.4
  TOP w0.14: v2(118.54,116.61) 118.54,116.77 v1(118.94,117.16)
  TOP w0.254: PR5203.1 118.96,116.2 v2(118.54,116.61)
  BOTTOM w0.254: PU5201.26 v2(118.54,116.61)
N31567631: length 4.9
  TOP w0.14: v1(115.57,129.15) 116.32,128.4 PR5216.1
  TOP w0.254: v2(118.15,126.34) 118.15,126.72 117.95,126.93 117.2,126.93 116.32,127.8 PR5216.1
  BOTTOM w0.254: PU5202.26 118.33,126.16 v2(118.15,126.34)
N32834652: length 3.2
  TOP w0.14: RA19.1 343,15.41 343.6,14.81 v1(343.88,14.81)
  TOP w0.203: RA19.1 342.81,15.96 343.38,16.53 343.38,16.54 343.45,16.61 HDA1.16
N33138349: length 4
  BOTTOM w0.14: UG11.5 223.37,73.34 223.02,73.7 RG65.2 221.96,73.21 221.96,72.38 v1(222.62,71.72)
N33204017: length 5.7
  BOTTOM w0.089: UG9.BD2 205.91,80.35 206.03,80.23 206.03,79.52 206.66,78.89
  BOTTOM w0.14: 206.66,78.89 207.32,78.23 207.47,78.23 208.19,77.51 v1(208.19,77.45) 208.19,77.33 207.75,76.89 207.29,76.89 RG566.1
N34662854: length 9.9
  TOP w0.203: RA17.1 345.05,9.03 RA18.1 345.89,9.89 v1(345.89,10.62) 346.18,10.91 346.18,15.21 345.87,15.52 345.87,15.58 345.05,16.4 HDA1.20
N48676721: length 2.6
  BOTTOM w0.14: JBL1.2 192.75,29.66 192.44,29.96 192.44,30.65 v2(192.56,30.76) RE3.2
N48680518: length 7.9
  BOTTOM w0.14: QE4.2 116.86,25.94 RE1.1 118.47,25.92 CE1.1 118.92,25.06 v1(119.74,25.88) 120.46,26.59 QE3.1
N111798152: length 2.1
  TOP w0.14: UZ1.12 260.85,34.11 260.77,34.19 v1(260.77,34.81) CZ4.1
N111798158: length 2.3
  TOP w0.14: UZ1.10 261.65,34.18 262.05,34.58 v1(262.05,34.84) 262.05,35.5 CZ6.1
N120139517: length 3.8
  TOP w0.14: RH71.2 297.23,50.37 v2(297.31,50.45) 297.31,50.8 296.74,51.37 v1(296.74,51.93)
  BOTTOM w0.076: v2(297.31,50.45) 297.24,50.45 296.98,50.19 UH2.E1
N120176772: length 6.7
  BOTTOM w0.076: 274.23,44.81 274.32,44.81 274.97,44.16 275.29,44.16 UH2.V44
  BOTTOM w0.14: 274.23,44.81 274.14,44.81 273.51,45.44 269.83,45.44 T2.1
N120176822: length 11
  BOTTOM w0.076: UH2.BD36 279.26,30.89 278.72,30.34 278.72,29.52 278.3,29.1 276.72,29.1 276.36,29.45 275.65,29.45 275.63,29.43 274.55,29.43 274.23,29.11
  BOTTOM w0.14: T8.1 271.81,29.3 272,29.11 274.23,29.11
N120177456: length 2.9
  BOTTOM w0.076: UH2.BD17 288.65,30.61 288.65,29.56 287.8,28.7 287.8,28.48
  BOTTOM w0.14: T17.1 287.8,28.48
N120361004: length 5.2
  BOTTOM w0.14: JNGFF2.38 282.09,16.53 282.51,16.94 283.52,16.94 RD7.2 283.96,16.51 RD59.1 v1(283.96,14.21)
N120361079: length 4.1
  BOTTOM w0.14: v1(284.56,10.63) 284.56,10.14 RD9.1 283.74,9.32 282.42,9.32 282.12,9.03 JNGFF2.60
N122712620: length 4
  TOP w0.14: v2(272.64,8.79) RD58.2 273.52,10.02 v1(274,10.51)
  BOTTOM w0.14: v2(272.64,8.79) 272.66,8.78 JNGFF2.61
N122754354: length 1.4
  TOP w0.14: UZ16.6 226.96,53.44 CZ57.1
N124752685: length 2.3
  TOP w0.14: v1(110.67,59.65) RH211.1 110.7,58.29 CH101.2
N124753277: length 2.2
  TOP w0.14: RH212.1 220.12,33.28 CH100.2 219.17,34.21 v1(218.95,34.43)
N129020146: length 3.7
  TOP w0.14: CA29.1 v1(342.81,11.67) 342.81,11.15 RA33.1 344.29,9.67
N129172883: length 5.4
  BOTTOM w0.14: JDEG1.9 321.25,7.35 319.25,9.35 v1(319.25,10.24) 319.25,11.26 RE118.2
N129347215: length 3
  TOP w0.14: RH105.1 RH103.2 RH180.2 308.73,32.44 v1(308.81,32.53)
N130584913: length 2.3
  TOP w0.14: v2(288.32,35.42) 287.78,35.96 T92.1
  BOTTOM w0.076: UH2.AR17 288.86,35.42 v2(288.32,35.42)
N130960109: length 1
  BOTTOM w0.14: T3.1 323.89,13.34 RE111.1
N130982801: length 3.7
  BOTTOM w0.14: RL43.2 22.73,41.75 22.73,43.2 v1(23.02,43.48) 23.87,44.34 UL1.26
N131311358: length 4
  BOTTOM w0.127: v1(262.13,16.89) 262.65,17.41 RC11.1
  BOTTOM w0.508: DC2.2 264.44,18.73 263.74,18.04 RC11.1
N131432061: length 4
  TOP w0.14: QE24.5 280.84,9.48 280.7,9.34 280.29,9.34 280.19,9.44 QE24.6 280.19,10.37 280.12,10.43 RH506.2 279.24,10.89 v1(278.85,10.51)
N131440042: length 4
  TOP w0.14: RH504.2 219.78,58.29 QE20.3 QE20.2 220.8,58.36 221.55,59.11 v1(222.17,59.11)
N134045472: length 2.7
  BOTTOM w0.127: RZ33.2 v1(136.44,29.19)
  BOTTOM w0.14: RZ33.2 135.02,29.04 UE4.3
N134144050: length 4.8
  BOTTOM w0.14: QC5.3 255.96,24.8 255.77,24.61 255.51,24.61 255.31,24.81 255.31,25.54 255.44,25.67 RS39.2 254.89,26.69 254.89,27.58 v1(255.29,27.98)
N134147995: length 3.2
  BOTTOM w0.14: UTPM1.27 294.49,14.94 RTPM7.1 v1(294.96,16.68)
N134148044: length 0.9
  BOTTOM w0.14: v1(294.51,12.91) 294.3,12.69 294.3,12.09
N134148081: length 25.9
  IN2 w0.097: v2(285.17,21.86) 283.91,20.6 283.91,15.21 283.98,15.15 283.98,9.61 284.98,8.61 v2(287.17,8.61)
  BOTTOM w0.14: QTPM1.2 287.03,8.47 v2(287.17,8.61) ; v2(285.17,21.86) 285.59,22.28 285.59,23.03 285.88,23.32 287.92,23.32 288.27,22.97 288.27,21.55 288.52,21.3 288.52,20.37 288.71,20.18 289.52,20.18 289.66,20.04 RTPM8.2
N134155630: length 4.1
  BOTTOM w0.14: RI12.2 RI11.2 12.76,46.95 v1(12.55,47.16) 12.55,48.03 11.97,48.62 UI3.5
N134208615: length 0.6
  BOTTOM w0.127: 368.34,117.34 v1(367.72,117.34)
N134520421: length 196.8
  TOP w0.127: RH89.2 v1(269.84,43.86)
  TOP w0.14: RH89.2 v2(269.24,42.7)
  IN3 w0.124: 138.19,106.47 139.86,108.14 158.82,108.14 159.57,108.89 160.79,108.89 161.09,108.58 179.84,108.58 182.52,105.89 182.95,105.89 185.58,103.26 185.58,100.93 188.44,98.07 188.44,78.64 198.42,68.67 202.16,68.67 203.91,70.42 204.99,70.42 205.19,70.62 208.82,70.62 209.3,70.14 209.3,69.47 210.18,68.6 211.11,68.6 212.98,66.73 212.98,64.4 213.27,64.11 213.27,63.08 214.08,62.27 219.67,62.27 220.78,61.16 223.64,61.16 223.96,60.85 225.45,60.85 225.55,60.95 230.62,60.95 230.96,61.29 233.57,61.29 234.27,60.59 235.43,60.59 237.72,62.87 264.33,62.87 268.87,58.34 268.87,52.27 269.69,51.45 269.69,45.71 269.24,45.27 v2(269.24,42.7)
  IN3 w0.127: v2(138.58,101.47) 138.19,101.87 138.19,106.47
  BOTTOM w0.076: UH1.BR33 139.96,100.82 139.24,100.82 v2(138.58,101.47)
N134526648: length 7.8
  BOTTOM w0.254: RH28.1 158.23,109.18 RH29.1 159.47,109.76 160.2,109.76 161.18,108.77 v1(161.18,108.28) 161.18,105.14 161.16,105.12 UH1.AG38
N134526650: length 10.8
  BOTTOM w0.254: UH1.AG37 161.31,104.16 161.54,104.39 161.54,106.72 162.05,107.23 v1(162.05,109.3) 162.05,109.75 160.91,110.9 159.47,110.9 RH197.2 RH198.1
N134527394: length 4.6
  BOTTOM w0.114: 139.08,94.98 139.21,94.98 139.47,95.25 139.91,95.25 UH1.BR25
  BOTTOM w0.14: 139.08,94.98 138.82,94.72 138.82,93.68 138.23,93.09 RH57.2
N134527396: length 4.2
  BOTTOM w0.114: 139.03,95.87 139.17,96.01 140.62,96.01 UH1.BP25
  BOTTOM w0.14: RH58.2 138.03,94.87 139.03,95.87
N134527398: length 2.8
  BOTTOM w0.203: UH1.BT29 139.52,98.96 138.58,98.96 RH166.2
N134531257: length 3.6
  TOP w0.254: RH514.1 174.48,87.77 v2(174.48,87.73) 174.67,87.73 RH515.1
  BOTTOM w0.203: v2(174.48,87.73) 174.6,87.61 175.31,87.61 UH1.H14
N134531263: length 2.6
  TOP w0.254: RH516.1 174.97,87.14 v2(174.47,87.14) 174.36,87.14 173.72,87.78 RH513.1
  BOTTOM w0.254: UH1.J14 175.02,87.2 174.53,87.2 v2(174.47,87.14)
N134531379: length 6.2
  BOTTOM w0.254: RH41.1 RH31.1 169.61,107.32 v1(170.17,106.76) 170.81,106.76 172.57,105 172.57,104.56 UH1.M37
N134531381: length 4.5
  BOTTOM w0.254: UH1.M38 172.93,104.86 172.93,105.27 171.54,106.66 v1(171.54,106.76) 171.52,106.78 RH201.1 RH202.1
N134546418: length 6.4
  BOTTOM w0.254: UH1.AH37 160.75,104.55 160.75,105.31 160.82,105.38 160.82,106.94 v1(160.76,107) 160.16,107.6 159.61,107.6 159.47,107.74 159.46,107.74 159.33,107.88 159.32,107.88 159.31,107.89 159.31,107.9 158.94,108.27 RH33.1 158.74,108.11 RH32.1
N134546424: length 4.7
  BOTTOM w0.254: RH204.1 158.48,107.53 159.18,107.53 159.69,107.03 RH203.2 160.25,106.53 160.25,104.94 UH1.AH38
N134687007: length 7.9
  TOP w0.14: RH518.1 RH517.1 212.97,59.65 v2(213.19,59.43) 213.2,59.43 213.75,58.88 v1(214.03,58.88)
  BOTTOM w0.14: v2(213.19,59.43) 211.34,59.43 210.87,59.9 JXDP1.1
N134928683: length 6.5
  TOP w0.14: v1(214.08,57.19) 214.08,57.43 215.16,58.51 QE23.6 QE23.5 216.19,58.88 216.36,59.05 217.74,59.05 217.9,58.89 RH505.2
N134987275: length 3.5
  TOP w0.127: R4.1 67.1,60.13 v1(67.5,60.53)
  TOP w0.14: QZ13.5 67.08,59.18 R4.1 R3.2
N135624823: length 3.1
  BOTTOM w0.076: 358.5,70.42 358.81,70.42 UT4.F1
  BOTTOM w0.14: 358.5,70.42 357.44,70.42 v1(357.21,70.2) 356.36,69.34 RT83.2
N135625951: length 3.2
  BOTTOM w0.076: UT4.D10 363.44,69.28 363.69,69.53 364.2,69.53 364.8,68.93
  BOTTOM w0.14: RT111.1 365.31,68.42 364.8,68.93
N135626510: length 6.5
  BOTTOM w0.076: UT4.C2 359.19,68.53 359.04,68.53 358.84,68.53 358.66,68.36 358.6,68.36 358.54,68.3 358.5,68.3
  BOTTOM w0.14: 358.5,68.3 358.47,68.28 358.01,68.28 357.54,67.81 357.54,67.09 357.39,66.94 355.49,66.94 354.93,66.39 T65.1
N135626543: length 1.4
  BOTTOM w0.089: 364.53,70.88 364.04,70.88 UT4.G11
  BOTTOM w0.14: 364.53,70.88 365.18,70.88 T4936.1
N135626932: length 2.2
  BOTTOM w0.076: 364.21,70.01 364.18,70.03 363.69,70.03 UT4.E10
  BOTTOM w0.14: T121.1 364.69,70.01 364.21,70.01
N135629282: length 7.3
  TOP w0.14: T62.1 354.8,68.15 v2(354.99,68.33)
  IN3 w0.124: v2(359.99,70.08) 357.49,70.08 356.19,68.77 355.43,68.77 v2(354.99,68.33)
  BOTTOM w0.102: v2(359.99,70.08) 360.2,70.28 UT4.F4
N135629285: length 6.8
  TOP w0.14: v2(354.97,69.1) 355.22,68.85 T63.1
  IN3 w0.124: v2(354.97,69.1) 356.13,69.1 357.39,70.36 359.66,70.36 v2(359.96,70.66)
  BOTTOM w0.102: UT4.G4 360.09,70.78 v2(359.96,70.66)
N136195465: length 4.6
  BOTTOM w0.076: 274.23,46.3 274.58,45.96 274.58,45.71 274.91,45.37 275.39,45.37 UH2.R44
  BOTTOM w0.14: T91.1 273.55,46.98 274.23,46.3
N136195482: length 5.8
  BOTTOM w0.076: 274.23,46.93 274.89,46.27 274.89,45.71 275.05,45.55 275.53,45.55 275.69,45.39 275.71,45.39 275.85,45.26 275.85,44.87 276.57,44.15 UH2.U42
  BOTTOM w0.14: T94.1 273.24,47.92 274.23,46.93
N136195787: length 1.2
  TOP w0.14: v2(280.45,39) 280.7,38.75 T182.1
  BOTTOM w0.089: v2(280.45,39) 280.1,39.35 UH2.AG35
N136377934: length 9.3
  TOP w0.127: PQ1.2 v1(45.71,58.63)
  TOP w0.254: PQ1.2 45.71,55.93 45.47,55.69 42.81,55.69 42.37,55.25 PR4.2 41.5,53.81 41.31,54 PQ2.1
N136478007: length 3.6
  TOP w0.14: v4(55.04,31.5) 55.61,30.93 PR31.2
  TOP w0.254: PR23.1 PR31.2 55.6,30.18 PQ7.5
N136478163: length 4.1
  TOP w0.127: v1(35.04,51.14) PQ8.2
  TOP w0.254: PQ8.2 35.04,49.57 35.3,49.32 35.72,49.32 36.13,49.74 PC14.1 PR30.2
N136478208: length 3.6
  TOP w0.14: v1(57.51,24.74) 57.51,25.54 PC15.2
  TOP w0.254: PQ7.2 55.6,26.61 PR33.2 PC15.2
N136479157: length 2.8
  TOP w0.14: RVGA16.1 323.47,38.89 v1(323.37,38.79) 323.2,38.62 323.2,38.04 323.08,37.91 UVGA1.11
N136688636: length 7.5
  TOP w0.14: QP1.2 333.34,56.91 v1(332.72,56.3) 332.51,56.08 332.51,53.73 331.92,53.15 331.92,52.02 RP46.1
N136692046: length 3.6
  TOP w0.14: UG30.4 200.11,62.46 199.94,62.64 199.57,62.64 RG575.1 RG573.1 199.43,61 QG9.2
N136947851: length 4.2
  TOP w0.14: v2(302.11,21.62) 301.6,22.13 UE1.126
  BOTTOM w0.14: v1(303.63,23.59) 302.46,22.43 RE52.1 302.11,22.11 v2(302.11,21.62)
N137159809: length 4.6
  BOTTOM w0.14: v1(294.93,8.92) 296.28,8.92 RE145.1 RE144.1 297.22,8.74 296.26,7.78 JESPI1.8
N137425838: length 12.1
  TOP w0.14: v1(82.44,37.57) 82.2,37.81 v2(81.95,37.81)
  IN5 w0.097: v2(81.95,37.81) 88.7,37.81 v2(89.18,37.33)
  BOTTOM w0.14: v2(89.18,37.33) 88.81,37.7 QV11.3 ; v2(81.95,37.81) 81.89,37.75 RV570.1 82.28,37.12 82.46,37.3 CV578.2 82.84,36.73 82.77,36.66 RV535.2
N137425854: length 3.3
  BOTTOM w0.14: v1(81.1,34.79) 81.1,35.42 RV570.2 82.91,35.19 QV2.1
N137678407: length 3.7
  TOP w0.089: v1(207.62,78.53) 207.7,78.6 207.7,79.59 RG576.2 208.62,80.04 209.35,80.76 QG23.2
N137999162: length 3.8
  BOTTOM w0.14: UG29.4 202.85,72.73 v1(202.85,73.37) 202.99,73.51 202.99,74.17 202.59,74.56 202.59,75.44 RG157.2
N137999174: length 1.4
  BOTTOM w0.14: RG157.1 202.88,76.39 203.1,76.18 QG510.2
N138050086: length 5.2
  BOTTOM w0.14: JDEG1.1 325.25,7.43 326.94,9.12 v1(326.94,10.33) RE60.1
N138313764: length 1.7
  TOP w0.14: T4940.1 297.5,12.19 UE1.24
N138313778: length 2.4
  TOP w0.14: UE1.88 315.73,18.19 315.82,18.09 316.35,18.09 316.55,17.89 316.55,17.33 T4941.1
N138313810: length 5.1
  TOP w0.14: T4942.1 314.49,6.57 314.49,8.03 314.05,8.47 312.97,8.47 312.8,8.31 UE1.63
N201821498: length 2.1
  TOP w0.102: v2(344.65,16.23) 344.68,16.23 v1(345.12,15.8)
  TOP w0.203: v2(344.65,16.23) 344.65,16.24 HDA1.19
  BOTTOM w0.203: v2(344.65,16.23) 344.72,16.3 CA23.1
N201821575: length 3.3
  TOP w0.127: 349.17,19.17 349.53,19.52 ; HDA1.28 347.93,19.06 348.54,18.46 v1(348.67,18.46) 348.82,18.46
  TOP w0.14: 348.82,18.46 348.87,18.46 349.17,18.76 349.17,19.17 ; 349.53,19.52 CA16.2

## Copper pours and planes (outline as drawn)
1.0VS_VGAP_VIN on BOTTOM (solid shape): 118.97,98.33 118.97,96.74 118.66,96.42 118.21,96.42 118.09,96.29 118.09,94.64 118.02,94.58 116.63,94.58 116.18,94.14 115.55,94.14 115.42,94.26 115.42,96.29 115.67,96.55 116.94,96.55 117.58,97.18 117.58,98.14 117.9,98.45 118.85,98.45
1.2V_B+ on TOP (solid shape): 106.53,74.64 106.53,72.47 106.48,72.42 105.83,72.42 105.23,71.82 105.23,68.51 104.94,68.21 104.94,67.59 104.75,67.4 101.96,67.4 101.96,71.02 102.08,71.15 102.08,73.75 103.05,74.72 106.45,74.72
1.2V_VDDQ_EN on TOP (solid shape): 241.82,25.66 241.82,22.68 241.71,22.57 240.73,22.57 240.2,23.11 240.2,25.59 240.38,25.77 241.7,25.77
1.8V_B+ on TOP (solid shape): 277.61,76.6 277.61,76.36 276.65,75.4 276.2,75.4 275.31,76.29 275.31,77.12 275.44,77.24 276.96,77.24
1.8V_B+ on BOTTOM (solid shape): 276.71,76.99 276.71,74.89 276.33,74.51 276.33,73.88 276.9,73.88 276.9,73.75 276.33,73.75 276.33,73.24 276.26,73.18 275.57,73.18 275.44,73.31 275.44,74.26 272.84,76.86 272.84,77.75 272.47,78.12 271.66,78.12 271.59,78.19 271.59,79.66 271.66,79.74 273.96,79.74
3/5V_B+ on TOP (solid shape): 78.59,48.54 78.59,44.29 79.15,43.73 79.15,43.47 79.28,43.34 80.23,43.34 80.29,43.28 80.29,43.15 80.23,43.09 79.21,43.09 78.89,43.41 78.26,43.41 78.07,43.22 77.5,43.22 77.18,42.9 77.18,40.26 76.28,39.36 76.28,35.97 76.11,35.8 76.11,33.24 75.48,32.6 72.86,32.6 72.71,32.75 72.71,35.3 72.81,35.4 72.81,42.76 73.13,43.08 73.13,49.62 73.38,49.88 77.26,49.88
3/5V_B+ on BOTTOM (solid shape): 75.35,45.68 75.35,38.32 74.65,37.62 72.94,37.62 72.81,37.75 72.81,39.14 73.25,39.59 73.25,44.61 73.13,44.73 73.13,45.49 73.51,45.88 75.16,45.88
3V_5V_EN on TOP (solid shape): 86.27,51.82 86.27,49.43 86.16,49.32 82.67,49.32 82.47,49.51 82.47,51.13 83.33,51.98 86.11,51.98
5VS_FAN1 on TOP (solid shape): 100.8,65.14 100.8,64.16 100.56,64.16 100.56,63.27 100.8,63.27 100.8,63.25 100.69,63.13 99.76,63.13 99.63,63.26 99.63,63.83 98.98,64.48 96.34,64.48 96.22,64.61 96.22,65.18 96.41,65.37 100.57,65.37
+0.6VS on TOP (solid shape): 104.88,63.97 104.72,63.81 103.83,63.81 103.61,64.04 103.61,65.05 103.8,65.24 104.88,65.24
+0.6VS on TOP (solid shape): 246.32,37.33 246.32,36.64 246.55,36.41 247.44,36.41 247.56,36.29 247.56,34.45 247.12,34 245.59,34 245.15,34.45 245.15,37.37 245.34,37.56 246.1,37.56
+0.6VS on TOP (solid shape): 169.97,36.05 169.97,35.08 170.16,34.89 170.16,34.32 169.84,34 169.84,32.92 169.58,32.67 168.82,32.67 168.76,32.73 168.76,33.68 168.57,33.87 168.06,33.87 167.87,34.06 167.87,35.88 168.19,36.21 169.81,36.21
+0.6VS on BOTTOM (solid shape): 246.37,37.31 246.37,36.76 245.74,36.14 245.74,33.87 245.68,33.81 245.47,33.81 245.41,33.87 245.41,35.62 245.13,35.9 245.13,37.25 245.36,37.49 246.19,37.49
+0.6VS on BOTTOM (solid shape): 169.23,35.5 169.23,33.78 169.33,33.68 169.75,33.68 169.89,33.55 169.89,33.1 169.48,32.69 169.16,32.69 169.16,32.69 168.99,32.69 168.8,32.88 168.8,33.55 168.92,33.66 168.92,35.47 169.01,35.57 169.16,35.57
+0.6VS on IN5 (solid shape): 105.96,63.97 105.96,62.96 105.26,62.26 104.05,63.46 104.05,64.1 103.61,64.54 103.61,64.93 103.73,65.05 104.88,65.05
+0.6VS on IN5 (solid shape): 246.36,37.3 246.36,35.91 245.4,34.95 245.09,34.95 244.2,35.84 244.2,36.03 244.58,36.41 244.58,36.6 244.58,36.65 244.58,37.3 244.77,37.49 246.17,37.49
+0.6VS on IN5 (solid shape): outline of 131 points within 168.18,30.04 175.55,33.69
+0.6VS on IN5 (solid shape): outline of 214 points within 190.06,29.39 207.86,32.26
+0.6VSP on TOP (solid shape): 108.98,66.52 110.44,66.52 110.49,66.46 110.49,66.33 110.44,66.27 109.97,66.27 109.78,66.08 109.78,65.32 110.09,65 110.86,65 111.09,65.23 111.09,66.02 111.15,66.08 111.24,66.08 111.3,66.01 111.3,65.13 110.86,64.68 109.39,64.68 108.84,65.23 107.48,65.23 107.28,65.43 104.62,65.43 104.62,66 104.12,66 104.12,65.43 103.93,65.43 103.86,65.5 103.86,66.51 104.03,66.68 108.82,66.68
+0.9V_CIO on TOP (solid shape): 355.96,53.38 355.96,53.06 356.22,52.8 356.54,52.8 356.67,52.67 356.67,52.24 356.73,52.18 356.73,51.8 356.69,51.76 356.23,51.76 356.15,51.84 356.15,52.11 355.96,52.3 354.44,52.3 354.31,52.42 354.31,52.99 354.38,53.06 354.82,53.06 354.88,53.12 354.88,53.31 355.01,53.44 355.9,53.44
+0.9V_DP on TOP (solid shape): 354.74,42.82 354.74,40.97 354.58,40.81 354.17,40.81 354.17,40.81 353.64,40.81 353.52,40.93 353.52,41.92 353.7,42.1 353.86,42.19 353.95,42.35 353.98,42.38 353.98,42.7 354.17,42.89 354.66,42.89
+0.9V_DP on TOP (solid shape): 357.4,55.26 357.4,54.74 357.33,54.66 357.33,53.71 357.24,53.62 356.78,53.62 356.73,53.67 356.73,54.08 356.69,54.12 356.69,54.14 356.67,54.14 356.66,54.16 356.25,54.16 356.21,54.2 356.21,54.66 356.24,54.69 356.71,54.69 356.86,54.84 356.86,55.21 356.95,55.3 357.37,55.3
+0.9V_DP on TOP (solid shape): 354.74,42.76 354.74,40.99 354.56,40.81 354.29,40.81 354.28,40.81 354.14,40.84 354.01,40.81 353.64,40.81 353.52,40.93 353.52,41.92 353.7,42.1 353.71,42.11 353.86,42.19 353.95,42.34 353.95,42.35 353.98,42.38 353.98,42.7 354.17,42.89 354.61,42.89
+0.9V_DP on IN3 (solid shape): outline of 1152 points within 347.76,48.37 357.41,54.85
