# Allegro board Dell_Inspiron_15_7577_Compal_CKA50_CKF50_LA_E992P_Rev_1_0_BoardView.brd (continued)
## Nets (continued)
USB2_VBUSSENSE: RH112.1 UH2.AD10
USB3_A_TRX_DTX_N0: DT5.1 JUSBC1.A10 UT1.A21
USB3_A_TRX_DTX_N1: DT9.1 JUSBC1.B10 UT1.B15
USB3_A_TRX_DTX_P0: DT4.1 JUSBC1.A11 UT1.B21
USB3_A_TRX_DTX_P1: DT8.1 JUSBC1.B11 UT1.A15
USB3_A_TTX_C_DRX_N0: CT42.1 DT3.1 JUSBC1.B3
USB3_A_TTX_C_DRX_N1: CT40.1 DT7.1 JUSBC1.A3
USB3_A_TTX_C_DRX_P0: CT41.1 DT2.1 JUSBC1.B2
USB3_A_TTX_C_DRX_P1: CT39.1 DT6.1 JUSBC1.A2
USB3_A_TTX_DRX_N0: CT42.2 UT1.B19
USB3_A_TTX_DRX_N1: CT40.2 UT1.B17
USB3_A_TTX_DRX_P0: CT41.2 UT1.A19
USB3_A_TTX_DRX_P1: CT39.2 UT1.A17
USB3RN1: CI8.1 UH2.B7
USB3RN1_C: CI8.2 UI3.11
USB3RN1_RE: DI12.5 DI12.6 JUSB3.5 UI3.20
USB3RN2: DI9.1 DI9.9 JUSB1.5 UH2.C8
USB3RN3: DI7.1 DI7.9 JUSB2.5 UH2.B10
USB3RP1: CI7.1 UH2.A7
USB3RP1_C: CI7.2 UI3.12
USB3RP1_RE: DI12.4 DI12.7 JUSB3.6 UI3.19
USB3RP2: DI9.2 DI9.8 JUSB1.6 UH2.B8
USB3RP3: DI7.2 DI7.8 JUSB2.6 UH2.A9
USB3TN1: CI6.1 UH2.C11
USB3TN1_C: CI6.2 UI3.8
USB3TN1_RE: CI29.1 UI3.23
USB3TN1_RE_C: CI29.2 DI12.2 DI12.8 JUSB3.8
USB3TN2: CI16.1 UH2.B12
USB3TN2_C: CI16.2 DI9.4 DI9.7 JUSB1.8
USB3TN3: CI9.1 UH2.C13
USB3TN3_C: CI9.2 DI7.4 DI7.7 JUSB2.8
USB3TP1: CI5.1 UH2.B11
USB3TP1_C: CI5.2 UI3.9
USB3TP1_RE: CI28.1 UI3.22
USB3TP1_RE_C: CI28.2 DI12.1 DI12.9 JUSB3.9
USB3TP2: CI20.1 UH2.A12
USB3TP2_C: CI20.2 DI9.5 DI9.6 JUSB1.9
USB3TP3: CI10.1 UH2.D13
USB3TP3_C: CI10.2 DI7.5 DI7.6 JUSB2.9
USB20_N1: UH2.AF5 US1.2
USB20_N2: LI2.1 UH2.AD5
USB20_N2_L: DI10.3 JUSB1.2 LI2.2
USB20_N3: LI5.1 UH2.AG8
USB20_N3_L: DI8.3 JUSB2.2 LI5.2
USB20_N4: JNGFF1.5 UH2.AE1
USB20_N7: UH2.AB3 UR1.3
USB20_N8: R127.1 TR5807.3 UH2.AL8
USB20_N8_R: D5226.2 JPW.8 R127.2 TR5807.4
USB20_N9: LI1.4 RI1.1 UH2.AA1
USB20_N9_R: DI3.2 JEDP1.10 LI1.3 RI1.2
USB20_N12: LV22.1 RV547.1 UH2.AD3
USB20_N12_R: DV12.3 JCAM1.4 LV22.2 RV547.2
USB20_P1: UH2.AG7 US1.3
USB20_P2: LI2.4 UH2.AD7
USB20_P2_L: DI10.2 JUSB1.3 LI2.3
USB20_P3: LI5.4 UH2.AG10
USB20_P3_L: DI8.2 JUSB2.3 LI5.3
USB20_P4: JNGFF1.3 UH2.AE2
USB20_P7: UH2.AB2 UR1.4
USB20_P8: R126.1 TR5807.2 UH2.AL7
USB20_P8_R: D5226.3 JPW.7 R126.2 TR5807.1
USB20_P9: LI1.1 RI2.1 UH2.AA2
USB20_P9_R: DI3.3 JEDP1.9 LI1.2 RI2.2
USB20_P12: LV22.4 RV545.1 UH2.AD2
USB20_P12_R: DV12.2 JCAM1.5 LV22.3 RV545.2
USB8713_TEST: RI24.1 UI3.14
USB_EN#: RE29.1 UE1.13 US2.4
USB_OC0#: RP16.1 UH2.AD43 US1.13
USB_OC1#: RP16.2 UH2.AD42 US2.3
USB_OC2#: RP16.3 UH2.AD39
USB_OC3#: RP16.4 UH2.AC44
USB_OC4#: RP8.3 UH2.Y43
USB_OC5#: RP8.4 UH2.Y41
USB_OC6#: RP8.2 UH2.W44
USB_OC7#: RP8.1 UH2.W43
USB_POWERSHARE_VBUS_EN: RI51.2 UE1.71 US1.5
USB_PWR_SHR_EN_L#: RI10.2 UE1.118 US1.6
USB_R_CTL: RI9.2 US1.7 US1.8
USBP1_D+: LI8.4 RI66.1 US1.10
USBP1_D+_R: DI11.2 JUSB3.3 LI8.3 RI66.2
USBP1_D-: LI8.1 RI65.1 US1.11
USBP1_D-_R: DI11.3 JUSB3.2 LI8.2 RI65.2
VBST1: PR308.1 PU300.17
VBST2: PR307.2 PU300.9
VBST_1V: PR101.1 PU100.1
VBST_+1.35V: PR801.1 PU800.10
VCIN0_PH: CTH2.1 HT1.1 RE73.1 RTH1.2
VCLK: PR306.1 PU300.19
VCREF0: CE91.1 RE34.2 RE35.1 UE1.25
VDRV_GPU_PH1: PC6101.1 PR6106.2 PU6100.24
VDRV_GPU_PH2: PC6116.1 PR6113.2 PU6101.24
VDRV_GPU_PH3: PC6130.1 PR6120.2 PU6102.24
VGA_CLK_REQ#: QG510.1 RP3.6 UH2.AR31
VGA_SMB_CK2: QG6.4 RG17.1 UG9.BJ8
VGA_SMB_DA2: QG6.1 RG18.1 UG9.BH8
VL: PC315.1 PU300.13
VR_CAP: CE103.1 T4931.1(TP-1) UE1.18
VR_ON: PR5023.1 RZ71.1 UC16.2 UZ21.4
VR_SVID_ALERT#: PR5008.2 RH152.2 RH153.1
VR_SVID_ALERT#_R: RH153.2 UH1.BH31
VR_SVID_CLK: PR5006.2 UH1.BH32
VR_SVID_DATA: PR5011.2 RH151.2 UH1.BH29
VREF: PC6016.2 PR6064.1 PU6000.2
VREF_CPU: CE77.1 RE116.2 UE1.95
VTTREF_1.2V: PC212.1 PU200.4
WLAN_CLK_REQ#: JNGFF1.45 RP3.7 UH2.BD25
WLAN_WIGIG60GHZ_DIS#: DN1.1 UH2.AL35
WLAN_WIGIG60GHZ_DIS#_R: DN1.2 JNGFF1.48
XDP_BPM#0: JXDP1.21 UH1.BR27
XDP_BPM#1: JXDP1.23 UH1.BT27
XDP_DBRESET#: CH207.1 JXDP1.48 RH531.2 RH532.1
XDP_PLTRST#: JXDP1.46 RH520.2 RH522.2 RH523.2
XDP_PRDY#: JXDP1.5 UH1.BP27 UH2.AT4
XDP_PREQ#: JXDP1.3 RH156.2 UH1.BL30 UH2.AT3
XDP_PRESENT#: JXDP1.60 RH519.1 RH540.2
XDP_PWRGOOD: JXDP1.39 RH541.2 RH542.2
XDP_TDI: JXDP1.56 RH534.1 RH537.1
XDP_TDO: JXDP1.52 RH533.1 RH539.1
XDP_TMS: JXDP1.58 RH535.1 RH538.1
XDP_TRST#: JXDP1.54 RH536.1
XTAL24_IN: RH569.1 UH2.A6
XTAL24_IN_R: CH47.1 RH72.1 RH569.2 YH2.1
XTAL24_OUT: RH570.1 UH2.A5
XTAL24_OUT_R: CH48.1 RH72.2 RH570.2 YH2.3
XTALIN: CG75.2 RG99.1 UG9.BL6 YG1.1
XTALOUT: CG76.2 RG99.2 UG9.BM6 YG1.3
XTALOUTBUFF_R: RG98.1 UG9.BK6
XTALSSIN: RG101.1 UG9.BJ6
XTLI: CL36.1 UL1.29 YL2.1
XTLO: CL37.1 UL1.28 YL2.3
ZCD_EN#_GPU_PH1: PR6104.1 PU6100.2
ZCD_EN#_GPU_PH2: PR6110.1 PU6101.2
ZCD_EN#_GPU_PH3: PR6118.1 PU6102.2
N06177: RP32.1 UP2.36
N10178: RP45.1 UP2.40
N16840: RP11.1 UP2.9
N16946088: QG23.5 QG23.6 RG546.2 RG584.2
N17036389: QZ13.6 R2.1
N17731278: DG3.1 QG502.3 RG505.2 RG580.2
N18094620: CL33.1 RL19.2 RL20.2 RL39.2 RL40.2
N18094850: RL31.2 UL1.31
N18095026: T944.1(TP-1) UL1.27
N18702920: PC6006.1 PC6008.1 PR6022.2 PR6070.2
N18703353: PJP10V0.2 PL10V01.1
N19074610: PC813.1 PQ802.2 PR810.2 PR811.1
N19094984: PC814.2 PR815.1
N19094987: PR807.2 PR813.2 PR814.1 PR815.2
N19147847: PQ802.1 PR812.2
N19180417: PL5203.2 PR5227.1
N19180429: PL5203.3 PR5228.2
N19209507: QZ13.2 QZ13.3 R1.2 R5.1
N19212978: QG509.5 QG509.6 RG543.2
N19213038: QG513.5 QG513.6 RG583.2
N19213048: QG513.3 RG582.2
N19213104: QG503.5 QG503.6 RG509.2
N19213111: QG503.3 RG510.2
N19213121: QG504.5 QG504.6 RG511.2
N19213130: QG504.3 RG512.2
N19213140: QG505.5 QG505.6 RG513.2
N19213149: QG505.3 RG514.2
N19213165: QG509.3 RG544.2
N19616464: CG230.1 CG231.1 CG232.1 LG4.2 UG9.BC12
N19616930: CG233.1 CG234.1 CG235.1 CG236.1 CG237.1 CG238.1 CG239.1 LG5.2 UG9.AF11 UG9.BB24 UG9.BD12 UG9.U42
N19810901: RG160.1 RG537.1 UG10.4
N19810924: RG19.1 UG9.BG8
N19810925: RG20.1 UG9.BF8
N19825042: T4939.1(TP-1) UE1.21
N19842722: RG130.1 UG5.J13
N19842724: RG126.1 UG5.J1
N19842731: RG128.1 UG5.J10
N19862793: RG120.1 UG4.J13
N19862795: RG116.1 UG4.J1
N19862800: RG118.1 UG4.J10
N19863158: QG3.1 RG122.1
N19863255: RG119.1 UG3.J13
N19863256: RG115.1 UG3.J1
N19863260: RG117.1 UG3.J10
N19864349: RG109.1 UG2.J13
N19864351: RG105.1 UG2.J1
N19864356: RG107.1 UG2.J10
N19864714: QG2.1 RG111.1
N19864859: RG108.1 UG1.J13
N19864860: RG104.1 UG1.J1
N19864864: RG106.1 UG1.J10
N20335974: RL41.1 UL2.3
N20539566: RG26.1 UG9.BK23
N20810959: PQ9.1 PR34.2
N20810969: PC16.2 PQ9.2 PR35.2
N20810972: PC15.1 PC16.1 PQ7.3 PR32.2
N20905578: CT104.1 UT4.H7
N21092291: PQ8.1 PR24.1
N21092399: PQ7.6 PR25.2
N21092759: PR732.2 PU700.13
N21092763: PR733.2 PU700.14
N21092894: PQ305.3 PR315.2
N21094566: PR5000.2 PU5000.46
N21094590: PC5003.1 PR5005.1 PU5000.41
N21094642: PR5001.2 PR5006.1 PR5007.1
N21094652: PR5002.2 PR5008.1 PR5009.1
N21094662: PR5003.2 PR5011.1 PR5012.1
N21094718: PR5009.2 PU5000.44
N21094756: PR5028.2 PU5000.1
N21094764: PR5015.2 PR5020.2 PU5000.47
N21094776: PR5023.2 PU5000.48
N21094960: PR5102.2 PU5101.1
N21094970: PR5104.2 PU5101.2
N21095023: PR5114.2 PU5102.1
N21232186: CA10.2 RA2.2 UA1.3
N21239155: QA1.3 RA58.2
N26668634: CG313.1 RG102.2 RG523.2
N26671206: CG314.1 RG103.2 RG524.2
N26672234: CG315.1 RG113.2 RG525.2
N26672631: CG316.1 RG114.2 RG526.2
N26673021: CG317.1 RG124.2 RG527.2
N26673418: CG318.1 RG125.2 RG528.2
N26979734: QG4.1 RG133.1
N27381541: RG529.1 UG11.9
N29418337: PC5009.2 PR5025.1
N29418339: PR5022.1 PR5025.2 PR5031.1 PU5000.5
N29418355: PC5034.2 PR5046.2
N29418359: PR5046.1 PR5049.1 PR5050.2 PU5000.17
N29418369: PC5015.1 PR5032.2
N29418371: PH5004.2 PR5045.1 PR5048.2
N29418373: PR5032.1 PR5033.1 PR5036.1 PU5000.30
N29418377: PC5037.2 PR5045.2 PU5000.15
N29418393: PH5000.2 PR5013.2 PR5014.1
N29418395: PC5006.2 PR5014.2 PU5000.3
N29418397: PC5005.2 PR5021.2 PU5000.4
N29418405: PR5026.1 PU5000.36
N29418417: PC5010.2 PR5024.1 PU5000.33
N29418423: PC5021.2 PR5037.1 PU5000.29
N29418425: PC5020.1 PR5039.1 PU5000.28
N29418441: PR5019.1 PU5000.40
N29418445: PR5018.1 PU5000.39
N29418451: PR5017.1 PU5000.38
N29418455: PR5016.1 PU5000.37
N29418473: PC5038.1 PR5051.1 PU5000.16
N29419473: PC5004.2 PR5010.2 PU5000.2
N29419486: PC5019.2 PR5040.2 PU5000.8
N29419576: PC5007.2 PR5021.1
N29419623: PH5002.1 PR5034.2
N29419647: PC5022.1 PR5037.2
N29419655: PC5023.1 PR5036.2
N29419663: PH5001.2 PR5030.1
N29419667: PH5003.2 PR5044.1
N29419693: PC5019.1 PR5038.2
N29419730: PC5010.1 PR5027.2
N29419832: PC5002.1 PR5004.2 PU5000.42
N29419860: PC5036.2 PR5047.1 PU5000.14
N29419910: PC5040.2 PR5051.2
N29419918: PC5039.1 PR5049.2
N29419943: PC5033.1 PR5041.1 PU5000.20
N29419947: PC5033.2 PR5043.1
N29426641: PR5126.2 PU5103.1
N29426805: PC5112.1 PR5106.2
N29426831: PC5123.1 PR5121.2
N29426855: PC5134.1 PR5131.2
N29435109: PL5203.1 PR5226.1 PU5203.8
N29435335: PC5232.1 PR5226.2
N29436709: PC5221.1 PR5218.2
N29436789: PC5209.1 PR5206.2
N29438561: PR5012.2 PU5000.43
N29438571: PR5007.2 PU5000.45
N29599145: PC5008.1 PR5022.2
N30070819: RG131.1 UG6.J13
N30070822: RG127.1 UG6.J1
N30070830: RG129.1 UG6.J10
N30314421: CG64.1 UG12.12
N30314423: CG65.1 UG12.10
N30316777: DG4.2 QG502.4 RG506.2
N30316795: QG502.6 RG516.2 UG22.2
N30365509: QG502.5 RG554.2
N30365512: RG554.1 UG22.4
N30365520: QG502.2 RG553.2
N30373122: RG545.1 UG26.4
N31306212: PR5223.2 PU5203.1
N31425872: PC5102.2 PU5101.5
N31425874: PC5102.1 PR5105.1
N31425876: PR5105.2 PU5101.7
N31426527: PC5101.1 PR5101.2 PU5101.24
N31427446: PC5100.2 PR5100.1 PU5101.3
N31433757: PC5115.1 PR5118.1
N31433760: PC5115.2 PU5102.5
N31433761: PR5118.2 PU5102.7
N31434994: PR5117.2 PU5102.2
N31436196: PC5126.1 PR5130.1
N31436215: PC5126.2 PU5103.5
N31436218: PR5130.2 PU5103.7
N31436380: PR5129.2 PU5103.2
N31438582: PC5124.1 PR5125.2 PU5103.24
N31438896: PC5125.2 PR5127.1 PU5103.3
N31439632: PC5202.1 PR5205.1
N31439653: PC5202.2 PU5201.5
N31439658: PR5205.2 PU5201.7
N31439736: PR5204.2 PU5201.2
N31439790: PR5202.2 PU5201.1
N31442956: PC5200.2 PR5200.1 PU5201.3
N31442990: PC5201.1 PR5201.2 PU5201.24
N31443441: PC5114.2 PR5115.1 PU5102.3
N31452288: PC5213.1 PR5217.1
N31452390: PR5215.2 PU5202.2
N31459450: PR5213.2 PU5202.1
N31459506: PC5212.2 PR5214.1 PU5202.3
N31460044: PC5211.1 PR5212.2 PU5202.24
N31494164: PC5222.1 PR5225.1
N31494196: PC5222.2 PU5203.4
N31494209: PR5225.2 PU5203.5
N31494627: PR5224.1 PU5203.12
N31495785: PC5230.2 PR5229.1 PU5203.2
N31495969: PC5231.2 PR5230.2 PU5203.11
N31528975: PC5213.2 PU5202.5
N31528977: PR5217.2 PU5202.7
N31565200: PR5103.1 PU5101.26
N31565645: PR5116.1 PU5102.26
N31565698: PC5113.1 PR5113.2 PU5102.24
N31566286: PR5128.1 PU5103.26
N31567454: PR5203.1 PU5201.26
N31567631: PR5216.1 PU5202.26
N32834652: HDA1.16 RA19.1
N33138349: RG65.2 UG11.5
N33204017: RG566.1 UG9.BD2
N34662854: HDA1.20 RA17.1 RA18.1
N48676721: JBL1.2 RE3.2
N48680518: CE1.1 QE3.1 QE4.2 RE1.1
N111798152: CZ4.1 UZ1.12
N111798158: CZ6.1 UZ1.10
N120139517: RH71.2 UH2.E1
N120176772: T2.1(TP-1) UH2.V44
N120176822: T8.1(TP-1) UH2.BD36
N120177456: T17.1(TP-1) UH2.BD17
N120361004: JNGFF2.38 RD7.2 RD59.1
N120361079: JNGFF2.60 RD9.1
N122712620: JNGFF2.61 RD58.2
N122754354: CZ57.1 UZ16.6
N124752685: CH101.2 RH211.1
N124753277: CH100.2 RH212.1
N129020146: CA29.1 RA30.2 RA33.1
N129172883: JDEG1.9 RE118.2
N129347215: RH103.2 RH105.1 RH180.2
N130584913: T92.1(TP-1) UH2.AR17
N130960109: RE111.1 T3.1(TP-1)
N130982801: RL43.2 UL1.26
N131311358: DC2.2 RC11.1
N131432061: QE24.5 QE24.6 RH506.2
N131440042: QE20.2 QE20.3 RH504.2
N134045472: RZ33.2 UE4.3
N134144050: QC5.2 QC5.3 RS39.2
N134147995: RTPM7.1 UTPM1.27
N134148044: CTPM1.1 CTPM2.1 RTPM1.1 RTPM14.1 UTPM1.1
N134148081: QTPM1.2 RTPM8.2
N134155630: RI11.2 RI12.2 UI3.5
N134208615: DVGA1.1 FVGA1.2
N134520421: RH89.2 UH1.BR33
N134526648: RH28.1 RH29.1 UH1.AG38
N134526650: RH197.2 RH198.1 UH1.AG37
N134527394: RH57.2 UH1.BR25
N134527396: RH58.2 UH1.BP25
N134527398: RH166.2 UH1.BT29
N134531257: RH514.1 RH515.1 UH1.H14
N134531263: RH513.1 RH516.1 UH1.J14
N134531379: RH31.1 RH41.1 UH1.M37
N134531381: RH201.1 RH202.1 UH1.M38
N134546418: RH32.1 RH33.1 UH1.AH37
N134546424: RH203.2 RH204.1 UH1.AH38
N134687007: JXDP1.1 RH517.1 RH518.1
N134928683: QE23.5 QE23.6 RH505.2
N134987275: QZ13.5 R3.2 R4.1
N135624823: RT83.2 UT4.F1
N135625951: RT111.1 UT4.D10
N135626510: T65.1(TP-1) UT4.C2
N135626543: T4936.1(TP-1) UT4.G11
N135626932: T121.1(TP-1) UT4.E10
N135629282: T62.1(TP-1) UT4.F4
N135629285: T63.1(TP-1) UT4.G4
N136195465: T91.1(TP-1) UH2.R44
N136195482: T94.1(TP-1) UH2.U42
N136195787: T182.1(TP-1) UH2.AG35
N136377934: PQ1.2 PQ2.1 PR4.2
N136478007: PQ7.5 PR23.1 PR31.2
N136478163: PC14.1 PQ8.2 PR30.2
N136478208: PC15.2 PQ7.2 PR33.2
N136479157: RVGA16.1 UVGA1.11
N136688636: QP1.2 RP46.1
N136692046: QG9.2 RG573.1 RG575.1 UG30.4
N136947851: RE52.1 UE1.126
N137159809: JESPI1.8 RE144.1 RE145.1
N137425838: CV578.2 QV11.3 RV535.2 RV570.1
N137425854: QV2.1 RV570.2
N137678407: QG23.2 RG576.2
N137999162: RG157.2 UG29.4
N137999174: QG510.2 RG157.1
N138050086: JDEG1.1 RE60.1
N138313764: T4940.1(TP-1) UE1.24
N138313778: T4941.1(TP-1) UE1.88
N138313810: T4942.1(TP-1) UE1.63
N201821498: CA23.1 HDA1.19
N201821575: CA16.2 HDA1.28

Pads without a net: DA6 3; FD1 1; FD2 1; FD3 1; FD4 1; HDA1 11 12 14 15 23 24 48; JBL1 3; JCRT1 4 11; JDIMM1 87 88 91 92 95 97 100 101 104 105 134 162 165; JDIMM2 87 88 91 92 95 97 100 101 104 105 134 162 165; JEDP1 4 15 23; JKB1 2 3; JNGFF1 6 8 9 10 11 12 13 14 15 16 17 19 20 21 23 26 28 32 34 36 38 40 50 51 52 53 54 56 57 58 59 60 62 63 65; JNGFF2 6 8 20 22 24 26 28 30 32 34 36 40 42 44 46 48 56 58 59; PBATT1 11 12; PD1 3; PD4 3; PJPDC1 10 11; PU10V0 1 7; PU18V00 10 12; PU25V00 5; PU100 10 12; PU4000 10 12; PU5101 6 22 25 27; PU5102 6 22 25 27; PU5103 6 22 25 27; PU5201 6 22 25 27; PU5202 6 22 25 27; PU5203 9; PU6000 4 5 6 7 8 13 14 15 16; PU6100 6 22 25 27; PU6101 6 22 25 27; PU6102 6 22 25 27; RP15 2 4 5 7; SW5 2 3; UA1 4; UC1 1; UC16 1; UE6 1; UG1 A5 A10 U5 U10; UG2 A5 A10 U5 U10; UG3 A5 A10 U5 U10; UG4 A5 A10 U5 U10; UG5 A5 A10 U5 U10; UG6 A5 A10 U5 U10; UG9 A9 A17 A42 AA1 AA2 AA3 AA4 AA5 AA6 AA7 AA9 AA44 AC1 AC2 AC3 AC4 AC5 AC6 AC7 AC8 AC9 AD1 AD2 AD3 AD4 AD5 AD6 AD7 AD8 AD9 AD45 AD46 AF2 AF3 AF4 AF6 AF7 AF8 AF9 AF49 AG1 AG2 AG4 AG5 AG6 AG7 AG8 AG9 AG52 AJ1 AJ3 AJ4 AJ5 AJ6 AJ7 AJ8 AK2 AK3 AK4 AK5 AK6 AK7 AK8 AK9 AM1 AM2 AM3 AM5 AM6 AM7 AM8 AN1 AN2 AN3 AN6 AN7 AN9 AN44 AR1 AR2 AR3 AR5 AR6 AR7 AR8 AR50 AT1 AT2 AT3 AT6 AT7 AT9 AT44 AT45 AV1 AV2 AV3 AV5 AV6 AV7 AV8 AW1 AW2 AW3 AW6 AW7 AW9 AW47 AW48 B50 BA1 BA2 BA3 BA5 BA6 BA7 BA8 BA9 BB1 BB2 BB3 BB6 BB7 BB8 BD4 BD5 BD7 BD14 BD17 BD23 BE3 BE5 BE7 BE11 BE12 BE14 BE23 BF11 BF12 BF14 BF15 BF21 BF23 BF24 BG1 BG4 BG6 BG11 BG12 BG14 BG15 BG17 BG21 BG23 BG24 BH1 BH3 BH6 BH11 BH12 BH14 BH17 BH23 BJ1 BJ2 BJ9 BJ11 BK8 BK11 BK12 BK14 BK15 BK17 BK18 BK20 BK21 BK44 BL8 BL11 BL12 BL14 BL15 BL17 BL18 BL20 BL21 BM8 BM9 BM11 BM12 BM14 BM15 BM17 BM18 BM20 BM21 C2 C3 C24 C35 D1 D2 D3 D17 D41 E1 E3 E29 F1 F2 F3 F4 F5 F9 F29 F41 G9 G14 G35 G41 H2 H3 H4 H5 H6 H7 H14 H24 H35 J2 J3 J4 J5 J6 J7 J14 J23 J24 J35 J41 J46 J47 L1 L2 L3 L4 L5 L6 L7 L8 M1 M2 M3 M4 M5 M7 M8 M9 M44 M45 P1 P2 P3 P4 P5 P6 P7 P8 P9 P45 R1 R2 R3 R4 R5 R6 R7 R8 R9 U1 U2 U3 U4 U5 U6 U8 V1 V2 V3 V4 V5 V6 V7 V8 V9 V44 V45 Y1 Y2 Y3 Y4 Y5 Y6 Y7 Y8 Y50; UG11 1 2 10 13 16; UH1 AA14 AD2 AD4 AE1 AE5 AE9 AE10 AE11 AE29 AF10 AF29 AF30 AF31 AF32 AF33 AF34 AG13 AG14 AG31 AG32 AG33 AG34 AG35 AG36 AH13 AH14 AH29 AH30 AH31 AH32 AH35 AH36 AJ8 AJ10 AJ11 AJ13 AJ14 AK3 AL1 AL2 AL3 AM10 AM11 AT3 AT5 AT7 AT11 AT13 AU13 AW7 AW8 AW9 AW10 AW11 AW13 AY1 AY2 AY3 AY4 AY5 AY7 AY8 AY9 AY10 AY11 AY13 B2 B30 B33 B38 BA1 BA2 BA3 BA4 BA5 BH30 BJ13 BJ14 BJ16 BJ17 BJ19 BJ20 BJ21 BJ23 BJ24 BJ26 BJ27 BJ28 BJ33 BJ34 BJ35 BJ36 BK16 BK17 BK19 BK20 BK21 BK23 BK24 BK26 BK27 BK28 BL14 BL15 BL16 BL17 BL18 BL19 BL20 BL21 BL22 BL23 BL24 BL25 BL26 BL27 BL28 BL31 BL33 BL34 BM14 BM15 BM16 BM17 BM22 BM24 BM31 BM33 BN1 BN15 BN16 BN17 BN33 BN35 BP1 BP13 BP15 BP16 BP17 BR1 BR2 BR15 BR16 BR17 BR31 BR35 BT2 BT15 BT16 BT17 BT30 C1 C30 C33 C38 D1 E1 E2 E3 E30 E33 F30 F33 G3 G13 H24 J3 J24 N29 R14; UH2 A14 A39 A40 A41 AA44 AA45 AB13 AB33 AB35 AB36 AB39 AB41 AB42 AB43 AB44 AC2 AC3 AC43 AD31 AD35 AD38 AE17 AE45 AF2 AF3 AF17 AF41 AG14 AG15 AG39 AG44 AH43 AH44 AJ7 AJ8 AJ11 AJ13 AJ35 AJ42 AJ43 AJ44 AK44 AK45 AL39 AL42 AL43 AL44 AM44 AN17 AN24 AN29 AN36 AN42 AR15 AR19 AR22 AR27 AR29 AR38 AT17 AT42 AU41 AU44 AV2 AV3 AV13 AV15 AV19 AV44 AW2 AW22 AW24 AW31 AW33 AW35 B13 B14 B15 B23 B24 B36 B39 BA4 BA5 BA33 BA35 BA41 BB3 BB13 BB17 BB19 BB22 BB24 BB31 BB33 BB36 BB38 BC8 BC15 BC19 BC22 BC24 BC32 BC33 BC35 BC36 BC38 BD1 BD8 BD14 BD18 BD21 BD23 BD27 BD32 BD33 BD34 BD35 BD38 BD39 BE2 BE5 BE21 BE34 BE39 C14 C15 C23 C24 C36 D5 D43 E6 E11 E35 E41 E42 E45 F41 F45 G11 G13 G35 G37 G44 G45 H13 H40 H42 H43 H44 J45 K13 K15 K22 K24 K37 K44 L5 L7 L22 L24 L37 L39 M44 M45 N2 N3 N7 N8 N29 N31 N38 N39 N42 N43 N44 P1 P2 P3 P24 P27 P29 P31 P44 R2 R3 R4 R11 R13 R24 R27 R35 R36 R41 R42 R43 T44 U2 U3 U13 U36 U39 V1 V2 W2 W3 W7 W10 W11 W13 W39 Y5; UL1 25; UP2 2 10 12 25 26 37; UR1 9 14 15 17 19 21; US1 9; UT1 A7 A9 A11 A13 A23 B7 B9 B11 B13 B23 D19 E18 E19 J1 J2 L1 L2 N1 N2 R1 R2 V18 W16 Y16; UT4 A9 B2 B9 D7 G10 L11; UTH1 8; UTPM1 2 4 5 6 7 10 11 12 13 15 25 26 28 30 31; UVGA1 12 13 27 28 31; UZ8 3

## Via types
v1: diameter 0.305, hole 0.152, TOP to BOTTOM, 1009 vias
v2: diameter 0.457, hole 0.203, TOP to BOTTOM, 10011 vias
v3: diameter 0.508, hole 0.254, TOP to BOTTOM, 168 vias
v4: diameter 0.406, hole 0.203, TOP to BOTTOM, 236 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
1.0VS_VGAP_VIN: length 1.9
  BOTTOM w0.127: v1(118.58,99.62) 118.49,99.53 118.49,97.81 118.44,97.75
1.2V_B+: length 14.3
  TOP w0.254: PR207.1 v2(115.7,69.46)
  IN5 w0.508: v2(104.04,69.41) 108.22,69.41 110.63,71.82 113.33,71.82 v2(115.7,69.46)
  vias: v4(102.52,73.73)
1.2V_PGOOD: length 6.3
  TOP w0.14: v1(115.91,72.71) 115.91,70.67 PR206.2
  TOP w0.203: PR206.2 114.75,69.5 114.28,69.5 113.69,68.91 113.69,68.21 113.46,67.98 PU200.10
1.2V_VDDQ_EN: length 172.6
  TOP w0.14: PR209.1 117.05,66.84 118.14,65.75 v2(118.14,64.29) ; 240.81,25.49 v1(239.78,25.49)
  IN2 w0.097: v2(118.14,64.29) 124.95,64.29 126.91,62.32 126.91,36.03 127.99,34.95 172,34.95 173.65,33.3 173.65,31.26 171.24,28.84 171.24,22.95 171.68,22.51 183.55,22.51 186.28,25.24 225.34,25.24 226.42,26.32 237.4,26.32 240.09,23.62 v2(240.44,23.62)
1.8V_B+: length 1.2
  TOP w0.14: 275.53,76.9 275.53,77.33 v1(274.97,77.89)
  vias: v2(275.76,76.93) v2(276.39,76.93)
1.8V_EN: length 4.7
  BOTTOM w0.14: v1(268.66,76.39) 268.11,75.85 PR18V00.2
  BOTTOM w0.254: PR18V00.2 PR18V04.1 PC18V09.1 267.92,77.63 268.55,78.25 PU18V00.11
1V8_AON_ON: length 21.8
  TOP w0.14: v4(217.13,70.88) 217.76,70.26 v2(217.78,70.26) ; QG503.2 218.08,62.21 217.82,61.94 216.98,61.94 216.74,62.18 216.74,62.92 v2(217.21,63.39) 216.75,63.85 211.61,63.85 211.54,63.92 UG25.4
  IN4 w0.254: v2(217.21,63.39) 217.21,64.25 217.78,64.82 v2(217.78,70.26)
  BOTTOM w0.203: UG12.3 216.73,70.46 216.93,70.26 v2(217.78,70.26) 219.18,70.26 219.44,70.53 RG70.2
1V8_MAIN_EN: length 288.6
  TOP w0.254: DG3.2 224.27,61.99 224.13,61.85 224.13,61.35 v2(224.1,61.32) 224.13,61.29 DG7.2 224.13,59.73 RG549.1 ; v2(214.93,63.35) 215.42,62.87 QG504.2 ; UG26.2 204,61.69 203.37,61.05 RG71.2 CG487.1 204.95,60.81 v1(205.96,59.8) 206.08,59.68 206.08,59.08 205.82,58.82 v2(205.65,58.82)
  IN3 w0.254: v2(224.1,61.32) 224.1,61.37 224.02,61.45 221.21,61.45 220.02,62.65 215.63,62.65 v2(214.93,63.35)
  IN4 w0.089: 204.75,78.19 204.37,78.57 204.2,78.57 v2(203.62,79.15)
  IN4 w0.137: 204.75,78.19 206.58,76.37 206.58,73.57 206.63,73.52 206.63,69.75 207.27,69.1 207.27,66.08 208.99,64.37 208.99,61.97 207.33,60.31 207.33,58.92 206.8,58.39 206.08,58.39 v2(205.65,58.82)
  IN5 w0.097: v2(115.77,85.07) 115.77,84.72 119.29,81.21 119.29,53.41 121.31,51.39 121.31,36.44 123.51,34.24 139.21,34.24 141.43,32.02 143.84,32.02 144.48,32.66 167.15,32.66 167.59,33.1 167.59,33.54 167.82,33.77 168.77,33.77 168.91,33.91 171.1,33.91 171.49,33.52 175.91,33.52 176.34,33.09 176.34,32.59 176.91,32.02 188.82,32.02 189.51,32.7 228.98,32.7 229.66,33.38 230.93,33.38 233.44,35.89 233.44,40.72 234.81,42.09 234.81,51.39 228.77,57.43 227.35,57.43 224.1,60.68 v2(224.1,61.32)
  BOTTOM w0.089: v2(203.62,79.15) 203.94,79.15 204.44,79.65 UG9.BE1
  BOTTOM w0.203: UG12.5 215.93,70.3 217.38,68.84 222.5,68.84 227.75,63.59 227.75,62.45 226.68,61.38 224.13,61.38 224.1,61.36 v2(224.1,61.32)
  BOTTOM w0.254: v2(115.77,85.07) 116.3,85.07 DG10.1 116.65,85.42 RG550.1 ; v2(214.93,63.35) 215.52,63.94 216.38,63.94 216.73,63.59 216.73,59.18 215.56,58.02 214.92,58.02 213.2,56.29 208,56.29 205.65,58.64 v2(205.65,58.82)
1V_PG: length 62.4
  TOP w0.14: PU100.9 248.93,40 v2(248.51,39.59) ; v2(272.14,23.97) v1(272.14,22.18) 272.14,20.28 275.06,17.36 280.39,17.36 282.58,15.18 286.87,15.18 288.76,13.29 289.45,13.29 290.46,12.27 290.46,11.65 RE149.2
  IN2 w0.254: v2(248.51,39.59) 249.02,39.08 v2(249.02,35.03)
  IN4 w0.137: v2(249.02,35.03) 249.02,34.87 250.17,33.73 259.33,33.73 260.27,32.79 260.27,29.08 262.66,26.68 265.06,26.68 265.46,26.28 269.82,26.28 v2(272.14,23.97)
2.5V_PGOOD: length 3.8
  TOP w0.14: v2(171.35,30.72) v4(172.19,30.72)
  BOTTOM w0.254: PR25V02.2 171.35,31.08 v2(171.35,30.72) 171.35,30.52 171.52,30.35 PU25V00.1
3/5V_B+:
  vias: v2(73.38,44.92) v2(73.83,39.59) v2(73.97,45.51) v2(73.97,44.92) v2(74.41,39.59) v2(74.41,39) v2(74.41,38.42) v2(74.41,37.84) v2(74.55,45.51) v2(74.55,44.92) v4(76.32,45.75)
3V3_SYS_EN: length 30.1
  TOP w0.089: RG515.2 212.15,80.22 v2(212.77,79.59)
  TOP w0.114: CG240.1 213.47,79.27 213.15,79.59 v2(212.77,79.59)
  TOP w0.14: 205.4,64.9 205.77,64.54 v1(205.77,64.4) 205.77,63.79 UG14.4 ; 205.4,64.9 204.94,64.9 RG545.2 ; 205.4,64.9 v2(205.42,64.9)
  TOP w0.254: v2(212.5,63.34) 212.75,63.09 QG505.2
  IN1 w0.254: v2(205.42,64.9) 205.53,64.8 208.55,64.8 209.67,65.92 210.33,65.92 210.51,65.74 211.1,65.74 v2(211.56,66.2)
  IN4 w0.508: v2(212.5,63.34) 212.5,63.74 212.1,64.14 212.1,65.65 v2(211.56,66.2) 211.56,67.85 212.14,68.43 212.14,75.57 213.69,77.12 213.69,78.29 212.77,79.2 v2(212.77,79.59)
3V_5V_EN:
  vias: v1(85.61,51.15)
3V_EN: length 7.8
  TOP w0.14: PR311.1 85.28,48.25 86.32,48.25 v1(86.68,47.89)
  TOP w0.203: PR311.1 84.48,48.39 84.48,48.15 83.85,47.51 83.85,46.33 82.35,44.84 82.23,44.84 82.08,44.69 PU300.6
5V_EN: length 10.7
  TOP w0.14: v1(83.2,47.44) 82.91,47.73 v2(82.91,47.95)
  TOP w0.203: PU300.20 82.08,40.92 82.31,40.68 82.32,40.68 82.39,40.61 v2(83.34,40.61)
  TOP w0.254: PR312.1 v2(82.91,47.95)
  IN3 w0.254: v2(83.34,40.61) 83.34,42.52 82.83,43.03 82.83,47.87 v2(82.91,47.95)
5VCC: length 6.3
  TOP w0.14: v1(161.38,145.14) PR6037.2
  TOP w0.203: PC6014.1 160.8,142.13 160.63,142.13 159.74,141.24 PU6000.12
  TOP w0.508: PC6014.1 161.52,142.85 161.52,143.73 PR6037.2 160.57,143.87 PR6033.1
5VS_FAN1:
  vias: v4(100.14,65.15)
5VS_FAN2: length 3.9
  TOP w0.508: RE105.2 310.78,48.23 v4(311.23,47.78) 312,47.78 312.27,48.05 JFAN2.1
+0.6VS: length 141.9
  TOP w0.127: v2(104.31,64.16) 104.31,63.85 v4(104.97,63.19)
  IN5 w1.524: 105.2,63.4 106.85,61.75 106.85,56.67 119.17,44.35 119.17,35.97 123.74,31.4 140.13,31.4 140.56,30.97 144.18,30.97 144.95,31.73 168.62,31.73 ; 175.06,30.89 190.79,30.89 ; 207.32,30.8 215.69,30.8 216.42,31.54 229.33,31.54 229.83,32.03 241.59,32.03 242.48,32.93 242.48,33.75 243.31,34.57 243.88,34.57 244.77,35.46
  vias: v2(103.93,64.67) v2(104.62,64.67) v2(169.04,33.42) v2(169.36,32.92) v2(169.69,33.42) v2(245.44,37.15) v2(245.44,36.52) v2(245.96,36.82)
+0.6VSP: length 1.9
  TOP w0.14: v4(102.34,65.9) 102.81,66.37 104.03,66.37
+0.9V_CIO: length 1.8
  BOTTOM w0.254: UT1.R9 v2(356.44,52.57) UT1.R8 ; UT1.R11 v2(355.14,53.22) UT1.R12
  vias: v1(355.39,52.39)
+0.9V_DP: length 29.6
  TOP w0.127: v4(353.04,40.48) 353.16,40.48 v2(353.8,41.11)
  IN5 w0.508: v2(354.49,51.92) 354.28,51.92 353.88,51.52 353.88,51.02 355.78,49.11 356.34,49.11 356.85,48.61 356.85,47.91 357.88,46.88 360.45,46.88 361.07,46.25 361.07,44.48 361.33,44.22 361.33,42.26 360.82,41.75 357.16,41.75 356.97,41.56 355.47,41.56 355.28,41.75 v2(353.81,41.75) 353.8,41.74 v2(353.8,41.11)
  BOTTOM w0.254: UT1.L11 v2(355.14,54.52) UT1.L12 ; UT1.L6 v2(357.09,54.52) UT1.L8 ; v2(354.49,51.92) UT1.V13 ; v2(354.49,51.92) UT1.V12 ; v2(354.49,51.92) UT1.T12 ; UT1.M8 v2(357.09,53.87) UT1.M6 ; UT1.V11 v2(355.14,51.92) UT1.T11
+0.9V_LVR_OUT: length 12.2
  TOP w0.381: CT83.1 349.64,57.9 348.72,58.82 v2(348.59,58.82)
  IN3 w0.508: v2(355.14,55.82) 355.14,56.18 354.88,56.44 353.18,56.44 v2(352.55,55.82) 352.55,57.41 351.2,58.76 348.65,58.76 v2(348.59,58.82)
  BOTTOM w0.254: UT1.J11 v2(355.14,55.82) UT1.H11
  vias: v1(348.7,59.72)
+0.9V_PCIE: length 1.8
  TOP w0.127: v1(349.48,55.34) 349.99,55.34 350.59,54.73 CT72.1
  vias: v2(351.9,54.52) v2(352.53,54.51) v2(353.19,54.51) v2(353.84,54.51)
+0.9V_SVR: length 5.7
  TOP w0.127: CT68.1 353.63,58.36 v1(352.69,59.3)
  BOTTOM w0.254: UT1.F11 355.45,56.79 v2(355.13,57.11) ; UT1.F15 v2(353.84,57.11) 354.16,57.44 UT1.E13 ; v2(355.79,54.52) 356.11,54.19 UT1.M9 ; UT1.F12 354.81,56.8 v2(354.5,57.11) 354.18,56.79 UT1.F13 ; UT1.J9 v2(355.79,55.17) UT1.L9 ; v2(354.5,57.78) 354.81,57.46 UT1.E12
  vias: v2(365.42,57.43) v2(366.05,57.43) v2(366.64,57.43) v2(367.22,57.43)
+0.9V_USB: length 15.3
  TOP w0.127: v2(347.98,47.84) v1(347.98,48.54)
  TOP w0.254: CT77.1 352.92,51.97 353.19,52.24 v2(353.19,52.57)
  TOP w0.356: v2(347.98,47.84) 348.24,47.59 CT56.1
  IN2 w0.508: v2(347.98,47.84) 347.98,52.95 348.74,53.71 351.23,53.71 351.92,53.02 351.92,52.96 351.93,52.95 351.93,52.32 352.29,51.96 352.79,51.96 352.88,52.04 352.92,52.04 353.19,52.31 v2(353.19,52.57)
  BOTTOM w0.254: UT1.R16 v2(353.19,52.57) UT1.R15
+1.0VS_VGA_PGOOD: length 224.7
  TOP w0.14: v2(121.55,94.52) v4(122.4,94.52)
  TOP w0.254: UG27.2 v2(210.22,78.77)
  IN4 w0.508: v2(217.46,58.1) 217.06,58.51 212.9,58.51 209.65,61.76 209.65,66.48 209.27,66.86 209.27,74.26 209.53,74.51 209.53,77.59 210.22,78.29 v2(210.22,78.77)
  IN5 w0.508: v2(121.55,94.52) 121.43,94.4 121.43,87.89 121.93,87.38 121.93,58.9 139.23,41.6 139.23,36.52 141.7,34.05 166.84,34.05 167.16,34.37 168.44,34.37 168.62,34.55 171.38,34.55 171.81,34.12 177.59,34.12 177.69,34.01 225.55,34.01 226.9,35.36 230.7,35.36 231.75,36.42 231.75,40.48 234.07,42.8 234.07,50.27 230.28,54.06 226.97,54.06 226.16,54.87 226.16,55.93 224.7,57.39 222.44,57.39 221.48,58.36 217.72,58.36 v2(217.46,58.1)
+1.0VS_VGAP: length 10.9
  TOP w0.127: v2(117.91,90.13) v4(117.13,90.13)
  BOTTOM w0.254: PC10V2.1 v2(117.91,90.13) 117.01,90.13 PC10V6.1 115.47,91.15 PR10V2.2
+1.2V_DDR: length 121.7
  BOTTOM w0.254: JDIMM1.12 105.58,35.84 v2(105.89,36.16) ; JDIMM2.33 187.32,43.95 186.99,44.28 v2(186.68,44.28) ; v2(197.3,44.87) 197.32,44.87 197.83,44.37 JDIMM2.75 ; JDIMM1.54 116.07,33.25 v2(116,33.17) ; v2(167.12,85.06) 166.83,85.35 UH1.Y12 ; v2(144.01,44.39) 144.07,44.39 144.33,44.13 JDIMM1.159
  BOTTOM w0.305: v2(149.14,33.43) 149.08,33.49 JDIMM1.178 ; JDIMM1.160 144.58,33.62 143.71,32.76 v2(143.47,32.76) ; JDIMM1.142 138.08,33.73 137.8,33.45 v2(137.11,33.45) 136.88,33.45 136.58,33.75 JDIMM1.136 ; JDIMM1.153 142.82,44.14 143.1,44.41 143.98,44.41 v2(144.01,44.39) ; JDIMM1.130 135.08,33.71 134.73,33.37 v2(133.31,33.37) 133.58,33.63 JDIMM1.124 ; JDIMM2.136 v2(213.08,33.4) ; JDIMM1.147 141.33,44.34 142.2,45.21 v2(144.01,45.21) 144.08,45.21 144.19,45.1 144.32,45.1 145.33,44.1 JDIMM1.163 ; JDIMM2.178 v2(225.58,33.39) ; JDIMM2.199 230.83,43.87 230.52,44.18 v2(230.05,44.18) ; JDIMM1.220 159.57,33.78 159.94,33.42 v2(160.32,33.42) ; JDIMM1.129 134.82,43.83 135.16,44.16 v2(135.81,44.16) 135.98,44.16 136.33,43.82 JDIMM1.135 ; JDIMM2.118 208.57,33.74 208.31,33.47 v2(208.31,33.4) ; v2(192.38,35.91) 192.57,35.71 JDIMM2.54 ; v2(130.51,33.44) 130.58,33.51 JDIMM1.112 ; JDIMM2.96 203.08,33.45 v2(202.96,33.33) ; JDIMM2.124 210.08,33.7 210.38,33.4 v2(210.44,33.4) 211.13,33.4 211.58,33.84 JDIMM2.130 ; JDIMM2.163 221.83,43.86 222.13,44.17 v2(222.3,44.17) ; JDIMM2.135 212.83,43.87 213.12,44.17 v2(214.02,44.17) 214.03,44.17 214.32,43.88 JDIMM2.141 ; JDIMM2.159 220.83,43.85 220.46,44.21 v2(219.97,44.21) 219.96,44.21 219.63,44.21 219.32,43.9 JDIMM2.153 ; JDIMM2.12 v2(182.08,33.38) ; v2(132.07,33.43) JDIMM1.118 ; v2(143.47,33.37) 143.38,33.37 143.08,33.67 JDIMM1.154 ; v2(221.07,33.37) JDIMM2.160 ; JDIMM2.147 217.83,44.52 v2(218.05,44.74) ; v2(207.07,44.39) 206.83,44.14 JDIMM2.111 ; JDIMM2.241 241.32,44.14 v2(240.88,44.58) ; JDIMM1.199 154.33,44.18 154.8,44.66 154.8,45.16 154.49,45.47 154.06,45.47 154.06,45.46 v2(154.06,45.46) ; JDIMM1.75 121.33,44.33 121.96,44.96 v2(122.37,44.96) ; JDIMM2.112 v2(207.08,33.4) ; JDIMM1.111 130.33,44.52 129.95,44.9 129.78,44.9 v2(129.73,44.94) 130.05,45.26 131.03,45.26 131.82,44.47 JDIMM1.117 ; v2(163.27,45.62) 164.11,45.62 164.82,44.9 JDIMM1.241 ; JDIMM2.123 v2(209.83,44.24) 208.74,44.24 208.32,43.82 JDIMM2.117 ; v2(209.29,44.75) 210.32,44.75 211.32,43.75 JDIMM2.129 ; JDIMM1.148 141.58,33.44 v2(141.52,33.39) ; v2(110.95,45.34) 110.63,45.34 110.33,45.04 110.33,44.31 110.66,43.97 110.66,43.96 110.73,43.89 110.73,43.83 110.75,43.82 110.83,43.82 JDIMM1.33 ; JDIMM1.96 v2(126.58,33.43) ; JDIMM2.220 v2(236.07,33.39) ; v2(133.33,44.47) JDIMM1.123 ; JDIMM1.141 137.82,44.71 136.47,46.07 133.37,46.07 v2(133.3,45.99)
  BOTTOM w0.33: JDIMM2.154 219.58,33.7 219.91,33.37 v2(221.07,33.37) ; JDIMM2.142 v2(214.58,33.4) ; JDIMM2.148 218.08,33.85 v2(217.59,33.37)
  BOTTOM w0.381: UC1.5 133.52,87.57 CH197.1
  BOTTOM w0.508: RD35.1 205.77,31.79 207.08,33.1 v2(207.08,33.4) ; CH197.1 133.51,87.39 v2(134.06,86.84)
  vias: v2(116.37,72.23) v2(116.37,71.64) v2(116.37,71.06) v2(116.37,70.48) v2(116.37,69.89) v2(116.37,69.31) v2(116.37,68.72) v2(116.96,72.23) v2(116.96,71.64) v2(116.96,71.06) v2(116.96,70.48) v2(116.96,69.89) v2(116.96,69.31) v2(116.96,68.72) v2(117.54,72.23) v2(117.54,71.64) v2(117.54,71.06) v2(117.54,70.48) v2(117.54,69.89) v2(151.64,81.1) v2(151.67,81.78) v2(154.15,81.07) v2(154.33,85.72) v2(154.32,85.02) v2(158.91,85.07) v2(159.79,85.11) v2(161.63,83.8) v2(161.7,80.99) v2(162.56,84.99) v2(166.71,81.05) v2(169.2,81.05) v2(169.88,83.18) v2(175.29,85.12) v2(175.95,81.1) v2(177.84,33.4) v2(177.84,32.77) v2(178.47,33.4) v2(178.47,32.77) v2(179.11,33.4) v2(179.11,32.77) v4(160.41,50.31)
+1.2V_RTM: length 71.9
  TOP w0.203: UP2.18 334.25,49.23 334.11,49.37 CP12.1 ; CP11.1 336.02,40.69 335.45,41.26 UP2.46 ; UP2.11 337.88,47.04 338.62,47.78 v2(338.75,47.78) ; UP2.43 334.25,40.48 CP9.1 ; UP2.6 338.29,45.04 338.68,45.43 339.51,45.43 v2(339.57,45.49) ; CP13.1 336.44,49.94 336.22,49.94 335.45,49.17 UP2.15
  TOP w0.508: CP12.1 334.67,49.99 v2(334.81,50.13) ; CP11.1 336.49,40.24 336.63,40.1 CP8.1 337.03,38.6 CP28.1 337.05,37.25 RP31.2 337.03,37.04 336.53,36.53 v2(336.18,36.53) 335.97,36.32 335.97,36.07 332.94,33.05 QZ2.3 ; CP9.1 CP10.1 334.44,38.97 v2(334.18,38.7) ; CP13.1 CP14.1 336.49,51.86 336.41,51.93 336.41,52.81 v2(336.59,52.99) 337.71,54.1 v1(338.48,54.1) 341.05,54.1 341.53,53.62 CP7.1 CP5.1 CP6.1 341.33,51.02 340.85,50.55 v2(340.85,50.37)
  IN2 w0.508: v2(336.59,52.99) 336.13,52.53 336.13,51.45 v2(334.81,50.13) 330.43,50.13 328.59,48.29 328.59,48.22 ; v2(340.85,50.37) 340.85,50.27 338.75,48.16 v2(338.75,47.78) 338.75,46.32 v2(339.57,45.49) ; 328.59,48.22 v2(328.54,48.22) ; 328.59,48.22 328.88,47.93 330.39,47.93 330.94,47.39 330.94,42.13 332.08,40.99 333.48,40.99 334.18,40.29 v2(334.18,38.7) 334.18,38.32 334.62,37.87 335.57,37.87 336.18,37.27 v2(336.18,36.53)
+1.2V_VCCK: length 14.6
  TOP w0.127: v2(324.07,35.34) v1(324.07,34.53)
  TOP w0.14: UVGA1.4 v2(320.01,35.58)
  TOP w0.508: CVGA7.1 324.07,35.94 v2(324.07,35.34)
  IN2 w0.508: v2(324.07,35.34) 320.24,35.34 v2(320.01,35.58) 320.01,35.61 316.22,39.4 316.22,40.11 315.74,40.59 v2(315.74,41.58)
+1.2V_VCCPLL_OC: length 281.7
  TOP w0.127: v4(222.8,56.29) 222.7,56.19 v2(222.7,55.08)
  TOP w0.508: v2(168.96,86.3) 168.81,86.15 RH107.1 ; QZ2.1 335.03,33.84 RP31.1
  TOP w1.524: 321.93,52.23 321.93,48.85 325.29,45.49 325.29,45.28
  IN2 w1.016: 223.95,54.21 228.58,54.21 229.44,55.07 233.63,55.07 236.12,57.56 241.1,57.56
  IN3 w1.524: 245.25,69.36 245.29,69.4 267.42,69.4 274.88,61.94 285.85,61.94 287.25,60.54 294.18,60.54 299.67,55.06 305.96,55.06 307.38,53.63 310.9,53.63 312.75,51.78 318.9,51.78 319.81,52.7
  IN4 w1.016: 200.01,48.57 199.71,48.87 197.12,48.87 196.67,49.33 189.75,49.33 184.46,54.63 184.46,60 181.75,62.7 181.75,66.08 182.31,66.64 182.31,69.19 181.97,69.54 181.97,70.39 180.94,71.41 177.89,71.41 177.28,70.81 140.03,70.81 137.63,73.21 137.63,75.5 140.26,78.13
  BOTTOM w0.305: v2(176.07,84.47) 176.4,84.8 UH1.G11 ; UH1.BH13 145,85.72 v2(145.19,85.72)
  BOTTOM w0.508: 241.34,52.86 241.47,52.99 241.47,55.02 241.91,55.46 241.91,56.16 ; 242.84,56.19 242.84,53.41 242.29,52.86
  BOTTOM w1.016: 204.01,47.65 236.13,47.65 241.34,52.86
  BOTTOM w1.524: 243.75,56.34 246.77,59.36 246.77,63.64 243.24,67.17 243.24,67.97 ; 336.55,39.84 333.02,39.84 332.21,39.03 332.21,38.36 331.23,37.38 329.72,37.38 329.19,37.91 327.92,37.91 326,39.82 326,40.66 325.16,41.51 325.16,42.69
  vias: v2(203.28,48.2) v2(223.29,55.08) v2(242.24,58.18) v2(242.25,57.58) v2(242.91,68.99) v2(243.5,68.99) v2(244.08,68.99) v2(321.02,53.43) v2(321.6,53.43) v2(322.24,53.43) v2(324.52,43.73) v2(324.93,44.16) v2(325.22,43.65) v2(339.19,37.75) v2(339.79,37.75)
+1.2V_VCCPLL_OC_OUT: length 2
  TOP w0.127: RZ67.1 225.46,54.02 v1(224.14,55.34)
+1.2VP: length 25.1
  TOP w0.203: v2(107.41,67.07) 107.51,66.97 108.86,66.97 109.04,66.78 110.04,66.78 PU200.19 ; 112.68,64.8 112.39,65.09 PU200.5
  TOP w0.254: 112.68,64.8 v2(113,64.8)
  TOP w0.508: v2(113,64.8) 112.73,64.53 PR205.2
  IN4 w0.508: v2(113,64.8) 114.85,64.8 118.21,68.16 118.21,74.01 v2(117.26,74.96)
  IN5 w0.508: v2(107.41,67.07) 108.51,67.07 110.78,64.8 v2(113,64.8)
  vias: v2(116.63,76.23) v2(116.63,75.59) v2(116.63,74.96) v2(117.26,76.23) v2(117.26,75.59) v4(118.97,76.14)
+1.8V_AVDD: length 11.7
  TOP w0.203: HDA1.40 345.45,23.97 346.28,24.79 346.28,25.15 CA2.1
  TOP w0.457: v2(351.45,25.64) 351.45,26.13 CA1.1
  TOP w0.508: CA1.1 CA63.2 349.54,26.32 349.04,25.81 347.14,25.81 346.81,25.48 CA2.1
  BOTTOM w0.127: v2(351.45,25.64) 351.05,26.04 v1(351.05,26.18)
  BOTTOM w0.508: v2(351.45,25.64) 351.51,25.58 RA1.2
+1.8V_DVDD: length 184.3
  TOP w0.203: HDA1.36 347.5,22.47 347.85,22.82 v2(348.34,22.82)
  TOP w0.508: RA57.2 334.19,12.82 v2(334.19,19.83) 333.83,20.18 333.62,20.18 331.81,21.99 331.81,22.72 329.72,24.82 v1(328.89,24.82) 321.94,24.82 v2(317.9,28.86) ; v2(228.35,59.01) 228.17,59.18 227.2,59.18 RE146.1 ; v2(334.7,21.75) 334.53,21.91 RA58.1 334.53,23.29 335.08,23.84 CA3.1
  IN1 w0.508: v2(348.34,22.82) 348.08,22.82 346.56,21.3 341.99,21.3 341.54,21.75 v2(334.7,21.75)
  IN3 w0.508: v2(232.07,68.86) 233.02,67.92 236.84,67.92 237.24,67.51 266.78,67.51 275.06,59.23 275.06,56.23 275.44,55.84 276.78,55.84 277.86,56.92 283.29,56.92 283.79,56.92 283.8,56.92 284.52,56.92 285.73,58.13 292.52,58.13 297.03,53.62 304.33,53.62 306.74,51.21 306.74,49.81 305.09,48.16 v2(305.09,47.65)
  BOTTOM w0.508: v2(317.9,28.86) 317.9,29.45 316.84,30.51 310.15,30.51 307.05,33.61 307.05,39.99 306.06,40.97 306.06,41.6 306.05,41.62 306.05,42.91 305.92,43.04 305.92,46.83 v2(305.09,47.65) ; RA1.1 348.78,23.27 v2(348.34,22.82) ; v2(334.7,21.75) 334.7,20.34 v2(334.19,19.83) ; v2(228.35,59.01) 228.35,59.63 230.09,61.37 230.09,64.35 232.07,66.33 v2(232.07,68.86)
+1.8V_PRIM: length 390
  TOP w0.127: 266.52,74.78 v4(266.52,76.98)
  TOP w0.508: v2(289.48,34.56) 288.94,34.56 RH546.2 ; RH67.2 287.92,25.96 287.49,25.53 v2(286.97,25.53)
  TOP w2.032: 265.89,70.42 260.82,65.36 237.69,65.36 232.82,70.23 228.49,70.23 227.05,68.8 222.51,68.8 219.37,71.94
  IN2 w0.508: v2(312,8.96) 312.68,8.28 314.05,8.28 315.76,6.57 317.98,6.57 318.62,7.2 326.06,7.2 329.13,10.28 329.13,19.81 324.42,24.53 320.03,24.53 v2(318.58,23.08) ; v2(289.48,34.56) 289.48,34.37 289.92,33.94 289.92,33.72 289.92,33.71 289.92,33.34 290.05,33.22 290.05,32.1 290.04,32.09 290.04,30.86 289.67,30.49 288.98,30.49 288.62,30.85 287.91,30.85 287.06,30 287.06,28.79 286.77,28.5 286.77,27.27 286.97,27.07 v2(286.97,25.53)
  IN2 w1.016: 313.89,52.71 313.89,51.86 314.77,50.98 314.77,40.5 314.08,39.82 314.08,38.99 315.45,37.63 315.74,37.63 316.45,36.92 316.45,35.6 317.6,34.45 v2(317.6,32.58) 317.6,32.26 319.01,30.85 325.54,30.85 326.05,30.34 326.05,27.33 327.06,26.32 333.76,26.32
  IN3 w0.508: 289.92,32.92 291.8,32.92 291.97,33.09 294.1,33.09 294.69,33.68 295.94,33.68 297.08,32.54 299.44,32.54 302.91,36.01 304.89,36.01 307.32,33.59 307.32,32.44 310.08,29.67 310.08,26.46 310.81,25.73 311.68,25.73 314.88,22.53 318.03,22.53 v2(318.58,23.08)
  IN3 w1.016: 265.47,86.3 265.47,82.86 266.82,81.51 266.82,80.3 267.26,79.86 267.26,78.17 267.59,77.84 268.72,77.84 269.39,78.51 269.39,79.61 269.83,80.04 271.18,80.04 273.88,77.35 273.88,75.72 275.5,74.1 277.12,74.1 287.57,63.66 293.79,63.66 300.93,56.52 306.44,56.52 307.95,55.01 312.51,55.01 313.09,54.42
  IN4 w0.508: v2(158.54,131.79) 158.23,131.49 158.23,128.83 157.37,127.97 157.37,124.75 159.09,123.02 161.66,123.02 163.33,124.69 164.97,124.69 165.71,123.95 166.31,123.95 166.79,124.43 166.79,125.62 167.34,126.16 169.58,126.16 170.47,125.28 170.47,124.77 171.88,123.36 171.88,117.52 173.18,116.22 174.24,116.22 174.43,116.41 179.65,116.41 180.29,115.77 180.29,110.08 180.89,109.48 183.58,109.48 185.95,107.1 185.95,105.69 187.4,104.24 187.4,104.23 187.96,103.67 187.96,102.36 194.9,95.42 194.9,90.31 195.61,89.6 195.61,88.52 v2(195.86,88.27)
  IN5 w0.457: 218.73,73.94 v2(219.37,73.94)
  IN5 w0.508: 218.73,73.94 218.16,74.51 214.43,74.51 214.06,74.88 208.29,74.88 207.62,74.21 205.94,74.21 204.09,76.05 200.38,76.05 199.37,77.05 199.37,77.33 197.68,79.02 197.68,81.33 198.11,81.77 198.11,86.81 196.65,88.27 v2(195.86,88.27)
  BOTTOM w0.203: UH2.BA31 281.52,32.39 v2(281.17,32.75)
  BOTTOM w0.508: v2(312,8.96) RH578.2 311.25,7.65 RE15.1 ; v2(158.54,131.79) 158.46,131.86 PR6042.2 ; v2(286.97,25.53) RH128.2 ; v2(317.6,32.58) 318.8,31.38 318.8,28.36 319.28,27.89 319.28,23.78 v2(318.58,23.08)
  vias: v2(218.83,74.79) v2(219.37,75.11) v2(219.37,74.53) v2(219.37,73.31) v2(265.47,89.31) v2(265.47,88.67) v2(265.47,88.04) v2(265.47,87.4) v2(266.42,74.45) v2(266.42,73.82) v2(266.42,73.18) v2(266.42,72.55) v2(313.48,53.56) v2(314.11,53.56) v2(334.99,26.42) v2(335.57,26.42)
+1.8VA_TBTA_LDO: length 4.5
  TOP w0.14: CT100.1 357.87,71.13 356.73,69.99 v1(356.5,69.99)
  TOP w0.508: v2(358.24,72.74) 357.88,72.37 CT100.1
  BOTTOM w0.203: v2(358.24,72.74) 358.49,72.74 UT4.K1
+1.8VALW_EC: length 5.3
  TOP w0.127: v1(309.06,5.16) v2(309.06,6.07)
  TOP w0.203: v2(309.06,6.07) 309.2,6.2 UE1.54
  BOTTOM w0.508: v2(309.06,6.07) 309.67,6.67 309.67,7.84 308.79,7.84 CE71.1
+1.8VD_TBTA_LDO: length 3.1
  BOTTOM w0.229: UT4.A2 359.44,67.57 358.71,66.85 358.71,66.54
  BOTTOM w0.381: CT99.1 358,66 358.31,66.31 v1(358.48,66.31) 358.71,66.54
+1.8VS: length 5.7
  TOP w0.14: RA57.1 331.74,9.21 331.26,9.69 331.26,11.55 v1(331.56,11.85)
  TOP w0.508: RA57.1 CA7.1 332.2,8.27 332.5,7.97 UA1.5
+1.8VSP: length 3.1
  BOTTOM w0.254: v2(268.26,82.07) 267.12,82.07 266.52,81.47 PR18V02.1 PC18V03.1
  vias: v2(268.14,86.32) v2(268.26,85.5) v2(268.72,86.32) v4(269.15,85.09)
+1.35VS_VGA: length 77.7
  TOP w0.381: CG122.1 258.86,113.3 CG125.1
  BOTTOM w0.152: UG6.G14 UG6.G13
  BOTTOM w0.203: v2(228.13,141.18) 228.93,141.18 UG1.B1
  BOTTOM w0.254: v2(244.13,129.98) 243.73,130.38 UG4.B12 ; v2(227.34,135.56) 227.72,135.18 UG1.K3 v2(227.33,134.78) UG1.L4 ; UG6.C5 v2(251.2,101.15) v2(251.2,101.95) UG6.B3 ; v2(259.2,101.15) 259.6,100.75 UG6.N5 ; v2(261.6,78.31) 261.2,77.91 UG5.C5 ; v2(262.4,102.75) 262,102.35 UG6.T3 ; UG1.D3 227.72,139.98 v2(227.33,140.38) ; v2(234.53,141.98) 234.93,141.58 UG4.T1 ; v2(254.03,109.17) 254.43,109.57 UG3.P1 ; UG1.B14 v2(218.53,141.18) ; UG6.P3 v2(260.8,101.95) ; UG5.T3 250.4,75.91 v2(250.4,75.91) ; v2(203.06,133.3) 203.46,132.9 UG2.E5 ; UG5.D3 260.41,76.31 v2(260.81,76.71) ; v2(229.73,141.98) 229.33,141.58 UG1.B1 229.32,141.58 v2(228.93,141.98) ; UG3.D11 262.43,117.57 ; UG3.B3 v2(263.63,111.57) ; UG1.P3 v2(227.33,132.38) ; UG3.C5 263.23,112.77 v2(263.63,113.17) ; UG6.B1 v2(250.4,104.35) ; v2(237.73,133.18) 237.73,133.18 237.73,133.17 UG4.E5 ; UG2.C10 v2(207.86,130.78) ; v2(263.63,116.37) 263.23,116.77 UG3.C10 ; UG1.G2 v2(228.93,137.98) UG1.F1 229.33,138.38 ; v2(259.6,81.36) 259.6,81.36 UG5.E10 ; v2(201.46,129.98) 201.86,130.38 UG2.B3 ; v2(261.6,85.51) 262,85.11 UG5.B14 ; UG4.B3 v2(236.93,130.78) ; UG2.P3 201.86,139.98 v2(202.26,140.38) ; v2(261.6,81.51) 261.2,81.91 UG5.C10 ; v2(256.43,109.97) 256.83,110.37 UG3.L2 256.83,110.37 v2(256.43,110.77) 256.03,111.17 UG3.M3 v2(255.63,110.77) ; 257.65,118.37 UG3.K12 ; UG6.D1 v2(252,104.35) ; UG4.P3 v2(236.93,140.38) ; v2(250.4,92.95) 250.8,93.35 UG6.B14 ; UG1.B12 v2(220.13,141.18) ; v2(264.43,117.97) 264.03,118.37 UG3.B12 ; UG5.B3 v2(261.6,76.71) ; UG2.C5 203.46,131.18 v2(203.06,130.78) ; UG2.B1 200.26,130.38 v2(199.86,129.98) ; UG3.T14 v2(252.43,120.37) ; UG3.T1 252.83,109.57 v2(252.43,109.17) ; v2(211.17,131.6) 210.79,131.98 UG2.D14 ; v2(253.71,101.15) 253.6,101.15 UG6.E5 ; UG2.T3 v2(201.46,141.98) ; UG9.K41 v2(229.15,107.35) ; UG9.M10 v2(227.75,86.25) ; UG3.E5 261.63,112.77 v2(261.23,113.17) ; UG2.P1 v2(199.86,140.38) ; v2(260.8,104.35) 260.4,103.95 UG6.P1 ; v2(228.13,141.18) 227.73,141.58 UG1.B3 ; v2(203.06,138.78) 203.46,139.18 UG2.N5 ; UG6.B12 v2(250.4,94.75) ; v2(252,74.31) 252.39,74.71 UG5.P1 ; v2(236.93,141.98) 236.53,141.58 UG4.T3 ; UG5.N10 v2(252.8,82.31) UG5.P11 v2(252,83.11) UG5.P12 ; UG2.R10 207.46,140.78 v2(207.06,141.18) ; v2(242.53,130.78) 242.13,131.18 UG4.C10 ; UG6.C10 v2(251.2,96.35) ; UG5.R5 v2(251.2,77.51) ; UG4.C5 v2(237.73,130.78) ; v2(259,78.45) 259.06,78.45 259.6,77.91 UG5.E5 ; UG1.R5 226.13,131.18 v2(226.53,130.78) ; v2(207.86,137.98) 208.26,137.58 UG2.L11 ; v2(255.63,109.17) 256.03,109.57 UG3.M1 256.03,109.57 v2(256.43,109.17) 256.83,109.57 UG3.L1 ; UG3.N5 v2(255.63,112.37) ; UG4.P14 v2(245.73,140.38) ; v2(262.4,74.31) UG5.B1 ; UG5.R10 v2(251.2,82.31) ; UG6.T12 v2(261.6,95.55) ; UG9.AF43 v2(218.55,108.75) ; v2(199.86,131.58) 200.26,131.98 UG2.D1 ; UG5.T12 v2(250.4,83.91) ; v2(260.8,74.31) UG5.D1 ; v2(262.83,111.57) 262.43,111.17 UG3.D3 ; UG4.D14 v2(245.93,131.98) ; v2(261.6,83.91) 262,83.51 UG5.B12 ; v2(209.46,131.64) 209.12,131.98 UG2.D12 v2(208.66,131.58) UG2.D11 v2(207.86,132.38) UG2.E10 ; UG1.G1 v2(229.73,137.98) ; v2(207.06,139.58) 207.46,139.18 UG2.N10 ; UG3.R10 v2(253.23,117.17) ; UG2.B12 v2(209.46,129.98) ; UG6.D3 v2(252.8,102.75) ; UG2.D3 v2(201.46,132.38) ; v2(254.83,111.57) 254.43,111.17 UG3.P3 ; UG5.P14 v2(252,85.51) ; UG1.T12 v2(220.13,129.98) ; UG1.N5 v2(226.53,133.18) ; UG6.D14 252.4,93.35 v2(252,92.95) ; UG3.T12 v2(252.43,118.77) ; UG6.T14 v2(262.4,93.15) ; UG9.K12 v2(229.15,87.65) ; v2(250.4,74.31) 250.8,74.71 UG5.T1 ; UG3.T3 v2(252.43,110.77) ; UG4.D3 v2(236.13,132.38) ; UG1.T3 v2(228.13,130.78) ; UG3.R5 v2(253.23,112.37)
  BOTTOM w0.3: v2(219.4,108) 219.4,108.1 UG9.AD42 ; v2(212.2,108) 211.95,108.25 UG9.AR42 ; UG9.AG43 v2(217.25,108.75) ; UG9.AG42 217.3,108.1 v2(217.3,108) ; UG9.P43 v2(226.95,108.75) ; UG9.V43 v2(223.55,108.75) ; UG9.M43 v2(227.75,108.75) ; UG9.P42 226.9,108.1 v2(226.9,108) ; UG9.AD43 v2(219.35,108.75) ; v2(225.7,108) 225.7,108.1 UG9.R42 ; UG9.AA43 v2(221.45,108.75) ; UG9.AA42 221.5,108.1 v2(221.5,108) ; v2(220.6,108) 220.6,108.1 UG9.AC42 ; UG9.V42 223.6,108.1 v2(223.6,108) ; UG9.Y43 v2(222.75,108.75) ; UG9.AC43 v2(220.65,108.75) ; UG9.R43 v2(225.65,108.75) ; UG9.Y42 222.7,108.1 v2(222.7,108) ; UG9.U43 v2(224.85,108.75)
  BOTTOM w0.508: RG582.1 v2(240.83,75.53) ; CG150.1 261.9,87.16 v2(261.59,86.85)
  vias: v2(199.86,141.98) v2(199.86,137.98) v2(199.86,133.98) v2(199.86,133.18) v2(200.61,142.84) v2(200.66,133.98) v2(201.38,138.01) v2(201.46,133.98) v2(202.26,137.18) v2(202.26,136.38) v2(202.26,135.58) v2(202.26,134.78) v2(204.63,141.57) v2(208.66,141.18) v2(208.66,140.38) v2(208.66,136.38) v2(208.66,133.98) v2(209.46,138.78) v2(209.46,137.98) v2(209.46,134.78) v2(209.46,133.98) v2(209.46,133.18) v2(211.06,141.98) v2(211.06,140.38) v2(211.06,138.78) v2(211.06,137.98) v2(211.15,132.55) v2(211.12,130.17) v2(212.25,108.75) v2(213.05,108.75) v2(214.35,108.75) v2(214.3,108) v2(215.15,108.75) v2(215.2,108) v2(215.2,87) v2(215.15,86.25) v2(216.4,108) v2(216.4,87) v2(216.45,108.75) v2(216.45,86.25) v2(217.25,86.25) v2(217.3,87) v2(218.53,139.58) v2(218.53,138.78) v2(218.53,137.98) v2(218.53,131.58) v2(218.53,129.98) v2(218.55,86.25) v2(219.33,133.98) v2(219.35,86.25) v2(219.4,87) v2(220.13,138.78) v2(220.13,137.98) v2(220.13,134.78) v2(220.13,133.98) v2(220.6,87) v2(220.65,86.25) v2(220.93,140.38) v2(220.93,136.38) v2(220.93,133.98) v2(220.93,131.58) v2(221.5,87) v2(221.45,86.25) v2(221.73,140.38) v2(221.73,137.98) v2(221.73,133.18) v2(221.73,131.58) v2(222.53,141.18) v2(222.68,139.18) v2(222.7,87) v2(222.75,86.25) v2(223.55,86.25) v2(224.8,87) v2(224.85,86.25) v2(225.65,86.25) v2(225.73,141.18) v2(225.73,138.78) v2(225.7,87) v2(226.95,86.25) v2(227.33,137.98) v2(227.33,137.18) v2(227.33,136.38) v2(228.13,133.98) v2(228.13,133.18) v2(228.4,106.5) v2(228.4,104.4) v2(228.4,102.3) v2(228.4,101.1) v2(228.4,98.1) v2(228.36,97) v2(228.4,94.8) v2(228.4,91.8) v2(228.93,133.98) v2(229.15,106.55) v2(229.15,105.25) v2(229.15,104.45) v2(229.15,103.15) v2(229.15,102.35) v2(229.15,101.05) v2(229.15,100.25) v2(229.15,98.95) v2(229.15,98.15) v2(229.15,96.85) v2(229.15,96.05) v2(229.15,94.75) v2(229.15,93.95) v2(229.15,92.65) v2(229.15,91.85) v2(229.15,90.55) v2(229.15,89.75) v2(229.15,88.45) v2(229.73,140.38) v2(229.73,138.78) v2(229.73,133.18) v2(229.73,131.58) v2(229.73,130.78) v2(234.53,140.38) v2(234.53,138.78) v2(234.53,137.98) v2(234.53,133.98) v2(234.53,133.18) v2(234.53,131.58) v2(234.53,130.78) v2(235.33,137.98) v2(235.33,133.98) v2(236.13,137.98) v2(236.13,133.98) v2(236.93,137.18) v2(236.93,136.38) v2(236.93,135.58) v2(236.93,134.78) v2(237.73,138.78) v2(238.53,141.18) v2(241.73,141.18) v2(241.73,138.78) v2(242.53,140.38) v2(242.53,139.58) v2(242.53,137.98) v2(242.53,132.38) v2(243.33,141.18) v2(243.33,140.38) v2(243.33,136.38) v2(243.33,133.98) v2(243.33,131.58) v2(244.13,138.78) v2(244.13,137.98) v2(244.13,134.78) v2(244.13,133.98) v2(244.13,133.18) v2(244.13,131.58) v2(245.73,141.98) v2(245.73,138.78) v2(245.73,137.98) v2(245.93,134.38) v2(245.93,133.58) v2(248.16,130.38) v2(250.4,85.51) v2(252,95.55) v2(252.8,96.35) v2(252.8,76.71) v2(253.6,104.35) v2(253.6,94.75) v2(253.6,92.98) v2(253.6,85.51) v2(253.6,77.51) v2(253.6,75.91) v2(253.6,74.31) v2(254.03,120.37) v2(254.03,117.97) v2(254.4,103.55) v2(254.4,102.75) v2(254.4,95.55) v2(254.4,94.75) v2(254.4,92.98) v2(254.4,85.51) v2(254.4,84.71) v2(254.4,83.91) v2(254.4,83.11) v2(254.4,75.91) v2(254.4,75.11) v2(254.4,74.31) v2(254.83,117.17) v2(255.11,94.75) v2(255.13,76.71) v2(255.2,101.95) v2(255.2,83.91) v2(255.63,120.37) v2(256,101.95) v2(256,76.71) v2(256.43,120.37) v2(256.43,119.57) v2(256.43,118.77) v2(256.43,117.97) v2(256.8,101.95) v2(256.8,95.55) v2(256.8,83.11) v2(256.8,76.71) v2(257.23,111.57) v2(257.6,101.95) v2(257.6,76.71) v2(258.03,111.57) v2(258.1,73.05) v2(258.1,72.42) v2(258.4,104.35) v2(258.4,103.55) v2(258.4,102.75) v2(258.4,96.35) v2(258.4,94.75) v2(258.4,93.15) v2(258.4,85.51) v2(258.4,83.91) v2(258.4,83.11) v2(258.4,82.31) v2(258.4,76.71) v2(258.4,75.11) v2(258.4,74.31) v2(258.74,73.69) v2(258.74,73.05) v2(258.74,72.42) v2(258.83,118.77) v2(258.83,111.57) v2(259.2,104.35) v2(259.2,97.15) v2(259.2,94.75) v2(259.2,93.15) v2(259.18,86.59) v2(259.2,85.51) v2(259.2,75.91) v2(259.2,74.31) v2(259.37,73.69) v2(259.37,73.05) v2(259.37,72.42) v2(259.63,111.57) v2(260,96.35) v2(260,85.51) v2(260.01,73.69) v2(260.01,73.05) v2(260.01,72.42) v2(260.11,107.56) v2(260.43,120.37) v2(260.43,118.77) v2(260.42,117.96) v2(260.43,117.17) v2(260.43,111.57) v2(260.43,109.17) v2(260.64,73.69) v2(260.64,73.05) v2(260.64,72.42) v2(260.8,97.15) v2(260.8,96.35) v2(260.8,95.55) v2(260.8,93.15) v2(260.8,83.11) v2(261.23,120.37) v2(261.23,109.17) v2(261.28,73.69) v2(261.28,73.05) v2(261.28,72.42) v2(261.63,116.22) v2(261.63,100.35) v2(261.6,97.15) v2(261.91,73.69) v2(261.91,73.05) v2(261.91,72.42) v2(262.03,120.37) v2(262.03,117.17) v2(262.1,130.77) v2(262.1,130.14) v2(262.1,129.5) v2(262.1,128.87) v2(262.4,104.35) v2(262.55,73.69) v2(262.55,73.05) v2(262.55,72.42) v2(262.83,117.97) v2(262.83,109.17) v2(263.18,73.69) v2(263.18,73.05) v2(263.18,72.42) v2(263.63,120.37) v2(263.82,73.69) v2(263.82,73.05) v2(263.82,72.42) v2(263.87,76.03) v2(263.87,75.44) v2(263.87,74.86) v2(263.87,74.27) v2(264.32,104.77) v2(264.31,98.13) v2(264.26,97.12) v2(264.43,109.17) v2(264.44,102.82) v2(264.39,101.09) v2(264.4,73.05) v2(264.4,72.42) v2(264.5,99.59) v2(264.45,75.44) v2(264.45,74.86) v2(264.45,74.27) v2(264.45,73.69) v2(265.04,75.44) v2(265.04,74.86) v2(265.04,74.27) v2(265.04,73.69) v2(264.99,73.05) v2(264.99,72.42) v4(251.36,139.28)
+1.35VS_VGAP: length 36.2
  TOP w0.14: v4(242.9,50.61) v2(241.45,50.61)
  TOP w0.508: PR813.1 231.81,52.23 v2(231.53,51.95)
  IN2 w0.508: v2(231.53,51.95) 233.47,51.95 233.86,51.55 240.51,51.55 v2(241.45,50.61)
  BOTTOM w0.508: 253.91,64.93 249.53,64.93 248.01,63.4 248.01,57.37 244.07,53.43 244.07,51.78 v4(242.9,50.61) v2(241.45,50.61)
+1.35VS_VGAP_B+: length 3.2
  TOP w0.14: PL800.1 243.14,58.58 v1(241.94,59.78)
+1V8_AON: length 280.7
  TOP w0.356: v2(208.21,80.8) 208.12,80.89 RG522.2 ; RG163.2 v2(196.2,95.09)
  TOP w0.381: v2(204.53,82.16) 204.34,81.97 RG168.2
  TOP w0.406: RG156.1 188.75,59.94 QG8.2 ; v2(192.32,62.89) 192.18,62.75 191.28,62.75 RG571.1 190.95,62.42 190.95,62.13 QG8.5
  TOP w0.508: v2(189.3,58.82) 188.75,59.37 RG156.1 ; PR811.2 231.1,50.45 v2(230.5,51.05) ; v2(203.81,59.08) 203.37,59.53 RG71.1
  IN2 w0.508: v2(207.4,88.5) 207.4,88.83 207.11,89.12 200.7,89.12 196.2,93.61 v2(196.2,95.09)
  IN3 w0.254: v2(117.98,88.01) 118.49,88.01 122.56,92.08 122.56,92.61 v2(123.51,93.56)
  IN3 w0.508: v2(202.48,64.73) 202.48,65.09 202.03,65.54 200.18,65.54 199.61,64.97 199.61,63.95 199.14,63.49 198.12,63.49 196.74,64.87 195.74,64.87 193.76,62.89 v2(192.32,62.89)
  IN4 w0.508: v2(204.96,69.96) 204.96,68.74 204.36,68.14 203.21,68.14 201.99,66.92 201.99,65.57 202.48,65.09 v2(202.48,64.73) 202.8,64.73 203.17,64.37 203.17,60.5 203.81,59.86 v2(203.81,59.08)
  IN5 w0.508: v2(230.5,51.05) 230.5,47.12 227.79,44.4 227.79,37.98 225.05,35.23 178.2,35.23 178.09,35.34 172.31,35.34 171.88,35.77 168.11,35.77 167.94,35.59 166.66,35.59 166.33,35.27 142.85,35.27 141.98,36.14 141.98,40.58 123.15,59.41 123.15,87.88 122.64,88.39 122.64,93.22 122.99,93.56 v2(123.51,93.56)
  BOTTOM w0.25: UG9.BC14 v2(206.65,88.45)
  BOTTOM w0.254: UG9.BB14 207.15,88.75 v2(207.4,88.5) ; UG31.5 116.13,88.91 116.46,88.59 117.01,88.59 CG527.1 117.5,88.5 v2(117.98,88.01) ; UG9.BA10 v2(207.45,85.65)
  BOTTOM w0.356: RG502.2 RG579.2 204.22,77.14 204.55,76.81 v2(204.83,76.81) ; CG526.1 201.59,75.64 201.4,75.45 201.4,75.28 v2(201.27,75.15) ; 196.97,73.48 196.93,73.52 RG21.2 ; 196.97,73.48 196.72,73.23 196.72,72.33 196.83,72.23 196.83,72.06 197.18,71.71 RG18.2 CG483.1 ; 196.97,73.48 RG81.2 ; RG166.2 192.7,71.1 193.04,71.44 193.04,72.21 v2(193.63,72.8) ; RG161.1 195.45,75.21 v2(195.05,75.21)
  BOTTOM w0.381: v2(199.54,74.24) 200.07,74.77 UG10.5
  BOTTOM w0.406: v2(204.4,73.28) UG29.5
  BOTTOM w0.457: RG80.2 198.84,73.48 199.22,73.86 199.22,73.88 199.54,74.2 v2(199.54,74.24)
  BOTTOM w0.508: v2(204.96,69.96) 204.96,70.01 205.49,70.54 206.57,70.54 RG159.1 ; v2(192.32,62.89) 192.32,60.89 190.3,58.87 189.35,58.87 189.35,58.82 v2(189.3,58.82) ; RG18.2 197.64,71.71 v2(198.03,72.1) ; v2(200.45,71.48) RG17.2 ; RG80.2 RG81.2 ; RG167.1 209.53,73.56 v2(209.99,74.01) ; v2(230.5,51.05) 229.71,50.26 220.79,50.26 218.97,52.07 218.97,62.58 v2(219.79,63.39) ; PR10V6.1 v2(123.51,93.56)
  vias: v1(218.49,60.3) v2(188,82.36) v2(188,81.78) v2(190.27,79.09) v2(190.67,78.64) v2(198.48,79.4) v2(202.87,76.86) v2(205.87,75.72) v2(207.24,85.13) v2(207.46,86.37) v2(208.16,84.96) v2(213.59,70.01) v2(214.17,70.01) v2(214.76,70.01) v2(215.34,70.01) v2(217.54,75.12) v2(217.48,73.73) v2(218.12,75.12) v2(218.06,73.73)
