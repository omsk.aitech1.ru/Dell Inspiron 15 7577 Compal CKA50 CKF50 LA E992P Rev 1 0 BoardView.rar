# Allegro board Dell_Inspiron_15_7577_Compal_CKA50_CKF50_LA_E992P_Rev_1_0_BoardView.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
SN65LVPE502ARGER_VQFN24_4X4-S
  oval 0.254x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 13(2.5,4.1) 14(2,4.1) 15(1.5,4.1) 16(1,4.1) 17(0.5,4.1) 18(0,4.1)
  oval 0.889x0.254 smd: 7(3.3,0.8) 8(3.3,1.3) 9(3.3,1.8) 10(3.3,2.3) 11(3.3,2.8) 12(3.3,3.3) 19(-0.8,3.3) 20(-0.8,2.8) 21(-0.8,2.3) 22(-0.8,1.8) 23(-0.8,1.3) 24(-0.8,0.8)
  rect 2.108x2.108 smd: 25(1.25,2.05)
SN74LVC1G06DCKR_SC70-5
  oval 0.381x0.864 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.74) 5(0,1.74)
SSM3K7002FU_SC70-3
  oval 0.508x0.991 smd: 1(0,0) 2(0.65,1.9) 3(-0.65,1.9)
SW_SKRBAAE010_4P
  rect 0.889x1.219 smd: 1(0,0) 2(3.9,0) 3(0,4.075) 4(3.9,4.075)
SY6288C20AAC_SOT23-5
  oval 0.559x0.787 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.4) 5(0,2.4)
SY6288D20AAC_SOT23-5
  oval 0.559x0.787 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.4) 5(0,2.4)
SY8286RAC_QFN20_3X3
  oval 0.889x0.254 smd: 1(0,0) 2(0,-0.45) 3(0,-0.9) 4(0,-1.35) 5(0,-1.8) 11(3.1,-1.8) 12(3.1,-1.35) 13(3.1,-0.9) 14(3.1,-0.45) 15(3.1,0)
  oval 0.254x0.889 smd: 6(0.65,-2.45) 7(1.1,-2.45) 8(1.55,-2.45) 9(2,-2.45) 10(2.45,-2.45) 16(2.45,0.65) 17(2,0.65) 18(1.55,0.65) 19(1.1,0.65) 20(0.65,0.65)
  rect 0.991x0.991 smd: 21(1.55,-0.9)
T-SOL_156-1001902607_11P
  round 1.143 hole 1.143 unplated: (-18.38,-2.8)
  round 1.651 hole 1.651 unplated: (2.62,-2.8)
  oval 0.991x1.702 smd: 1(0,0) 2(-2.5,0) 3(-5,0) 4(-7.5,0) 5(-10,0) 6(-12.5,0) 7(-14.93,0) 8(-16.63,0) 9(2.5,0)
  oval 0.711x1.702 smd: 10(-17.93,0) 11(-19.13,0)
  rect 1.397x2.794 smd: 12(4.62,-1.8) 13(-20.58,-1.8)
  oval 1.194x3.912 hole 0.61x3.302: 14(6.27,-11.65) 15(-20.03,-11.65)
TAI-T_HCB2012KF-121T50_2P
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
TC7SH08FU_SSOP5
  oval 0.406x0.787 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0,1.9)
TCS40DLR_SOT23F3
  oval 0.787x0.889 smd: 1(0,0) 2(0.95,2.1) 3(-0.95,2.1)
TOKO_1239AS-H-1R0M-P2_2P
  rect 0.787x2.007 smd: 1(0,0) 2(2,0)
TPC12
  round 0.305 smd: 1(0,0)
TPS2544RTER_WQFN16_3X3-S
  oval 0.254x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 9(1.5,3.1) 10(1,3.1) 11(0.5,3.1) 12(0,3.1)
  oval 0.889x0.254 smd: 5(2.3,0.8) 6(2.3,1.3) 7(2.3,1.8) 8(2.3,2.3) 13(-0.8,2.3) 14(-0.8,1.8) 15(-0.8,1.3) 16(-0.8,0.8)
  rect 1.651x1.651 smd: 17(0.75,1.55)
TPS22961DNYR_WSON8
  oval 0.305x0.508 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(1.95,2.7)
  oval 1.6x0.508 smd: 6(0.65,2.7)
  rect 2.388x1.6 smd: 7(0.975,1.35)
TPS22966DPUR_SON14_2X3
  oval 0.203x0.762 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.4,2.05) 9(2,2.05) 10(1.6,2.05) 11(1.2,2.05) 12(0.8,2.05) 13(0.4,2.05) 14(0,2.05)
  rect 2.489x0.889 smd: 15(1.2,1.025)
TPS51212DSCR_SON10_3X3
  oval 0.279x0.838 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2,2.95) 7(1.5,2.95) 8(1,2.95) 9(0.5,2.95) 10(0,2.95)
  custom 0.412x0.412 smd: 11(1,1.475)
TPS51285BRUKR_QFN20_3X3
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 11(3.1,-1.6) 12(3.1,-1.2) 13(3.1,-0.8) 14(3.1,-0.4) 15(3.1,0)
  oval 0.203x0.889 smd: 6(0.75,-2.35) 7(1.15,-2.35) 8(1.55,-2.35) 9(1.95,-2.35) 10(2.35,-2.35) 16(2.35,0.75) 17(1.95,0.75) 18(1.55,0.75) 19(1.15,0.75) 20(0.75,0.75)
  rect 1.702x1.702 smd: 21(1.55,-0.8)
TPS65982DAZQZR-ES_BGA_96P
  round 0.254 smd: A1(0,0) A2(0.5,0) A3(1,0) A4(1.5,0) A5(2.001,0) A6(2.501,0) A7(3.001,0) A8(3.501,0) A9(4.001,0) A10(4.501,0) A11(5.001,0) B1(0,-0.5) B2(0.5,-0.5) B3(1,-0.5) B4(1.5,-0.5) B5(2.001,-0.5) B6(2.501,-0.5) B7(3.001,-0.5) B8(3.501,-0.5) B9(4.001,-0.5) B10(4.501,-0.5) B11(5.001,-0.5) C1(0,-1) C2(0.5,-1) C10(4.501,-1) C11(5.001,-1) D1(0,-1.5) D2(0.5,-1.5) D5(2.001,-1.5) D6(2.501,-1.5) D7(3.001,-1.5) D8(3.501,-1.5) D10(4.501,-1.5) D11(5.001,-1.5) E1(0,-2.001) E2(0.5,-2.001) E4(1.5,-2.001) E5(2.001,-2.001) E6(2.501,-2.001) E7(3.001,-2.001) E8(3.501,-2.001) E10(4.501,-2.001) E11(5.001,-2.001) F1(0,-2.501) F2(0.5,-2.501) F4(1.5,-2.501) F5(2.001,-2.501) F6(2.501,-2.501) F7(3.001,-2.501) F8(3.501,-2.501) F10(4.501,-2.501) F11(5.001,-2.501) G1(0,-3.001) G2(0.5,-3.001) G4(1.5,-3.001) G5(2.001,-3.001) G6(2.501,-3.001) G7(3.001,-3.001) G8(3.501,-3.001) G10(4.501,-3.001) G11(5.001,-3.001) H1(0,-3.501) H2(0.5,-3.501) H4(1.5,-3.501) H5(2.001,-3.501) H6(2.501,-3.501) H7(3.001,-3.501) H8(3.501,-3.501) H10(4.501,-3.501) H11(5.001,-3.501) J1(0,-4.001) J2(0.5,-4.001) J10(4.501,-4.001) J11(5.001,-4.001) K1(0,-4.501) K2(0.5,-4.501) K3(1,-4.501) K4(1.5,-4.501) K5(2.001,-4.501) K6(2.501,-4.501) K7(3.001,-4.501) K8(3.501,-4.501) K9(4.001,-4.501) K10(4.501,-4.501) K11(5.001,-4.501) L1(0,-5.001) L2(0.5,-5.001) L3(1,-5.001) L4(1.5,-5.001) L5(2.001,-5.001) L6(2.501,-5.001) L7(3.001,-5.001) L8(3.501,-5.001) L9(4.001,-5.001) L10(4.501,-5.001) L11(5.001,-5.001)
TVNST52302AB0_SOT523-3
  oval 0.508x0.559 smd: 1(0,0) 2(-0.5,-1.4) 3(0.5,-1.4)
TVWDF1004AD0_DFN9
  oval 0.203x0.686 smd: 1(0,0) 2(0.5,0) 4(1.5,0) 5(2,0) 6(2,0.875) 7(1.5,0.875) 8(0.5,0.875) 9(0,0.875)
  oval 0.406x1.549 smd: 3(1,0.437)
UP9511PQGJ_VQFN40_5X5
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 9(0,-3.2) 10(0,-3.6) 21(5.1,-3.6) 22(5.1,-3.2) 23(5.1,-2.8) 24(5.1,-2.4) 25(5.1,-2) 26(5.1,-1.6) 27(5.1,-1.2) 28(5.1,-0.8) 29(5.1,-0.4) 30(5.1,0)
  oval 0.203x0.889 smd: 11(0.75,-4.35) 12(1.15,-4.35) 13(1.55,-4.35) 14(1.95,-4.35) 15(2.35,-4.35) 16(2.75,-4.35) 17(3.15,-4.35) 18(3.55,-4.35) 19(3.95,-4.35) 20(4.35,-4.35) 31(4.35,0.75) 32(3.95,0.75) 33(3.55,0.75) 34(3.15,0.75) 35(2.75,0.75) 36(2.35,0.75) 37(1.95,0.75) 38(1.55,0.75) 39(1.15,0.75) 40(0.75,0.75)
  rect 3.505x3.505 smd: 41(2.55,-1.8)
W25Q80DVSSIG_SO8
  oval 0.635x1.676 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,7.25) 6(2.54,7.25) 7(1.27,7.25) 8(0,7.25)
W25Q80EWSSIG_SO8
  oval 0.635x1.676 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,7.25) 6(2.54,7.25) 7(1.27,7.25) 8(0,7.25)
W25Q128FVSIQ_SO8
  oval 0.635x1.676 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,7.25) 6(2.54,7.25) 7(1.27,7.25) 8(0,7.25)
W25X20CLSNIG_SO8
  oval 0.635x1.854 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,5.165) 6(2.54,5.165) 7(1.27,5.165) 8(0,5.165)
Y_5YEA27000163IF50Q5_4P
  rect 1.295x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.7) 4(0,1.7)
Y_7V25000012_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.7) 4(0,1.7)
Y_7V25000014_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.7) 4(0,1.7)
Y_CM31532768DZFT_2P
  rect 1.092x1.905 smd: 1(0,0) 2(2.5,0)
Y_X1A000141000200_2P
  rect 0.991x1.803 smd: 1(0,0) 2(2.5,0)
Y_X3G024000DC1H_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.7) 4(0,1.7)

## Nets
1.0VS_VGAP_VIN: PC10V0.2 PC10V1.2 PL10V01.2 PU10V0.8 PU10V0.9 PU10V0.10
1.2V_B+: PC200.1 PC201.1 PC202.1 PC203.1 PJP200.2 PQ201.5 PR207.1
1.2V_PGOOD: PR206.2 PU200.10
1.2V_VDDQ_EN: CZ102.1 DZ1.2 PR209.1 RZ102.2
1.8V_B+: PC18V00.2 PC18V02.2 PJP18V1.2 PU18V00.2 PU18V00.3 PU18V00.4 PU18V00.5
1.8V_EN: PC18V09.1 PR18V00.2 PR18V04.1 PU18V00.11
1V8_AON_ON: QG503.2 RG70.2 UG12.3 UG25.4
1V8_MAIN_EN: CG487.1 DG3.2 DG7.2 DG10.1 QG504.2 RG71.2 RG549.1 RG550.1 UG9.BE1 UG12.5 UG26.2
1V_PG: PU100.9 RE149.2
2.5V_PGOOD: PR25V02.2 PU25V00.1
3/5V_B+: PC301.1 PC302.1 PC303.1 PC304.1 PC307.1 PC308.1 PL300.2 PL301.2 PQ301.5 PQ303.5 PU300.12
3V3_SYS_EN: CG240.1 QG505.2 RG515.2 RG545.2 UG14.4
3V_5V_EN: PC316.1 PQ305.1 PR311.2 PR312.2 PR313.2
3V_EN: PR311.1 PU300.6
5V_EN: PR312.1 PU300.20
5VCC: PC6014.1 PR6033.1 PR6037.2 PU6000.12
5VS_FAN1: JFAN1.1 RE104.2
5VS_FAN2: JFAN2.1 RE105.2
+0.6VS: CD12.1 CD13.1 CD14.1 CD15.1 CD32.1 CD88.1 CD89.1 CD90.1 JDIMM1.258 JDIMM2.258 PJP203.2
+0.6VSP: PC207.1 PC208.1 PJP203.1 PU200.2 PU200.20
+0.9V_CIO: CT78.1 CT79.1 CT80.1 UT1.R8 UT1.R9 UT1.R11 UT1.R12
+0.9V_DP: CT54.1 CT57.1 CT58.1 CT59.1 CT60.1 CT61.1 CT62.1 UT1.L6 UT1.L8 UT1.L11 UT1.L12 UT1.M6 UT1.M8 UT1.T11 UT1.T12 UT1.V11 UT1.V12 UT1.V13
+0.9V_LVR_OUT: CT81.1 CT82.1 CT83.1 CT84.1 UT1.F18 UT1.H11 UT1.H18 UT1.J11
+0.9V_PCIE: CT55.1 CT70.1 CT71.1 CT72.1 UT1.L18 UT1.L19 UT1.M13 UT1.M15 UT1.M16 UT1.M18 UT1.N18 UT1.N19
+0.9V_SVR: CT63.1 CT64.1 CT65.1 CT66.1 CT67.1 CT68.1 CT69.1 CT73.1 CT74.1 CT75.1 LT1.2 UT1.E12 UT1.E13 UT1.F11 UT1.F12 UT1.F13 UT1.F15 UT1.J9 UT1.L9 UT1.M9
+0.9V_USB: CT56.1 CT77.1 UT1.R15 UT1.R16
+1.0VS_VGA_PGOOD: PR10V1.2 PU10V0.4 UG27.2
+1.0VS_VGAP: PC10V2.1 PC10V3.1 PC10V4.1 PC10V6.1 PJP10V1.1 PL10V0.2 PR10V2.2
+1.2V_DDR: CD1.1 CD2.1 CD5.1 CD6.1 CD7.1 CD8.1 CD19.1 CD20.1 CD21.1 CD22.1 CD23.1 CD24.1 CD25.1 CD26.1 CD33.1 CD70.1 CD71.1 CD72.1 CD73.1 CD74.1 CD75.1 CD76.1 CD77.1 CD78.1 CD79.1 CD80.1 CD81.1 CD82.1 CD83.1 CD84.1 CD85.1 CD86.1 CD87.1 CH118.1 CH119.1 CH120.1 CH121.1 CH122.1 CH123.1 CH124.1 CH125.1 CH126.1 CH127.1 CH128.1 CH129.1 CH130.1 CH131.1 CH132.1 CH197.1 JDIMM1.12 JDIMM1.33 JDIMM1.54 JDIMM1.75 JDIMM1.96 JDIMM1.111 JDIMM1.112 JDIMM1.117 JDIMM1.118 JDIMM1.123 JDIMM1.124 JDIMM1.129 JDIMM1.130 JDIMM1.135 JDIMM1.136 JDIMM1.141 JDIMM1.142 JDIMM1.147 JDIMM1.148 JDIMM1.153 JDIMM1.154 JDIMM1.159 JDIMM1.160 JDIMM1.163 JDIMM1.178 JDIMM1.199 JDIMM1.220 JDIMM1.241 JDIMM2.12 JDIMM2.33 JDIMM2.54 JDIMM2.75 JDIMM2.96 JDIMM2.111 JDIMM2.112 JDIMM2.117 JDIMM2.118 JDIMM2.123 JDIMM2.124 JDIMM2.129 JDIMM2.130 JDIMM2.135 JDIMM2.136 JDIMM2.141 JDIMM2.142 JDIMM2.147 JDIMM2.148 JDIMM2.153 JDIMM2.154 JDIMM2.159 JDIMM2.160 JDIMM2.163 JDIMM2.178 JDIMM2.199 JDIMM2.220 JDIMM2.241 PJP201.2 PJP202.2 RD35.1 RH107.2 RH206.1 RH207.1 UC1.5 UH1.AA6 UH1.AE12 UH1.AF5 UH1.AF6 UH1.AG5 UH1.AG9 UH1.AJ12 UH1.AL11 UH1.AP6 UH1.AP7 UH1.AR6 UH1.AR12 UH1.AT12 UH1.AW6 UH1.AY6 UH1.J5 UH1.J6 UH1.K6 UH1.K12 UH1.L6 UH1.L12 UH1.R6 UH1.T6 UH1.W6 UH1.Y12 UZ16.1 UZ16.2
+1.2V_RTM: CP3.1 CP4.1 CP5.1 CP6.1 CP7.1 CP8.1 CP9.1 CP10.1 CP11.1 CP12.1 CP13.1 CP14.1 CP28.1 CP29.1 QZ2.3 RP31.2 UP2.6 UP2.11 UP2.15 UP2.18 UP2.30 UP2.43 UP2.46
+1.2V_VCCK: CVGA5.1 CVGA6.2 CVGA7.1 UVGA1.4 UVGA1.25
+1.2V_VCCPLL_OC: CZ49.1 QZ2.1 RH107.1 RP31.1 RZ67.2 UH1.BH13 UH1.G11
+1.2V_VCCPLL_OC_OUT: RZ67.1 UZ16.7 UZ16.8
+1.2VP: PC217.1 PC218.1 PC219.1 PC220.1 PC221.1 PC222.1 PC223.1 PC224.1 PJP201.1 PJP202.1 PL200.1 PR205.2 PU200.5 PU200.19
+1.8V_AVDD: CA1.1 CA2.1 CA63.2 HDA1.40 RA1.2
+1.8V_DVDD: CA3.1 HDA1.36 RA1.1 RA57.2 RA58.1 RE146.1
+1.8V_PRIM: CG288.1 PJP18V2.2 PR6042.2 QA1.1 RE15.1 RG70.1 RH67.2 RH128.2 RH546.2 RH578.2 UG12.1 UG12.2 UH2.BA31
+1.8VA_TBTA_LDO: CT100.1 UT4.K1
+1.8VALW_EC: CE71.1 RE15.2 UE1.54
+1.8VD_TBTA_LDO: CT99.1 UT4.A2
+1.8VS: CA7.1 RA57.1 UA1.5
+1.8VSP: PC18V03.1 PC18V04.1 PC18V05.1 PC18V06.1 PC18V07.1 PJP18V2.1 PL18V00.2 PR18V02.1
+1.35VS_VGA: CG80.1 CG81.1 CG82.1 CG83.1 CG84.1 CG85.1 CG86.1 CG87.1 CG88.1 CG89.1 CG90.1 CG91.1 CG97.1 CG98.1 CG99.1 CG100.1 CG101.1 CG102.1 CG103.1 CG104.1 CG105.1 CG106.1 CG115.1 CG116.1 CG117.1 CG118.1 CG119.1 CG120.1 CG121.1 CG122.1 CG123.1 CG124.1 CG125.1 CG126.1 CG132.1 CG133.1 CG134.1 CG135.1 CG136.1 CG137.1 CG138.1 CG139.1 CG140.1 CG141.1 CG150.1 CG151.1 CG152.1 CG153.1 CG154.1 CG155.1 CG156.1 CG157.1 CG158.1 CG159.1 CG160.1 CG161.1 CG167.1 CG168.1 CG169.1 CG170.1 CG171.1 CG172.1 CG173.1 CG174.1 CG175.1 CG176.1 CG184.1 CG185.1 CG186.1 CG187.1 CG188.1 CG189.1 CG190.1 CG191.1 CG192.1 CG193.1 CG194.1 CG195.1 CG196.1 CG197.1 CG198.1 CG199.1 CG200.1 CG201.1 CG202.1 CG203.1 CG204.1 CG205.1 CG206.1 CG207.1 CG208.1 CG209.1 CG210.1 CG211.1 CG212.1 CG213.1 CG214.1 CG215.1 CG216.1 CG217.1 CG218.1 CG219.1 CG220.1 CG221.1 CG222.1 CG223.1 CG224.1 CG225.1 CG226.1 CG227.1 CG228.1 CG242.1 CG243.1 CG324.1 CG325.1 CG326.1 CG327.1 CG328.1 CG329.1 CG330.1 CG331.1 CG332.1 CG333.1 CG334.1 CG335.1 CG336.1 CG337.1 CG338.1 CG339.1 CG340.1 CG341.1 CG342.1 CG343.1 CG344.1 CG345.1 CG346.1 CG347.1 CG348.1 CG349.1 CG350.1 CG351.1 CG352.1 CG353.1 CG354.1 CG355.1 CG356.1 CG357.1 CG358.1 CG359.1 CG360.1 CG361.1 CG362.1 CG363.1 CG364.1 CG365.1 CG366.1 CG367.1 CG368.1 CG369.1 CG370.1 CG371.1 CG372.1 CG373.1 CG374.1 CG375.1 CG376.1 CG377.1 CG378.1 CG379.1 CG380.1 CG381.1 CG382.1 CG383.1 CG388.1 CG389.1 CG390.1 CG391.1 CG392.1 CG393.1 CG394.1 CG395.1 CG396.1 CG397.1 CG398.1 CG399.1 CG400.1 CG401.1 CG402.1 CG403.1 CG404.1 CG405.1 CG406.1 CG407.1 CG408.1 CG409.1 CG410.1 CG411.1 CG412.1 CG413.1 CG414.1 CG415.1 CG416.1 CG417.1 CG418.1 CG419.1 CG420.1 CG421.1 CG422.1 CG423.1 CG424.1 CG425.1 CG426.1 CG427.1 CG428.1 CG429.1 CG430.1 CG431.1 CG432.1 CG433.1 CG434.1 CG435.1 CG528.1 PJP801.2 PJP802.2 RG47.1 RG48.1 RG49.1 RG50.1 RG51.1 RG52.1 RG67.2 RG104.2 RG110.1 RG115.2 RG121.1 RG126.2 RG132.1 RG582.1 UG1.B1 UG1.B3 UG1.B12 UG1.B14 UG1.C5 UG1.C10 UG1.D1 UG1.D3 UG1.D11 UG1.D12 UG1.D14 UG1.E5 UG1.E10 UG1.F1 UG1.F3 UG1.F12 UG1.F14 UG1.G1 UG1.G2 UG1.G4 UG1.G11 UG1.G13 UG1.G14 UG1.H3 UG1.H12 UG1.K3 UG1.K12 UG1.L1 UG1.L2 UG1.L4 UG1.L11 UG1.L13 UG1.L14 UG1.M1 UG1.M3 UG1.M12 UG1.M14 UG1.N5 UG1.N10 UG1.P1 UG1.P3 UG1.P11 UG1.P12 UG1.P14 UG1.R5 UG1.R10 UG1.T1 UG1.T3 UG1.T12 UG1.T14 UG2.B1 UG2.B3 UG2.B12 UG2.B14 UG2.C5 UG2.C10 UG2.D1 UG2.D3 UG2.D11 UG2.D12 UG2.D14 UG2.E5 UG2.E10 UG2.F1 UG2.F3 UG2.F12 UG2.F14 UG2.G1 UG2.G2 UG2.G4 UG2.G11 UG2.G13 UG2.G14 UG2.H3 UG2.H12 UG2.K3 UG2.K12 UG2.L1 UG2.L2 UG2.L4 UG2.L11 UG2.L13 UG2.L14 UG2.M1 UG2.M3 UG2.M12 UG2.M14 UG2.N5 UG2.N10 UG2.P1 UG2.P3 UG2.P11 UG2.P12 UG2.P14 UG2.R5 UG2.R10 UG2.T1 UG2.T3 UG2.T12 UG2.T14 UG3.B1 UG3.B3 UG3.B12 UG3.B14 UG3.C5 UG3.C10 UG3.D1 UG3.D3 UG3.D11 UG3.D12 UG3.D14 UG3.E5 UG3.E10 UG3.F1 UG3.F3 UG3.F12 UG3.F14 UG3.G1 UG3.G2 UG3.G4 UG3.G11 UG3.G13 UG3.G14 UG3.H3 UG3.H12 UG3.K3 UG3.K12 UG3.L1 UG3.L2 UG3.L4 UG3.L11 UG3.L13 UG3.L14 UG3.M1 UG3.M3 UG3.M12 UG3.M14 UG3.N5 UG3.N10 UG3.P1 UG3.P3 UG3.P11 UG3.P12 UG3.P14 UG3.R5 UG3.R10 UG3.T1 UG3.T3 UG3.T12 UG3.T14 UG4.B1 UG4.B3 UG4.B12 UG4.B14 UG4.C5 UG4.C10 UG4.D1 UG4.D3 UG4.D11 UG4.D12 UG4.D14 UG4.E5 UG4.E10 UG4.F1 UG4.F3 UG4.F12 UG4.F14 UG4.G1 UG4.G2 UG4.G4 UG4.G11 UG4.G13 UG4.G14 UG4.H3 UG4.H12 UG4.K3 UG4.K12 UG4.L1 UG4.L2 UG4.L4 UG4.L11 UG4.L13 UG4.L14 UG4.M1 UG4.M3 UG4.M12 UG4.M14 UG4.N5 UG4.N10 UG4.P1 UG4.P3 UG4.P11 UG4.P12 UG4.P14 UG4.R5 UG4.R10 UG4.T1 UG4.T3 UG4.T12 UG4.T14 UG5.B1 UG5.B3 UG5.B12 UG5.B14 UG5.C5 UG5.C10 UG5.D1 UG5.D3 UG5.D11 UG5.D12 UG5.D14 UG5.E5 UG5.E10 UG5.F1 UG5.F3 UG5.F12 UG5.F14 UG5.G1 UG5.G2 UG5.G4 UG5.G11 UG5.G13 UG5.G14 UG5.H3 UG5.H12 UG5.K3 UG5.K12 UG5.L1 UG5.L2 UG5.L4 UG5.L11 UG5.L13 UG5.L14 UG5.M1 UG5.M3 UG5.M12 UG5.M14 UG5.N5 UG5.N10 UG5.P1 UG5.P3 UG5.P11 UG5.P12 UG5.P14 UG5.R5 UG5.R10 UG5.T1 UG5.T3 UG5.T12 UG5.T14 UG6.B1 UG6.B3 UG6.B12 UG6.B14 UG6.C5 UG6.C10 UG6.D1 UG6.D3 UG6.D11 UG6.D12 UG6.D14 UG6.E5 UG6.E10 UG6.F1 UG6.F3 UG6.F12 UG6.F14 UG6.G1 UG6.G2 UG6.G4 UG6.G11 UG6.G13 UG6.G14 UG6.H3 UG6.H12 UG6.K3 UG6.K12 UG6.L1 UG6.L2 UG6.L4 UG6.L11 UG6.L13 UG6.L14 UG6.M1 UG6.M3 UG6.M12 UG6.M14 UG6.N5 UG6.N10 UG6.P1 UG6.P3 UG6.P11 UG6.P12 UG6.P14 UG6.R5 UG6.R10 UG6.T1 UG6.T3 UG6.T12 UG6.T14 UG9.AA10 UG9.AA11 UG9.AA42 UG9.AA43 UG9.AC10 UG9.AC11 UG9.AC42 UG9.AC43 UG9.AD10 UG9.AD11 UG9.AD42 UG9.AD43 UG9.AF10 UG9.AF43 UG9.AG10 UG9.AG11 UG9.AG42 UG9.AG43 UG9.AJ10 UG9.AJ11 UG9.AJ42 UG9.AJ43 UG9.AK10 UG9.AK11 UG9.AK42 UG9.AK43 UG9.AM42 UG9.AM43 UG9.AN43 UG9.AR42 UG9.AR43 UG9.AT43 UG9.K12 UG9.K14 UG9.K15 UG9.K17 UG9.K18 UG9.K20 UG9.K21 UG9.K23 UG9.K24 UG9.K26 UG9.K27 UG9.K29 UG9.K30 UG9.K32 UG9.K33 UG9.K35 UG9.K36 UG9.K38 UG9.K39 UG9.K41 UG9.L14 UG9.L15 UG9.L18 UG9.L20 UG9.L21 UG9.L23 UG9.L24 UG9.L26 UG9.L27 UG9.L30 UG9.L32 UG9.L33 UG9.L35 UG9.L36 UG9.L39 UG9.M10 UG9.M43 UG9.P10 UG9.P11 UG9.P42 UG9.P43 UG9.R10 UG9.R11 UG9.R42 UG9.R43 UG9.U10 UG9.U11 UG9.U43 UG9.V10 UG9.V42 UG9.V43 UG9.Y10 UG9.Y11 UG9.Y42 UG9.Y43
+1.35VS_VGAP: PC810.1 PC811.1 PJP801.1 PJP802.1 PL801.2 PR813.1
+1.35VS_VGAP_B+: PC801.1 PC802.1 PC803.1 PC804.1 PC805.1 PL800.1 PQ800.2 PQ801.2
+1V8_AON: CG66.1 CG246.1 CG289.1 CG291.1 CG292.1 CG293.1 CG294.1 CG320.1 CG439.1 CG440.1 CG483.1 CG526.1 CG527.1 PR10V6.1 PR811.2 QG8.2 QG8.5 QG511.2 RG16.2 RG17.2 RG18.2 RG19.2 RG20.2 RG21.2 RG71.1 RG74.1 RG78.2 RG79.2 RG80.2 RG81.2 RG82.2 RG83.2 RG84.2 RG85.2 RG86.2 RG156.1 RG159.1 RG161.1 RG162.2 RG163.2 RG164.2 RG166.2 RG167.1 RG168.2 RG502.2 RG504.2 RG510.1 RG516.1 RG522.2 RG571.1 RG572.2 RG579.2 UG9.BA10 UG9.BB14 UG9.BC14 UG10.5 UG12.6 UG12.7 UG12.13 UG12.14 UG13.3 UG13.7 UG13.8 UG22.5 UG26.5 UG27.5 UG29.5 UG30.5 UG31.5
+1V8_MAIN: CG290.1 CG295.1 CG296.1 CG297.1 CG298.1 CG299.1 CG300.1 CG301.1 CG302.1 CG303.1 CG304.1 CG305.1 CG306.1 CG307.1 CG505.1 CG507.1 CG508.1 CG512.1 CG514.2 CG515.2 CG517.1 CG520.1 CG522.1 LG4.1 LG5.1 LG6.2 LG7.2 LG8.1 LG9.2 RG512.1 RG515.1 RG546.1 UG9.AM10 UG9.AM11 UG9.AN10 UG9.AN11 UG9.AR10 UG9.AR11 UG9.AT10 UG9.AT11 UG9.AV10 UG9.AV11 UG9.AW10 UG9.AW11 UG9.BB26 UG9.BB27 UG9.BB29 UG9.BB32 UG9.BC26 UG9.BC27 UG9.BC29 UG9.BC30 UG9.BC32 UG9.BD27 UG9.BD30 UG12.8 UG12.9
+1V_APLLEBB: CH214.1 RH544.2 UH2.V28
+1V_B+: PC101.1 PC102.1 PC103.1 PC104.1 PJP11.2 PU100.2 PU100.3 PU100.4 PU100.5
+1V_MPHY: CH183.1 CH184.1 CH185.1 RH544.1 RZ70.2 UH2.U21 UH2.U23 UH2.U25 UH2.U26 UH2.V26
+1V_MPHY_MPHYPLL: CH180.1 CH181.1 CH182.1 RH124.2 UH2.A43 UH2.B43 UH2.C44 UH2.C45
+1V_PCH: CH205.1 JXDP1.43 JXDP1.44 PJP1302.2 RH520.1 UH2.AC17 UH2.AD15 UH2.AL22 UH2.N17 UH2.R17 UH2.R19 UH2.U20 UH2.V17
+1V_PCH_AZPLL: CH203.1 LH2.2 UH2.AN19
+1V_PCH_CLK5: CH177.1 CH178.1 CH179.1 RH122.2 UH2.K2 UH2.K3
+1V_PCH_PRIM: PJP1303.2 RH196.1 UH2.AA23 UH2.AA26 UH2.AA28 UH2.AC23 UH2.AC26 UH2.AC28 UH2.AE23 UH2.AE26 UH2.AJ20 UH2.AJ21 UH2.AJ23 UH2.AJ25 UH2.Y23 UH2.Y25
+1V_PCH_USBPLL: CH201.1 CH202.1 RH123.2 UH2.AJ5 UH2.AL5
+1V_VCCDSW: CH176.1 RH196.2 UH2.BA29
+1VALW: CZ88.1 CZ96.1 LH2.1 PJP12.2 PJP1302.1 PJP1303.1 RE116.1 RH71.1 RH122.1 RH123.1 RH124.1 RZ70.1 UZ9.1 UZ9.2 UZ9.7 UZ15.1 UZ15.2 UZ15.7
+1VALWP: PC109.1 PC110.1 PC112.1 PC113.1 PC114.1 PJP12.1 PL100.2 PR106.1
+2.5V_MEM: CD3.1 CD4.1 CD9.1 CD10.1 CD27.1 CD28.1 CD30.1 CD31.1 JDIMM1.257 JDIMM1.259 JDIMM2.257 JDIMM2.259 PJP25V2.2
+2.5V_MEMP: PC25V03.1 PC25V04.1 PC25V05.1 PJP25V2.1 PR25V03.1 PU25V00.6
+3.3V_ANA_PCIE: CT85.1 UT1.L16
+3.3V_ANA_USB2: CT86.1 UT1.J16
+3.3V_FLASH: CT45.1 CT103.1 CT117.1 RT48.1 RT49.2 RT50.2 RT51.1 RT66.1 RT67.1 RT74.1 RT112.1 RT125.2 RT126.2 RT127.2 RT128.2 UT2.8 UT4.G1 UT5.8
+3.3V_LC: CT46.1 RT6.1 RT7.1 RT8.1 RT9.1 UT1.R6
+3.3V_TBT_S0: CT48.1 CT115.1 CT116.1 LT4.1 UT1.R13
+3.3V_TBT_SX: CT47.1 RT26.1 RT27.1 RT28.1 RT29.1 RT30.1 RT31.1 RT32.1 RT33.1 RT61.2 RT70.1 RT80.1 RT86.1 RT94.1 RT97.2 UT1.F8
+3.3V_TBT_SX_R: CT102.1 RT61.1 UT4.H2
+3.3VDX_SSD: CD36.1 CD38.1 CD39.1 CD40.1 CD41.1 JNGFF2.2 JNGFF2.4 JNGFF2.12 JNGFF2.14 JNGFF2.16 JNGFF2.18 JNGFF2.62 JNGFF2.64 JNGFF2.66 RD7.1 RD8.2 RZ36.2
+3V3_SYS: CG61.1 CG323.1 CG385.1 PR10V1.1 RG60.1 RG61.1 RG514.1 UG11.4 UG14.6
+3V_DVDD: CA8.1 CA9.1 CA25.1 CA26.1 CA28.1 HDA1.1 HDA1.9 RA5.2 RA23.1 RA24.1
+3V_FPSW: C5235.1 D5223.2 JPW.2 JPW.3 RW4.2
+3V_HDA: CH213.1 RH543.2 UH2.BA15
+3V_PCH_AZIO: CH200.1 LH1.2 RH543.1
+3V_PCH_DSW: CH82.1 RH17.2 RH81.2 RH125.2 RH137.2 RH181.2 RH529.1 UH2.BA24 UH2.W15
+3V_PCH_SPI: RH493.2 UH2.BE41 UH2.BE42 UH2.BE43
+3V_ROM: RH74.1 RH121.1 RH540.1 UH8.8
+3V_RTM: CP24.1 CP25.1 CP26.1 RP24.2 RP25.2 RP28.1 RP33.1 RP34.1 RP35.1 RP36.1 RP37.1 RP38.1 RP48.2 RP49.2 UP2.1 UP2.24
+3V_TPM: CTPM5.1 CTPM6.1 CTPM7.1 QTPM1.3 RTPM10.1 RTPM13.2 RTPM15.1 UTPM1.14 UTPM1.22
+3V_USBRD: CI3.1 CI4.1 RI12.1 RI15.2 RI16.2 RI17.2 RI18.2 RI19.2 RI20.2 RI21.2 RI22.2 RI24.2 RI59.2 RI67.2 UI3.1 UI3.13
+3VALW: CC298.1 CE18.1 CH186.1 CH187.1 CH189.1 CH190.1 CH191.1 CH192.1 CL39.1 CZ12.1 LH1.1 PC18V11.1 PC108.1 PC4014.1 PJP25V1.1 PJP33.2 PJP34.2 PR2.2 PR13.2 PR18V06.2 PR25V02.1 PR32.1 PR108.1 PR206.1 PR713.1 PR714.2 PR722.2 PR4008.2 PR6034.1 PU18V00.15 PU100.15 PU4000.15 RA17.2 RE12.1 RE25.1 RE29.2 RE30.2 RE34.1 RE38.1 RE39.2 RE113.2 RE150.2 RH21.1 RH22.1 RH62.1 RH63.1 RH64.1 RH65.1 RH66.1 RH68.2 RH82.1 RH91.1 RH92.1 RH121.2 RH130.1 RH137.1 RH193.2 RH493.1 RH521.1 RH568.1 RI9.1 RI10.1 RI30.1 RI67.1 RL41.2 RN2.1 RP8.5 RP8.6 RP8.7 RP8.8 RP16.5 RP16.6 RP16.7 RP16.8 RPE2.5 RPE2.6 RPE2.7 RPE2.8 RPE3.5 RPE3.6 RPE3.7 RPE3.8 RPE4.1 RPE4.2 RPE4.3 RPE4.4 RPE5.1 RPE5.2 RPE5.3 RPE5.4 RPE6.1 RPE6.2 RPE6.3 RPE6.4 RPE7.1 RPE7.2 RPE7.3 RPE7.4 RT53.1 RT95.1 RT97.1 RTH1.1 RTPM1.2 RTPM10.2 RZ32.2 RZ33.1 RZ96.1 UC16.5 UE3.2 UE4.5 UH2.AD41 UH2.AJ41 UH2.AL41 UH2.AN5 UH2.BA20 UH2.BA45 UH2.BB45 UH2.BC42 UH2.BC44 UH2.BC45 UH2.BD3 UH2.BD40 UH2.BE3 UH2.BE4 UL2.5 UZ1.6 UZ1.7 UZ8.5 UZ21.5
+3VALW_EC: CE62.1 CE63.2 CE64.2 CE65.1 CE66.1 CE67.1 CE68.1 CE69.1 CE79.1 CE81.1 CE89.1 RE12.2 RE13.1 RE43.2 RE44.2 RE45.2 RE46.2 RE53.2 RE60.2 RE63.1 RE64.1 RE65.1 RE118.1 RE119.2 RE125.1 RE130.1 RE139.2 RE140.2 RE141.2 UE1.5 UE1.19 UE1.22 UE1.43 UE1.65 UE1.82 UE1.103 UE1.115
+3VALW_PD: CT88.1 CT101.1 RT53.2 UT4.B1 UT4.H1
+3VALWP: PC311.1 PJP33.1 PJP34.1 PL302.1 PR300.1 PR314.2
+3VLP: PC300.1 PJP1304.1 PU300.3 RE20.2
+3VS: CA4.1 CD16.1 CD17.1 CD34.1 CD35.1 CE85.1 CG322.1 CG438.1 CH188.1 CN19.1 CN22.1 CTH1.1 CTPM3.1 CTPM4.1 CVGA8.1 JDIMM1.255 JDIMM2.255 JDIMM2.260 JPZ2.2 PR800.1 PR4001.1 PR5015.1 PR6040.1 PR6061.1 Q12.2 Q13.2 QA1.2 QE3.2 QE19.2 QE19.5 QH4.2 QH4.5 QP1.1 QTH3.2 QTH3.5 RA2.1 RA5.1 RE81.1 RE83.1 RE120.2 RE121.1 RE122.1 RE143.2 RG505.1 RG506.1 RH10.1 RH26.1 RH27.1 RH69.2 RH79.2 RH80.2 RH86.1 RH93.1 RH119.1 RH120.1 RH129.2 RH141.2 RH159.1 RH160.1 RH179.2 RH180.1 RH531.1 RH545.1 RH547.1 RH549.1 RH551.1 RH553.1 RH557.1 RH559.1 RH561.1 RH573.2 RH579.2 RH580.2 RI52.1 RI59.1 RL33.1 RM22.1 RP3.1 RP3.2 RP3.3 RP3.4 RP28.2 RPT1.5 RPT1.6 RPT1.7 RPT1.8 RS39.1 RS40.1 RS41.1 RT57.1 RT58.1 RT124.1 RTH2.1 RTH3.1 RTH4.1 RTPM14.2 RTPM15.2 RVGA1.1 RVGA2.1 RVGA3.2 RVGA16.2 RW4.1 RZ36.1 RZ37.1 U5603.2 U5603.3 U5603.9 U5603.10 UA1.1 UE6.5 UG14.1 UG14.2 UG14.7 UG25.5 UH2.AD13 UH7.5 UH14.5 UTH1.1 UTPM1.8 UVGA1.14 UVGA1.26
+3VS_CAM: CV582.1 CV583.1 CV584.1 CZ44.1 JCAM1.6 RZ37.2
+3VS_CR: CR9.1 CR10.1 RI52.2 UR1.5 UR1.6 UR1.8
+3VS_OUT: CZ9.1 JPZ2.1 UZ1.8 UZ1.9
+3VS_TBT: CT49.1 CT50.1 CT51.1 CT52.1 CT53.1 LT4.2 RT20.1 RT21.1 RT76.2 RT77.2 RT95.2 RT124.2 UT1.A2 UT1.A3 UT1.B3 UT1.H9
+3VS_TP: CE2.1 DE4.5 JTP.8 QE13.2 RE7.2 RE9.2 RE24.1 RE55.1 RE87.1 RE93.2 RE123.1
+3VS_TP_OUT: RE93.1 UE4.1
+3VS_WLAN: CN1.1 CN2.1 CN6.1 CN7.1 CN9.1 JNGFF1.2 JNGFF1.4 JNGFF1.64 JNGFF1.66 RM22.2 RN2.2
+5V_AVDD: CA17.1 CA18.1 HDA1.26 RA8.1
+5V_CHGUSB_1: CI11.1 CI12.1 CI13.1 CI17.1 CI18.1 CI19.1 CI30.1 CI31.1 JUSB1.1 JUSB2.1 RE115.2
+5V_CHGUSB_1_OUT: RE115.1 US2.1
+5V_CHGUSB_3: CI21.1 CI25.1 CI26.1 CI27.1 JUSB3.1 US1.12
+5V_PVDD: CA11.1 CA12.1 CA13.1 CA14.1 HDA1.41 HDA1.46 RA7.2 RA10.2
+5VALW: CG384.1 CI23.1 CI24.1 CT90.1 CT91.1 CT92.1 CT93.1 CZ11.1 CZ86.1 CZ97.1 JLED.4 JPW.1 PC25V06.1 PC809.1 PJP10V0.1 PJP31.2 PJP32.2 PR4.1 PR203.1 PR204.1 PU25V00.4 PU800.7 RG509.1 RG511.1 RG513.1 RG543.1 RG583.1 RH504.1 RH505.1 RH506.1 RW3.2 UG14.3 US1.1 US2.5 UT4.A11 UT4.B11 UT4.C11 UT4.D11 UT4.H10 UZ1.1 UZ1.2 UZ1.4 UZ9.3 UZ15.3 UZ16.4
+5VALWP: PC312.1 PJP31.1 PJP32.1 PL303.2 PR301.2 PU300.14
+5VS: CE5.1 CG386.1 CVGA14.1 CVGA15.1 DVGA1.2 F1.2 JPZ1.2 PC6100.1 PC6114.1 PC6128.1 PR5004.1 PR5100.2 PR5101.1 PR5103.2 PR5113.1 PR5115.2 PR5116.2 PR5125.1 PR5127.2 PR5128.2 PR5200.2 PR5201.1 PR5203.2 PR5212.1 PR5214.2 PR5216.2 PR5229.2 PR5230.1 PR6037.1 PR6044.2 PR6046.2 PR6047.2 PR6048.2 PR6050.2 PR6102.2 PR6103.2 PR6104.2 PR6106.1 PR6109.2 PR6110.2 PR6112.2 PR6113.1 PR6116.2 PR6117.2 PR6118.2 PR6120.1 PU6100.3 PU6101.3 PU6102.3 QE4.3 RA7.1 RA8.2 RA10.1 RE1.2 RE82.1 RE84.1 RE100.1 RE101.1 RE104.1 RE105.1 RZ26.1 RZ34.1 UG12.4 UV17.1 UVGA1.17
+5VS_HDD: CS12.1 CS13.1 CS14.1 CS15.1 JHDD1.10 JHDD1.11 JHDD1.12 RS1.1 RZ34.2
+5VS_KBL: CE4.1 CE6.1 F1.1 JBL1.1
+5VS_OUT: CZ8.1 JPZ1.1 UZ1.13 UZ1.14
+5VS_TS: JEDP1.19 RZ26.2
+VCC_3IN1: CR5.1 CR6.1 JREAD1.4 UR1.7
+VCC_CORE: PC5500.1 PC5501.1 PC5502.1 PC5503.1 PC5504.1 PC5505.1 PC5506.1 PC5507.1 PC5508.1 PC5509.1 PC5510.1 PC5511.1 PC5512.1 PC5513.1 PC5514.1 PC5515.1 PC5516.1 PC5517.1 PC5518.1 PC5519.1 PC5520.1 PC5521.1 PC5522.1 PC5523.1 PC5524.1 PC5525.1 PC5526.1 PC5527.1 PC5528.1 PC5529.1 PC5530.1 PC5531.1 PC5532.1 PC5533.1 PC5534.1 PC5535.1 PC5536.1 PC5537.1 PC5538.1 PL5101.1 PL5102.1 PL5103.1 PR5109.2 PR5111.1 PR5112.1 PR5122.2 PR5123.1 PR5124.1 PR5134.2 PR5135.1 PR5136.1 RH197.1 UH1.AA13 UH1.AA31 UH1.AA32 UH1.AA33 UH1.AA34 UH1.AA35 UH1.AA36 UH1.AA37 UH1.AA38 UH1.AB29 UH1.AB30 UH1.AB31 UH1.AB32 UH1.AB35 UH1.AB36 UH1.AB37 UH1.AB38 UH1.AC13 UH1.AC14 UH1.AC29 UH1.AC30 UH1.AC31 UH1.AC32 UH1.AC33 UH1.AC34 UH1.AC35 UH1.AC36 UH1.AD13 UH1.AD14 UH1.AD31 UH1.AD32 UH1.AD33 UH1.AD34 UH1.AD35 UH1.AD36 UH1.AD37 UH1.AD38 UH1.AE13 UH1.AE14 UH1.AE30 UH1.AE31 UH1.AE32 UH1.AE35 UH1.AE36 UH1.AE37 UH1.AE38 UH1.AF35 UH1.AF36 UH1.AF37 UH1.AF38 UH1.K13 UH1.K14 UH1.L13 UH1.L14 UH1.N13 UH1.N14 UH1.N30 UH1.N31 UH1.N32 UH1.N35 UH1.N36 UH1.N37 UH1.N38 UH1.P13 UH1.P14 UH1.P29 UH1.P30 UH1.P31 UH1.P32 UH1.P33 UH1.P34 UH1.P35 UH1.P36 UH1.R13 UH1.R31 UH1.R32 UH1.R33 UH1.R34 UH1.R35 UH1.R36 UH1.R37 UH1.R38 UH1.T29 UH1.T30 UH1.T31 UH1.T32 UH1.T35 UH1.T36 UH1.T37 UH1.T38 UH1.U29 UH1.U30 UH1.U31 UH1.U32 UH1.U33 UH1.U34 UH1.U35 UH1.U36 UH1.V13 UH1.V14 UH1.V31 UH1.V32 UH1.V33 UH1.V34 UH1.V35 UH1.V36 UH1.V37 UH1.V38 UH1.W13 UH1.W14 UH1.W29 UH1.W30 UH1.W31 UH1.W32 UH1.W35 UH1.W36 UH1.W37 UH1.W38 UH1.Y29 UH1.Y30 UH1.Y31 UH1.Y32 UH1.Y33 UH1.Y34 UH1.Y35 UH1.Y36
+VCCGT: PC5539.1 PC5540.1 PC5541.1 PC5542.1 PC5543.1 PC5544.1 PC5545.1 PC5546.1 PC5547.1 PC5548.1 PC5549.1 PC5553.1 PC5554.1 PC5555.1 PC5556.1 PC5557.1 PC5558.1 PC5559.1 PC5560.1 PC5561.1 PC5562.1 PC5563.1 PC5564.1 PC5565.1 PC5570.1 PC5571.1 PC5572.1 PC5573.1 PC5574.1 PC5575.1 PC5576.1 PC5577.1 PC5578.1 PC5579.1 PC5580.1 PC5584.1 PC5587.1 PC5590.1 PC5591.1 PC5592.1 PC5593.1 PC5594.1 PC5595.1 PC5596.1 PC5597.1 PC5598.1 PC5599.1 PC5600.1 PC5601.1 PC5602.1 PC5603.1 PC5604.1 PC5605.1 PC5606.1 PC5607.1 PC5608.1 PC5609.1 PC5610.1 PL5201.1 PL5202.1 PR5209.2 PR5211.1 PR5221.2 PR5222.1 RH203.1 UH1.AJ29 UH1.AJ30 UH1.AJ31 UH1.AJ32 UH1.AJ33 UH1.AJ34 UH1.AJ35 UH1.AJ36 UH1.AK31 UH1.AK32 UH1.AK33 UH1.AK34 UH1.AK35 UH1.AK36 UH1.AK37 UH1.AK38 UH1.AL13 UH1.AL29 UH1.AL30 UH1.AL31 UH1.AL32 UH1.AL35 UH1.AL36 UH1.AL37 UH1.AL38 UH1.AM13 UH1.AM14 UH1.AM29 UH1.AM30 UH1.AM31 UH1.AM32 UH1.AM33 UH1.AM34 UH1.AM35 UH1.AM36 UH1.AN13 UH1.AN14 UH1.AN31 UH1.AN32 UH1.AN33 UH1.AN34 UH1.AN35 UH1.AN36 UH1.AN37 UH1.AN38 UH1.AP13 UH1.AP14 UH1.AP29 UH1.AP30 UH1.AP31 UH1.AP32 UH1.AP35 UH1.AP36 UH1.AP37 UH1.AP38 UH1.AR29 UH1.AR30 UH1.AR31 UH1.AR32 UH1.AR33 UH1.AR34 UH1.AR35 UH1.AR36 UH1.AT14 UH1.AT31 UH1.AT32 UH1.AT33 UH1.AT34 UH1.AT35 UH1.AT36 UH1.AT37 UH1.AT38 UH1.AU14 UH1.AU29 UH1.AU30 UH1.AU31 UH1.AU32 UH1.AU35 UH1.AU36 UH1.AU37 UH1.AU38 UH1.AV29 UH1.AV30 UH1.AV31 UH1.AV32 UH1.AV33 UH1.AV34 UH1.AV35 UH1.AV36 UH1.AW14 UH1.AW31 UH1.AW32 UH1.AW33 UH1.AW34 UH1.AW35 UH1.AW36 UH1.AW37 UH1.AW38 UH1.AY29 UH1.AY30 UH1.AY31 UH1.AY32 UH1.AY35 UH1.AY36 UH1.AY37 UH1.AY38 UH1.BA13 UH1.BA14 UH1.BA29 UH1.BA30 UH1.BA31 UH1.BA32 UH1.BA33 UH1.BA34 UH1.BA35 UH1.BA36 UH1.BB13 UH1.BB14 UH1.BB31 UH1.BB32 UH1.BB33 UH1.BB34 UH1.BB35 UH1.BB36 UH1.BB37 UH1.BB38 UH1.BC29 UH1.BC30 UH1.BC31 UH1.BC32 UH1.BC35 UH1.BC36 UH1.BC37 UH1.BC38 UH1.BD13 UH1.BD14 UH1.BD29 UH1.BD30 UH1.BD31 UH1.BD32 UH1.BD33 UH1.BD34 UH1.BD35 UH1.BD36 UH1.BE31 UH1.BE32 UH1.BE33 UH1.BE34 UH1.BE35 UH1.BE36 UH1.BE37 UH1.BE38 UH1.BF13 UH1.BF14 UH1.BF29 UH1.BF30 UH1.BF31 UH1.BF32 UH1.BF35 UH1.BF36 UH1.BF37 UH1.BF38 UH1.BG29 UH1.BG30 UH1.BG31 UH1.BG32 UH1.BG33 UH1.BG34 UH1.BG35 UH1.BG36 UH1.BH33 UH1.BH34 UH1.BH35 UH1.BH36 UH1.BH37 UH1.BH38 UH1.BJ37 UH1.BJ38 UH1.BL36 UH1.BL37 UH1.BM36 UH1.BM37 UH1.BN36 UH1.BN37 UH1.BN38 UH1.BP37 UH1.BP38 UH1.BR37 UH1.BT37
+VCCIO: CH102.1 CH103.1 CH104.1 PJP4001.2 RH24.1 RH30.2 RH515.2 RH526.1 UH1.AG12 UH1.G15 UH1.G17 UH1.G19 UH1.G21 UH1.H15 UH1.H16 UH1.H17 UH1.H19 UH1.H20 UH1.H21 UH1.H26 UH1.H27 UH1.J15 UH1.J16 UH1.J17 UH1.J19 UH1.J20 UH1.J21 UH1.J26 UH1.J27
+VCCIO_PG: PR4001.2 PU4000.9 RH103.1
+VCCIOP: PC4006.1 PC4007.1 PC4008.1 PC4009.1 PC4010.1 PJP4001.1 PL4000.2 PR4004.1
+VCCSA: CH111.1 CH112.1 CH113.1 CH114.1 CH115.1 CH116.1 CH117.1 CH133.1 CH134.1 CH135.1 CH136.1 PC5550.1 PC5551.1 PC5552.1 PC5566.1 PC5567.1 PC5568.1 PC5569.1 PC5581.1 PC5582.1 PC5583.1 PC5585.1 PC5586.1 PC5588.1 PC5589.1 PL5203.4 RH201.2 UH1.J30 UH1.K29 UH1.K30 UH1.K31 UH1.K32 UH1.K33 UH1.K34 UH1.K35 UH1.L31 UH1.L32 UH1.L35 UH1.L36 UH1.L37 UH1.L38 UH1.M29 UH1.M30 UH1.M31 UH1.M32 UH1.M33 UH1.M34 UH1.M35 UH1.M36
+VCCST: CH110.1 CH204.1 PC5001.1 PR5001.1 PR5002.1 PR5003.1 RH97.1 RH98.1 RH100.1 RH144.1 RH151.1 RH152.1 RH156.1 RH163.1 RH164.1 RZ66.2 UH1.H28 UH1.H30 UH1.J28
+VCCST_OUT: CZ28.1 RZ66.1 UZ15.6
+VCCSTG: CH106.1 CZ47.1 RH56.1 RH165.1 RH496.1 RH497.1 RZ48.1 UH1.G30 UH1.H29
+VCCSTG_OUT: RZ48.2 UZ9.6
AVCC33: CVGA1.2 RVGA1.2 RVGA6.2 UVGA1.1
