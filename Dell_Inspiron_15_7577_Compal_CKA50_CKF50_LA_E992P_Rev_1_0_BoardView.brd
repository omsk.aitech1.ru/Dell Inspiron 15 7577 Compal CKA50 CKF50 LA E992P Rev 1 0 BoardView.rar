# Allegro board Dell_Inspiron_15_7577_Compal_CKA50_CKF50_LA_E992P_Rev_1_0_BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FBC_CLK1: length 36
  TOP w0.089: 256.73,92.23 v2(256.79,92.28)
  TOP w0.137: RG125.1 256.47,91.97 256.73,92.23
  IN1 w0.089: v2(255.89,94.74) 255.79,94.74 255.72,94.81 255.72,94.9 255.9,95.08 256.2,95.08 256.33,94.95 256.33,94.39 256.96,93.76 256.96,92.46 v2(256.79,92.28)
  IN1 w0.119: v2(230.55,93.96) 230.39,93.96 230.14,93.7 230.14,93.36 230.26,93.24 231.56,93.24 231.84,93.51 236,93.51 236.51,93.01 247.47,93.01 248.85,91.62 257.15,91.62 257.32,91.8 257.32,91.99 257.04,92.28 v2(256.79,92.28)
  BOTTOM w0.089: UG6.J12 256.3,95.15 v2(255.89,94.74)
  BOTTOM w0.119: UG9.H21 230.68,93.65 230.55,93.78 v2(230.55,93.96)
FBC_CLK1#: length 37.1
  TOP w0.089: 257.41,92.23 v2(257.53,92.35)
  TOP w0.137: 257.41,92.23 256.19,91.02 RG528.1
  IN1 w0.089: v2(256,95.55) 256,95.34 256.08,95.25 256.28,95.25 256.5,95.03 256.5,94.47 257.15,93.82 257.15,92.74 v2(257.53,92.35)
  IN1 w0.119: v2(229.85,93.95) 229.93,93.87 229.93,93.23 230.13,93.03 231.64,93.03 231.92,93.31 235.91,93.31 236.42,92.8 247.38,92.8 248.77,91.41 257.23,91.41 257.53,91.71 v2(257.53,92.35)
  BOTTOM w0.089: UG6.J11 v2(256,95.55)
  BOTTOM w0.119: UG9.J21 v2(229.85,93.95)
FBC_CMD0: length 35.3
  BOTTOM w0.142: UG9.C11 234.7,86.3 235.2,86.3 235.47,86.03 237.65,86.03 238.2,85.47 238.2,84.41 ; 257.46,73.75 257.6,73.89 257.6,73.96 257.63,73.98 257.63,74.3 257.6,74.33 257.6,75.91 UG5.G3
  BOTTOM w0.173: 257.46,73.75 256.54,72.83 254.18,72.83 253.42,72.06 247.16,72.06 v1(245.82,73.4) 238.77,80.44 238.77,83.84 238.2,84.41
FBC_CMD1: length 35.7
  TOP w0.089: RG51.2 256.26,77.06 256.4,76.92 UG5.J3 v2(256.8,75.91)
  BOTTOM w0.089: UG5.J3 256.4,76.31
  BOTTOM w0.142: 256.8,73.83 v2(256.8,75.91) 256.4,76.31 ; UG9.B11 235.2,86.65 235.55,86.3 237.77,86.3 238.5,85.58 238.5,84.86
  BOTTOM w0.173: 238.5,84.86 239.39,83.97 239.39,80.66 v1(244.17,75.89) 247.38,72.67 253.3,72.67 253.85,73.22 254.27,73.22 254.32,73.18 256.14,73.18 256.8,73.83
FBC_CMD2: length 34.7
  TOP w0.178: RG58.1 255.89,79.34 255.57,79.02 255.57,75.54 v2(256,75.11)
  BOTTOM w0.142: 255.61,73.68 256,74.07 v2(256,75.11) UG5.J2 ; UG9.A11 237.81,86.65 238.95,85.51 238.95,85.2
  BOTTOM w0.173: 255.61,73.68 255.49,73.56 253.67,73.56 253.39,73.28 247.61,73.28 v1(241.15,79.74) 239.99,80.9 239.99,84.16 238.95,85.2
FBC_CMD3: length 31.2
  BOTTOM w0.089: UG5.L3 254.8,76.3
  BOTTOM w0.142: 254.56,73.88 255.15,74.47 255.15,75.95 254.8,76.3 ; 237.94,87 234,87 UG9.D11
  BOTTOM w0.173: 254.56,73.88 247.86,73.88 240.6,81.13 v1(240.6,82.6) 240.6,84.33 237.94,87
FBC_CMD4: length 26.6
  BOTTOM w0.089: UG5.K5 255.6,77.98
  BOTTOM w0.142: 255.6,77.98 255.32,78.26 249.85,78.26 249.54,77.94 249.54,77.56 249.27,77.29 248.97,77.29 ; UG9.A12 238.32,87.35
  BOTTOM w0.173: 238.32,87.35 241.21,84.46 241.21,81.37 245.29,77.29 v1(246.99,77.29) 248.97,77.29
FBC_CMD5: length 28.7
  BOTTOM w0.142: UG5.K4 255.6,77.2 255.95,77.56 255.95,78.38 255.77,78.56 249.64,78.56 248.94,77.86 248.94,77.82 ; UG9.B12 235.25,87.35 235.6,87.7 238.61,87.7
  BOTTOM w0.173: 238.61,87.7 240.65,85.66 240.75,85.66 241.82,84.59 241.82,81.65 v1(244.88,78.59) 245.66,77.81 248.93,77.81 248.94,77.82
FBC_CMD6: length 28.9
  BOTTOM w0.142: 248.97,78.36 249.06,78.36 249.56,78.87 255.98,78.87 256.4,78.45 UG5.J5 ; UG9.C12 234.54,87.35 234.89,87.7 235.25,87.7 235.48,87.93 236.41,87.93 236.51,88.03 238.82,88.03 238.92,87.93
  BOTTOM w0.173: 238.92,87.93 240.83,86.03 241.19,86.03 242.43,84.79 242.43,81.93 v1(243.54,80.83) 246,78.36 248.97,78.36
FBC_CMD7: length 30.3
  BOTTOM w0.142: 248.97,78.88 249.15,78.88 249.44,79.17 256.31,79.17 256.78,78.7 256.78,77.69 256.4,77.3 UG5.J4 ; UG9.C14 234.7,88.4 235.2,88.4 235.43,88.17 236.22,88.17 236.35,88.29 239.11,88.29 239.24,88.17
  BOTTOM w0.173: 239.24,88.17 240.9,86.5 241.48,86.5 243.04,84.94 v1(243.04,83.28) 243.04,82.2 246.36,78.88 248.97,78.88
FBC_CMD8: length 29
  BOTTOM w0.142: UG5.H5 257.2,78.92 256.66,79.45 249.02,79.45 248.97,79.4 ; 239.51,88.4 239.36,88.55 236.17,88.55 236.03,88.4 235.55,88.4 235.2,88.75 UG9.B14
  BOTTOM w0.173: 239.51,88.4 240.72,87.19 241.63,87.19 v1(242.86,85.96) 243.65,85.17 243.65,82.43 246.68,79.4 248.97,79.4
FBC_CMD9: length 29.7
  BOTTOM w0.142: 239.96,88.75 239.86,88.85 235.85,88.85 UG9.A14 ; UG5.H4 257.2,77.28 257.6,77.69 257.6,79.02 256.89,79.73 249.16,79.73 248.97,79.92
  BOTTOM w0.173: 239.96,88.75 240.98,87.73 241.93,87.73 244.26,85.4 244.26,82.66 v1(245.01,81.91) 247,79.92 248.97,79.92
FBC_CMD10: length 32.6
  BOTTOM w0.142: UG5.G12 258,83.41 257.6,83.02 257.6,80.73 256.89,80.02 249.3,80.02 248.88,80.44 ; 240.26,89.1 234,89.1 UG9.D14
  BOTTOM w0.173: 240.26,89.1 241.11,88.25 242.24,88.25 244.87,85.63 244.87,83.04 v1(246.94,80.97) 247.46,80.44 248.88,80.44
FBC_CMD11: length 27.9
  BOTTOM w0.142: UG9.A15 240.4,89.45 ; 248.8,80.96 249.46,80.3 256.41,80.3 257.2,81.09 UG5.H10
  BOTTOM w0.173: 248.8,80.96 247.78,80.96 245.48,83.26 245.48,85.85 v1(244.76,86.57) 242.56,88.77 241.08,88.77 240.4,89.45
FBC_CMD12: length 29.1
  BOTTOM w0.142: 240.46,89.79 235.59,89.79 235.25,89.45 UG9.B15 ; UG5.H11 257.2,82.61 256.84,82.26 256.84,81.24 256.19,80.59 249.58,80.59 248.69,81.48
  BOTTOM w0.173: 248.69,81.48 248.1,81.48 246.09,83.49 246.09,86.08 v1(243.56,88.61) 242.88,89.29 240.96,89.29 240.46,89.79
FBC_CMD13: length 29
  BOTTOM w0.142: 248.59,82 249.7,80.89 255.6,80.89 255.95,81.24 255.95,82.35 UG5.K11 ; 236.47,90.1 236.39,90.03 235.48,90.03 235.25,89.8 234.9,89.8 234.55,89.45 UG9.C15
  BOTTOM w0.173: 236.47,90.1 240.74,90.1 241.03,89.81 243.2,89.81 246.7,86.31 v1(246.7,84.53) 246.7,83.72 248.42,82 248.59,82
FBC_CMD14: length 27.6
  BOTTOM w0.102: UG9.C17 234.58,90.85 234.93,90.5 235.2,90.5
  BOTTOM w0.142: 248.6,82.39 249.82,81.18 255.19,81.18 255.6,81.58 UG5.K10 ; 236.46,90.45 236.29,90.27 235.43,90.27 235.2,90.5
  BOTTOM w0.173: 248.6,82.39 248.6,82.65 247.31,83.95 247.31,86.54 v1(246.72,87.13) 243.51,90.33 241.07,90.33 240.96,90.45 236.46,90.45
FBC_CMD15: length 28.2
  BOTTOM w0.142: 249.06,82.34 249.91,81.5 254.9,81.5 255.19,81.79 255.19,83.02 254.8,83.41 UG5.L12 ; 236.3,90.86 235.95,90.51 235.54,90.51 235.2,90.85 UG9.B17
  BOTTOM w0.173: 236.3,90.86 243.83,90.86 v1(245.17,89.51) 247.92,86.77 247.92,84.18 249.06,83.04 249.06,82.34
FBC_CMD16: length 31.7
  BOTTOM w0.142: 238.91,96.1 235.6,96.1 235.25,95.75 UG9.B24 ; 257.6,104.16 257.6,102.75 UG6.L3
  BOTTOM w0.173: 238.91,96.1 239.84,97.03 239.84,98.4 240.96,99.52 241.93,99.52 v1(243.19,100.79) 248.92,106.51 256.65,106.51 257.6,105.56 257.6,105.56 257.79,105.37 257.79,104.36 257.6,104.16
FBC_CMD17: length 32.3
  TOP w0.089: RG52.2 257.73,103.69 v2(256.8,102.75)
  BOTTOM w0.089: UG6.J3 256.4,102.35
  BOTTOM w0.142: 256.4,102.35 v2(256.8,102.75) 256.8,103.13
  BOTTOM w0.173: 256.8,103.13 256.8,105.3 256.1,105.99 249.13,105.99 v1(245.18,102.04) 242.15,99.01 241.31,99.01 240.36,98.06 240.36,97.01 239.09,95.75
  BOTTOM w0.178: UG9.A24 239.09,95.75
FBC_CMD18: length 33.4
  TOP w0.178: v2(256,103.55) 255.89,103.66 255.89,104.74 255.76,104.86 255.76,106.73 256.18,107.15 RG57.1
  BOTTOM w0.142: 239.16,95.4 234,95.4 UG9.D23
  BOTTOM w0.173: 239.16,95.4 240.79,97.03 240.79,97.73 241.55,98.49 242.36,98.49 v1(247.21,103.33) 249.35,105.47 255.7,105.47 255.89,105.28 255.89,104.44 255.98,104.36 255.98,103.57
  BOTTOM w0.178: UG6.J2 v2(256,103.55) 255.98,103.57
FBC_CMD19: length 26
  BOTTOM w0.142: UG9.A23 239.24,95.05 ; UG6.G3 254.8,102.44 255.14,102.78 255.14,104.13
  BOTTOM w0.173: 255.14,104.13 254.31,104.95 249.56,104.95 242.58,97.97 v1(242.16,97.97) 241.77,97.97 241.21,97.41 241.21,97.02 239.24,95.05
FBC_CMD20: length 24.2
  BOTTOM w0.142: UG6.H5 255.6,100.65 255.37,100.42 249.6,100.42 248.69,101.33 ; UG9.B23 235.2,95.05 235.55,94.7 238.92,94.7 238.99,94.77 239.39,94.77
  BOTTOM w0.173: 239.39,94.77 241.54,96.91 241.54,97.15 241.83,97.45 242.92,97.45 246.81,101.33
  BOTTOM w0.178: 248.69,101.33 v1(247.56,101.33) 246.81,101.33
FBC_CMD21: length 26.2
  BOTTOM w0.142: UG9.C23 234.7,94.7 235.2,94.7 235.44,94.46 239.53,94.46 ; UG6.H4 255.6,101.47 256.02,101.05 256.02,100.48 255.63,100.1 249.35,100.1 248.64,100.81
  BOTTOM w0.173: 243.14,96.93 v1(244.94,98.73) 247.03,100.81 ; 239.53,94.46 242,96.93
  BOTTOM w0.178: 242,96.93 243.14,96.93 ; 248.64,100.81 247.03,100.81
FBC_CMD22: length 25.6
  BOTTOM w0.142: 248.62,100.29 249.09,99.82 255.86,99.82 256.4,100.35 UG6.J5 ; 239.68,94.2 236.12,94.2 236.1,94.22 235.47,94.22 235.25,94 234.86,94 234.51,93.65 UG9.C21
  BOTTOM w0.173: 239.68,94.2 241.88,96.41 ; 247.24,100.29 v1(244.02,97.08) 243.35,96.41
  BOTTOM w0.178: 241.88,96.41 243.35,96.41 ; 248.62,100.29 247.24,100.29
FBC_CMD23: length 26.2
  BOTTOM w0.142: UG6.J4 256.41,101.55 256.84,101.12 256.84,100.35 256.03,99.54 248.94,99.54 248.71,99.77 ; UG9.B21 235.27,93.65 235.6,93.99 235.91,93.99 235.99,93.9 239.84,93.9
  BOTTOM w0.173: 247.46,99.77 v1(246.86,99.17) 243.57,95.88 241.82,95.88 239.84,93.9
  BOTTOM w0.178: 248.71,99.77 247.46,99.77
FBC_CMD24: length 24.8
  BOTTOM w0.142: UG9.A21 240.14,93.65 ; 248.71,99.25 256.25,99.25 257.2,100.2 UG6.K5
  BOTTOM w0.173: 240.14,93.65 241.86,95.36 v1(242.84,95.36) 243.94,95.36 246.03,97.46 246.03,97.54 247.69,99.2 247.77,99.2 247.83,99.25
  BOTTOM w0.178: 248.71,99.25 247.83,99.25
FBC_CMD25: length 28.8
  BOTTOM w0.142: 237.09,93.2 236.99,93.3 234,93.3 UG9.D20 ; UG6.K4 257.2,101.4 257.54,101.05 257.54,99.78 256.71,98.96 249.09,98.96 248.87,98.73
  BOTTOM w0.173: 248.14,98.73 248.09,98.68 247.9,98.68 246.55,97.33 246.55,97.14 244.26,94.84 241.82,94.84 v1(241.04,94.07) 240.17,93.2
  BOTTOM w0.178: 237.09,93.2 240.17,93.2 ; 248.87,98.73 248.14,98.73
FBC_CMD26: length 27.8
  BOTTOM w0.142: UG9.A20 236.84,92.95 236.97,92.82 ; UG6.L12 257.54,95.61 257.54,98.07 256.93,98.68 249.26,98.68 248.79,98.21
  BOTTOM w0.173: 248.16,98.21 247.07,97.11 247.07,96.81 v1(246.58,96.33) 244.57,94.32 241.86,94.32 240.35,92.82
  BOTTOM w0.178: 248.79,98.21 248.16,98.21 ; 236.97,92.82 240.35,92.82
FBC_CMD27: length 26.4
  BOTTOM w0.142: 236.96,92.41 236.76,92.61 235.54,92.61 235.2,92.95 UG9.B20 ; 248.64,97.65 249.37,98.39 256.52,98.39 257.2,97.71 UG6.K10
  BOTTOM w0.173: 240.48,92.41 241.87,93.8 244.97,93.8 v1(245.64,94.47) 247.58,96.41 247.58,96.9 248.33,97.65
  BOTTOM w0.178: 248.64,97.65 248.33,97.65 ; 236.96,92.41 240.48,92.41
FBC_CMD28: length 27.6
  BOTTOM w0.142: UG6.K11 257.2,96 256.84,96.35 256.84,97.43 256.21,98.07 249.46,98.07 248.12,96.72 248.12,96.71 ; UG9.C20 234.7,92.6 235.2,92.6 235.43,92.37 236.45,92.37 236.7,92.11 240.75,92.11
  BOTTOM w0.173: 248.12,96.71 248.1,96.69 248.1,96.09 245.29,93.28 243.53,93.28 v1(243.47,93.22) 243.41,93.28 241.92,93.28 240.75,92.11
FBC_CMD29: length 26.7
  BOTTOM w0.142: 248.4,96.54 249.6,97.75 255.51,97.75 255.95,97.31 255.95,96.29 255.61,95.95 UG6.H11 ; UG9.C18 234.5,91.55 234.85,91.9 235.25,91.9 235.48,92.13 236.15,92.13 236.44,91.85
  BOTTOM w0.173: 241.06,91.85 241.97,92.76 245.6,92.76 v1(247.77,94.93) 248.4,95.55 248.4,96.54
  BOTTOM w0.178: 236.44,91.85 241.06,91.85
FBC_CMD30: length 24.6
  BOTTOM w0.142: UG6.H10 255.6,97.15 255.28,97.47 249.76,97.47 248.78,96.49 248.78,95.38 ; UG9.B18 235.25,91.55 235.6,91.9 235.93,91.9 236.27,91.56
  BOTTOM w0.173: 248.78,95.38 248.78,95.1 245.92,92.24 v1(245.24,92.24) 241.97,92.24 241.29,91.56
  BOTTOM w0.178: 236.27,91.56 241.29,91.56
FBC_CMD31: length 25.2
  BOTTOM w0.142: UG6.G12 254.8,95.33 255.19,95.72 255.19,96.99 255,97.18 249.87,97.18 249.16,96.46 ; UG9.A18 236.08,91.23 241.4,91.23
  BOTTOM w0.173: 249.16,96.46 249.16,94.59 246.06,91.49 v1(242.3,91.49) 241.67,91.49 241.4,91.23
FBC_D0: length 19.5
  IN3 w0.14: v2(234.06,83.49) 234.93,82.61 236.3,82.61 236.54,82.37 238.05,82.37 238.35,82.07 238.39,82.07 238.4,82.05 240.6,82.05 244.69,77.96 247.67,77.96 v2(249.13,76.5)
  BOTTOM w0.089: UG5.U4 249.74,77.11 v2(249.13,76.5)
  BOTTOM w0.17: UG9.C6 234.06,83.44
  BOTTOM w0.178: 234.06,83.44 v2(234.06,83.49)
FBC_D1: length 19.8
  IN3 w0.14: v2(249.6,75.11) 249.31,75.4 248.14,75.4 246.36,77.18 244.46,77.18 240.33,81.3 238.49,81.3 237.88,81.91 v2(237.39,81.91)
  BOTTOM w0.089: UG5.U2 249.99,75.51 v2(249.6,75.11)
  BOTTOM w0.1: 235.87,82.79 234.01,82.79 UG9.D6
  BOTTOM w0.15: 237.22,82.08 236.51,82.79 235.87,82.79
  BOTTOM w0.213: 237.22,82.08 v2(237.39,81.91)
FBC_D2: length 19.1
  IN3 w0.14: v2(250.4,76.71) 250.4,76.82 250.02,77.2 250.02,77.58 248.26,79.34 245.34,79.34 241.28,83.4 239.12,83.4 238.29,84.23 237.31,84.23 v2(236.57,83.49)
  BOTTOM w0.089: UG5.T4 v2(250.4,76.71)
  BOTTOM w0.142: v2(236.57,83.49) 236.23,83.15 UG9.A6
FBC_D3: length 20.1
  IN3 w0.14: v2(235.35,83.45) 235.84,82.96 236.39,82.96 236.65,82.7 241.03,82.7 245.12,78.61 247.94,78.61 249.78,76.77 249.78,76.42 250.01,76.2 250.01,75.63 250.4,75.24 v2(250.4,75.11)
  BOTTOM w0.089: UG5.T2 250.8,75.51 v2(250.4,75.11)
  BOTTOM w0.178: UG9.B6 v2(235.35,83.45)
FBC_D4: length 24.8
  IN3 w0.14: v2(235.35,81.45) 236.2,80.6 237.29,80.6 237.98,79.91 239.75,79.91 243.94,75.72 245.73,75.72 247.57,73.88 252.97,73.88 253.2,74.1 253.2,76.31 v2(253.6,76.71)
  BOTTOM w0.089: UG5.N4 v2(253.6,76.71)
  BOTTOM w0.178: v2(235.35,81.45) UG9.B4
FBC_D5: length 20.7
  IN3 w0.14: v2(236.9,81.13) 237.46,81.13 237.98,80.61 240.01,80.61 244.2,76.42 245.98,76.42 247.69,74.71 252.4,74.71 v2(252.8,75.11)
  BOTTOM w0.089: v2(252.8,75.11) 253.2,75.51 UG5.N2
  BOTTOM w0.1: UG9.A4 236.28,81.75 v2(236.9,81.13)
FBC_D6: length 28.1
  IN3 w0.14: v2(236.9,79.8) 236.9,79.23 237.68,78.45 239,78.45 243.25,74.2 244,74.2 244.01,74.2 244.7,74.2 244.7,74.2 245.03,74.2 246.74,72.48 253.86,72.48 254.9,73.51 254.9,76.21 v2(254.4,76.71)
  BOTTOM w0.089: v2(254.4,76.71) 254,77.11 UG5.M4
  BOTTOM w0.1: UG9.B3 235.4,80.7 236,80.7 v2(236.9,79.8)
FBC_D7: length 25.6
  IN3 w0.14: v2(253.6,75.11) 254,74.71 254,73.85 253.32,73.18 247.25,73.18 245.54,74.89 243.57,74.89 239.25,79.21 237.79,79.21 237.4,79.61 237.4,79.89 237.08,80.2 236.2,80.2 235.45,80.95 235.15,80.95 v2(234.65,81.45)
  BOTTOM w0.089: UG5.M2 253.99,75.51 v2(253.6,75.11)
  BOTTOM w0.17: UG9.C4 v2(234.65,81.45)
FBC_D8: length 18.2
  IN1 w0.089: v2(249.6,83.11) 249.56,83.15 248.94,83.15
  IN1 w0.145: v2(233.95,85.55) 234.35,85.15 235.53,85.15 236.25,85.87 239.09,85.87 241.01,83.95 246.96,83.95 247.76,83.15 248.94,83.15
  BOTTOM w0.089: UG5.U11 v2(249.6,83.11)
  BOTTOM w0.178: UG9.D9 v2(233.95,85.55)
FBC_D9: length 17.1
  IN1 w0.145: v2(249.6,84.71) 241.31,84.71 239.48,86.54 235.64,86.54 v2(234.65,85.55)
  BOTTOM w0.089: UG5.U13 v2(249.6,84.71)
  BOTTOM w0.178: UG9.C9 v2(234.65,85.55)
FBC_D10: length 20.3
  IN1 w0.089: 248.94,82.38 249.67,82.38 v2(250.4,83.11)
  IN1 w0.145: v2(233.1,85.68) 234.04,84.74 236.24,84.74 236.4,84.9 237.89,84.9 238.05,85.05 238.97,85.05 240.89,83.13 246.19,83.13 246.94,82.38 248.94,82.38
  BOTTOM w0.089: UG5.T11 v2(250.4,83.11)
  BOTTOM w0.178: v2(233.1,85.68) 232.95,85.53 UG9.E9
FBC_D11: length 17.2
  IN2 w0.145: v2(250.4,84.71) 250,84.31 249.07,84.31 248.72,84.67 239.56,84.67 238.48,85.75 236.85,85.75 v2(236.42,85.33)
  BOTTOM w0.089: UG5.T13 v2(250.4,84.71)
  BOTTOM w0.142: UG9.B9 235.41,84.89 235.98,84.89 236.41,85.33 v2(236.42,85.33)
FBC_D12: length 21.9
  IN1 w0.1: 252.4,81.8 252.4,82.51
  IN1 w0.129: v2(237.43,83.18) 237.91,82.71 237.92,82.71 ; v2(252.8,83.11) 252.8,82.91 252.4,82.51 ; 252.4,81.8 250.82,80.23 248.97,80.23
  IN1 w0.145: 248.97,80.23 240.88,80.23 238.41,82.71 237.92,82.71
  BOTTOM w0.089: UG5.N11 v2(252.8,83.11)
  BOTTOM w0.142: UG9.B8 235.18,84.55 235.55,84.19 236.43,84.19 236.97,83.65 236.97,83.58 237.22,83.33
  BOTTOM w0.213: v2(237.43,83.18) 237.28,83.33 237.22,83.33
FBC_D13: length 21.8
  IN1 w0.1: 252.4,82.91 252.4,84.31 ; 251.8,82.71 252.2,82.71 ; 251.6,82.01 251.6,82.51
  IN1 w0.129: 251.6,82.51 251.8,82.71 ; 252.2,82.71 252.4,82.91 ; 252.4,84.31 v2(252.8,84.71) ; 251.6,82.01 250.58,80.99 249.03,80.99
  IN1 w0.145: v2(238.08,83.76) 238.38,83.76 241.15,80.99 249.03,80.99
  BOTTOM w0.089: UG5.N13 v2(252.8,84.71)
  BOTTOM w0.178: 237.91,83.97 237.34,84.55 UG9.A8
  BOTTOM w0.213: v2(238.08,83.76) 238.08,83.81 237.91,83.97
FBC_D14: length 27.1
  IN1 w0.1: 254,81.95 UG5.M11
  IN1 w0.129: UG5.M11 v2(253.6,83.11) ; 248.97,78.76 251.21,78.76 254,81.55 254,81.95
  IN1 w0.145: v2(232.55,82.85) 232.86,82.54 236.24,82.54 236.53,82.24 236.53,82.04 237.29,81.29 239.81,78.76 248.97,78.76
  BOTTOM w0.089: UG5.M11 v2(253.6,83.11)
  BOTTOM w0.17: UG9.F6 v2(232.55,82.85)
FBC_D15: length 27.3
  IN1 w0.1: 253.2,84.31 253.2,81.68
  IN1 w0.129: 253.2,81.68 250.98,79.46 248.97,79.46 ; v2(253.6,84.71) 253.2,84.31
  IN1 w0.145: v2(232.65,83.45) 233.06,83.04 236.86,83.04 240.44,79.46 248.97,79.46
  BOTTOM w0.089: UG5.M13 v2(253.6,84.71)
  BOTTOM w0.17: v2(232.65,83.45) UG9.E6
FBC_D16: length 44
  IN1 w0.1: 232.16,92.26 232.16,92.92
  IN1 w0.129: v2(231.85,91.95) 232.16,92.26
  IN1 w0.145: v2(263.2,82.31) 264.72,83.83 264.72,89.24 263.08,90.87 248.23,90.87 247,92.1 236.33,92.1 235.54,92.89 233,92.89 232.81,93.08 232.32,93.08 232.16,92.92
  BOTTOM w0.089: UG5.A11 262.8,82.71 v2(263.2,82.31)
  BOTTOM w0.178: UG9.F18 v2(231.85,91.95)
FBC_D17: length 37.5
  IN1 w0.129: v2(263.2,84.71) 263.32,84.83 263.32,86.38
  IN1 w0.145: 263.32,86.38 263.32,87.09 260.78,89.62 244.78,89.62 243.76,90.64 236.06,90.64 235.29,91.41 231.69,91.41 v2(231.25,91.85)
  BOTTOM w0.089: v2(263.2,84.71) 262.8,84.31 UG5.A13
  BOTTOM w0.17: v2(231.25,91.85) UG9.G18
FBC_D18: length 40.3
  IN1 w0.1: 263.4,83.51 263.03,83.51 262.8,83.28 262.8,82.71
  IN1 w0.129: 263.86,83.91 263.46,83.51 263.4,83.51 ; v2(262.4,82.31) 262.8,82.71
  IN1 w0.145: 263.86,83.91 263.89,83.95 263.89,87.91 261.48,90.32 247.76,90.32 246.68,91.4 236.18,91.4 235.64,91.94 235.31,91.94 234.7,92.55 233.95,92.55 v2(233.25,91.85)
  BOTTOM w0.089: v2(262.4,82.31) 262,82.71 UG5.B11
  BOTTOM w0.178: UG9.E18 v2(233.25,91.85)
FBC_D19: length 38.6
  IN1 w0.1: 262.8,84.31 262.8,85.89
  IN1 w0.129: v2(262.4,83.91) 262.8,84.31 ; 262.8,85.89 262.3,86.38
  IN1 w0.145: 262.3,86.38 262.18,86.51 262.18,86.89 260.14,88.92 243.95,88.92 243,89.88 235.9,89.88 234.82,90.96 231.44,90.96 v2(230.38,92.03)
  BOTTOM w0.089: v2(262.4,83.91) 262,84.31 UG5.B13
  BOTTOM w0.178: UG9.H18 v2(230.38,92.03)
FBC_D20: length 32.8
  IN1 w0.1: 260.4,83.51 260.4,86.38
  IN1 w0.129: v2(260,83.11) 260.4,83.51
  IN1 w0.145: 260.4,86.38 260.35,86.43 260.35,86.93 259.06,88.23 243.25,88.23 242.38,89.1 235.69,89.1 234.98,89.81 234.3,89.81 v2(234.12,89.99)
  BOTTOM w0.089: v2(260,83.11) 259.6,82.71 UG5.E11
  BOTTOM w0.17: UG9.D15 233.65,89.47 234.12,89.94 v2(234.12,89.99)
FBC_D21: length 32.4
  IN1 w0.1: 259.6,84.31 259.6,86.23
  IN1 w0.129: v2(259.2,83.91) 259.6,84.31
  IN1 w0.145: 259.6,86.23 259.61,86.24 259.61,86.86 258.94,87.53 242.62,87.53 241.64,88.51 235.7,88.51 234.86,89.35 233.95,89.35 233.77,89.53 233.14,89.53 v2(232.72,89.95)
  BOTTOM w0.089: v2(259.2,83.91) 259.6,84.31 UG5.E13
  BOTTOM w0.17: v2(232.72,89.95) 232.72,89.68 UG9.E15
FBC_D22: length 33.3
  IN1 w0.1: 258.8,83.51 258.8,85.9
  IN1 w0.129: v2(259.2,83.11) 258.8,83.51
  IN1 w0.145: 258.8,85.9 258.8,86.28 258.24,86.83 242.24,86.83 241.21,87.86 235.77,87.86 234.76,88.87 233.79,88.87 233.51,89.15 232.87,89.15 232.19,89.83 232.19,90.11 231.85,90.45 v2(231.85,90.48)
  BOTTOM w0.089: UG5.F11 258.8,82.71 v2(259.2,83.11)
  BOTTOM w0.178: UG9.G17 231.55,90.75 231.82,90.48 v2(231.85,90.48)
FBC_D23: length 31.7
  IN1 w0.145: v2(230.55,90.55) 230.85,90.25 230.85,89.54 231.49,88.9 232.15,88.9 232.3,88.75 233.32,88.75 233.75,88.32 234.76,88.32 235.84,87.24 240.17,87.24 241.28,86.13 255.79,86.13 256.93,84.99 258.12,84.99 v2(258.4,84.71)
  BOTTOM w0.089: UG5.F13 258.8,84.31 v2(258.4,84.71)
  BOTTOM w0.178: UG9.H17 v2(230.55,90.55)
FBC_D24: length 41.1
  IN5 w0.089: 233.8,88.85 233.69,88.96 230.64,88.96 230.36,89.24 v2(229.85,89.75)
  IN5 w0.145: v2(263.27,77.3) 263.59,77.62 263.59,78.99 262.47,80.11 260.73,80.11 259.96,80.88 259.68,80.88 259.64,80.92 257.57,80.92 256.65,81.84 256.08,81.84 255.99,81.75 249.2,81.75 244.89,86.06 242.47,86.06 239.87,88.67 235.77,88.67 235.58,88.85 233.8,88.85
  BOTTOM w0.089: v2(263.27,77.3) 262.99,77.3 UG5.A4
  BOTTOM w0.178: UG9.J15 v2(229.85,89.75)
FBC_D25: length 43.6
  IN5 w0.089: 234.75,89.19 234.71,89.14 231.16,89.14 v2(230.4,89.9)
  IN5 w0.145: 234.75,89.19 240.27,89.19 242.68,86.78 245.17,86.78 249.24,82.71 255.52,82.71 255.74,82.5 256.87,82.5 257.54,81.83 260.62,81.83 260.97,81.49 260.97,81.16 261.36,80.76 262.56,80.76 264.52,78.79 264.52,77.24 v2(263.2,75.91)
  BOTTOM w0.089: UG5.A2 262.8,75.51 v2(263.2,75.91)
  BOTTOM w0.178: UG9.H15 v2(230.4,89.9)
FBC_D26: length 35.9
  IN5 w0.089: v2(232.69,88.32) 232.95,88.58 233.43,88.58 233.66,88.35
  IN5 w0.145: 233.66,88.35 234.69,88.35 235.45,87.59 236.14,87.59 236.27,87.46 239.21,87.46 242.1,84.57 244.41,84.57 248.53,80.45 255.53,80.45 256.12,79.86 259.2,79.86 260.18,78.88 261.73,78.88 262,78.61 262,77.91 v2(262.4,77.51)
  BOTTOM w0.089: v2(262.4,77.51) 262,77.11 UG5.B4
  BOTTOM w0.17: UG9.E14 232.69,88.5 v2(232.69,88.32)
FBC_D27: length 39.2
  IN5 w0.089: 233.73,88.61 233.56,88.78 232.28,88.78 v2(231.95,88.45)
  IN5 w0.145: v2(262.4,75.91) 262.4,76.75 262.81,77.16 262.81,78.92 262.31,79.42 260.49,79.42 259.56,80.35 259.46,80.35 259.42,80.39 256.49,80.39 255.81,81.07 248.95,81.07 244.64,85.38 242.18,85.38 239.4,88.16 235.51,88.16 235.06,88.61 233.73,88.61
  BOTTOM w0.089: UG5.B2 262,75.51 v2(262.4,75.91)
  BOTTOM w0.17: UG9.F14 v2(231.95,88.45)
FBC_D28: length 36
  IN5 w0.145: v2(259.2,76.71) 259.6,77.11 259.6,78.54 258.89,79.25 255.98,79.25 255.38,79.84 248.21,79.84 244.28,83.77 242.03,83.77 238.91,86.89 236.14,86.89 236.01,87.02 234.97,87.02 234.73,87.26 231.46,87.26 v2(230.55,86.35)
  BOTTOM w0.089: v2(259.2,76.71) 259.2,76.71 UG5.E4
  BOTTOM w0.178: UG9.H11 v2(230.55,86.35)
FBC_D29: length 36.2
  IN5 w0.145: v2(259.2,75.11) 258.8,75.51 258.8,77.68 258.48,78 258.03,78 257.45,78.58 255.76,78.58 255.09,79.25 247.71,79.25 244.06,82.91 241.93,82.91 238.52,86.32 236.08,86.32 235.97,86.43 235.01,86.43 234.54,86.9 233.56,86.9 233.51,86.95 232,86.95 231.55,86.5 231.55,85.85 v2(231.6,85.8)
  BOTTOM w0.089: v2(259.2,75.11) 259.2,75.11 UG5.E2
  BOTTOM w0.142: UG9.G11 231.55,85.85 v2(231.6,85.8)
FBC_D30: length 30.8
  IN5 w0.145: v2(232.55,86.35) 232.86,86.66 233.38,86.66 233.47,86.57 234.37,86.57 234.9,86.04 235.72,86.04 236.01,85.75 237.98,85.75 241.59,82.14 243.79,82.14 247.3,78.63 254.95,78.63 255.59,77.99 257.49,77.99 257.97,77.51 v2(258.4,77.51)
  BOTTOM w0.089: v2(258.4,77.51) 258.8,77.11 UG5.F4
  BOTTOM w0.17: UG9.F11 v2(232.55,86.35)
FBC_D31: length 31.3
  IN5 w0.145: v2(233.2,86.25) 233.5,85.95 233.5,85.37 233.76,85.11 235.46,85.11 235.83,84.74 237.73,84.74 241.16,81.32 243.48,81.32 246.77,78.02 254.66,78.02 255.35,77.33 257.6,77.33 258,76.93 258,76.31 v2(258.4,75.91)
  BOTTOM w0.089: UG5.F2 v2(258.4,75.91)
  BOTTOM w0.17: UG9.E11 233.2,86.4 v2(233.2,86.25)
FBC_D32: length 22.5
  IN1 w0.129: v2(229.85,98.95) 230.44,99.54 232.24,99.54 232.39,99.4 233.69,99.4 233.84,99.25
  IN1 w0.145: v2(249.6,101.95) 249.29,102.26 245.95,102.26 243.36,99.68 235.85,99.68 235.41,99.25 233.84,99.25
  BOTTOM w0.089: UG6.A4 v2(249.6,101.95)
  BOTTOM w0.178: UG9.J29 v2(229.85,98.95)
FBC_D33: length 19.9
  IN1 w0.089: 234.01,99.95 233.49,99.95 233.41,99.87 232.93,99.87 v2(232.55,100.25)
  IN1 w0.145: 234.01,99.95 234.67,99.95 235.46,100.74 242.43,100.74 245.35,103.66 248.21,103.66 248.35,103.81 249.34,103.81 v2(249.6,103.55)
  BOTTOM w0.178: UG9.F30 v2(232.55,100.25) ; UG6.A2 v2(249.6,103.55)
FBC_D34: length 21.9
  IN1 w0.089: 233.67,98.93 233.42,99.19 232.23,99.19 232.13,99.28 231.48,99.28 v2(231.15,98.95)
  IN1 w0.145: v2(250.4,101.95) 249.99,101.55 246.29,101.55 243.51,98.77 234.74,98.77 234.58,98.93 233.67,98.93
  BOTTOM w0.089: UG6.B4 v2(250.4,101.95)
  BOTTOM w0.178: UG9.H29 v2(231.15,98.95)
FBC_D35: length 22
  IN1 w0.129: v2(231.25,100.25) 231.62,99.88 232.32,99.88 232.56,99.64 233.89,99.64 233.93,99.6
  IN1 w0.145: 233.93,99.6 235.09,99.6 235.71,100.23 242.9,100.23 245.63,102.96 248.46,102.96 248.64,103.14 249.99,103.14 v2(250.4,103.55)
  BOTTOM w0.178: UG9.G30 v2(231.25,100.25) ; UG6.B2 v2(250.4,103.55)
FBC_D36: length 24.7
  IN1 w0.145: v2(240.29,101.3) 240.29,101.34 240.83,101.88 241.15,101.88 244.87,105.6 252.7,105.6 253.2,105.1 253.2,102.35 v2(253.6,101.95)
  BOTTOM w0.089: UG6.E4 v2(253.6,101.95)
  BOTTOM w0.102: UG9.B30 235.25,99.95 235.58,100.28 235.97,100.28 236.06,100.19 236.84,100.19 236.87,100.22
  BOTTOM w0.178: 236.87,100.22 236.94,100.29 238.55,100.29 239,100.74 239.4,100.74
  BOTTOM w0.213: v2(240.29,101.3) 240.12,101.13 240.12,101.1 v1(239.76,100.74) 239.4,100.74
FBC_D37: length 20.9
  IN1 w0.145: v2(252.8,103.55) 252.4,103.95 252.4,104.7 252.15,104.95 246.2,104.95 245.6,104.36 245.03,104.36 241.98,101.31 v2(241.46,101.31)
  BOTTOM w0.142: 239.12,100.28 238.97,100.28 238.65,99.95 UG9.A30
  BOTTOM w0.178: UG6.E2 v2(252.8,103.55)
  BOTTOM w0.213: v2(241.46,101.31) 241.47,101.3 241.47,101 241.09,100.62 240.51,100.62 240.17,100.28 239.12,100.28
FBC_D38: length 33.3
  IN1 w0.1: 235.35,101.29 232.91,101.29 232.72,101.48 231.05,101.48 230.78,101.21 230.78,100.48
  IN1 w0.129: v2(230.55,100.25) 230.78,100.48
  IN1 w0.145: v2(254.4,101.95) 254.8,102.36 254.8,105.86 253.75,106.91 243.81,106.91 239.31,102.4 239.31,102.12 238.88,101.7 235.76,101.7 235.35,101.29
  BOTTOM w0.089: UG6.F4 v2(254.4,101.95)
  BOTTOM w0.17: UG9.H30 v2(230.55,100.25)
FBC_D39: length 25.4
  IN1 w0.145: v2(253.6,103.55) 254,103.95 254,105.67 253.41,106.26 244.49,106.26 239.97,101.74 239.53,101.74 v2(239.1,101.31)
  BOTTOM w0.102: 236.74,100.48 235.43,100.48 235.25,100.3 234.9,100.3 234.55,99.95 UG9.C30
  BOTTOM w0.142: v2(239.1,101.31) 239.1,101.3 238.92,101.12 238.61,100.81
  BOTTOM w0.178: 236.74,100.48 236.86,100.6 238.3,100.6 v1(238.35,100.65) 238.45,100.65 238.61,100.81 ; UG6.F2 v2(253.6,103.55)
FBC_D40: length 18.2
  IN5 w0.145: v2(233.95,98.15) 234.06,98.04 235.42,98.04 235.81,97.64 235.81,97.06 236.14,96.74 243.82,96.74 243.95,96.86 248.29,96.86 v2(249.6,95.55)
  BOTTOM w0.089: UG6.A11 v2(249.6,95.55)
  BOTTOM w0.17: UG9.D27 v2(233.95,98.15)
FBC_D41: length 22.9
  IN5 w0.145: v2(249.6,93.95) 249.33,93.69 248.52,93.69 247.63,94.58 244.21,94.58 243.64,95.15 235.74,95.15 235.11,95.78 235.11,96.3 234.15,97.25 230.25,97.25 229.86,96.86 v2(229.86,96.81)
  BOTTOM w0.089: v2(249.6,93.95) 249.99,94.35 UG6.A13
  BOTTOM w0.178: v2(229.86,96.81) 230.15,97.1 UG9.J26
FBC_D42: length 21
  IN5 w0.145: v2(250.4,95.55) 250,95.15 249.03,95.15 248.08,96.1 244.65,96.1 244.52,96.23 236.13,96.23 235.46,96.91 235.46,97.18 234.88,97.75 232.35,97.75 v2(231.95,98.15)
  BOTTOM w0.089: UG6.B11 v2(250.4,95.55)
  BOTTOM w0.17: UG9.F27 v2(231.95,98.15)
FBC_D43: length 21.9
  IN5 w0.145: v2(250.4,93.95) 250,94.35 248.81,94.35 247.82,95.34 244.4,95.34 244.03,95.7 236.2,95.7 234.41,97.5 231.9,97.5 v2(231.25,98.15)
  BOTTOM w0.089: UG6.B13 250.8,94.35 v2(250.4,93.95)
  BOTTOM w0.178: UG9.G27 v2(231.25,98.15)
FBC_D44: length 22.4
  IN5 w0.145: v2(252.8,95.55) 252.4,95.95 252.4,96.97 250.22,99.15 243.82,99.15 243.07,98.39 240.77,98.39 240.7,98.33 238.87,98.33 v2(238,99.2)
  BOTTOM w0.089: UG6.E11 v2(252.8,95.55)
  BOTTOM w0.142: v2(238,99.2) 237.28,98.48 235.53,98.48 235.25,98.2 234.87,98.2 234.52,97.85 UG9.C27
FBC_D45: length 24.5
  IN5 w0.145: v2(253.6,93.95) UG6.E13 253.2,97.37 250.74,99.82 243.58,99.82 242.72,98.96 240.32,98.96 240.13,98.77 239.03,98.77 v2(238.6,99.2)
  BOTTOM w0.089: UG6.E13 253.2,94.35 v2(253.6,93.95)
  BOTTOM w0.142: v2(238.6,99.2) 237.6,98.2 235.6,98.2 235.25,97.85 UG9.B27
FBC_D46: length 23.3
  IN5 w0.145: v2(253.6,95.55) UG6.F11 254,97.5 250.98,100.52 243.42,100.52 242.44,99.54 240.08,99.54 v2(239.79,99.25)
  BOTTOM w0.089: UG6.F11 v2(253.6,95.55)
  BOTTOM w0.178: 239.12,98.52 v1(238.68,98.08) 238.45,97.85 UG9.A27
  BOTTOM w0.213: v2(239.79,99.25) 239.79,99.18 239.12,98.52
FBC_D47: length 28.5
  IN5 w0.145: v2(232.69,98.81) 233.2,99.32 235.45,99.32 236.12,98.65 237.6,98.65 238.37,97.88 243.38,97.88 243.95,98.45 249.81,98.45 251.6,96.67 251.6,95.28 251.72,95.15 252.25,95.15 252.39,95.02 252.39,93.76 252.74,93.42 253.86,93.42 v2(254.4,93.95)
  BOTTOM w0.089: UG6.F13 254,94.35 v2(254.4,93.95) ; v2(232.69,98.81) 232.6,98.89 232.14,98.89 231.78,99.25 UG9.G29
FBC_D48: length 44.6
  IN5 w0.145: v2(263.2,95.55) 263.21,95.56 263.96,95.56 264.6,94.92 264.6,91.47 260.53,87.4 247.06,87.4 246.05,88.42 243.38,88.42 241.34,90.46 235.19,90.46 234.88,90.77 233.67,90.77 233.49,90.95 231.35,90.95 230.8,91.5 230.8,92.25 230.55,92.5 v2(230.55,92.65)
  BOTTOM w0.089: v2(263.2,95.55) 263.2,95.55 UG6.U11
  BOTTOM w0.178: UG9.H20 v2(230.55,92.65)
FBC_D49: length 34.4
  IN5 w0.145: v2(233.95,91.85) 234.1,91.7 241.87,91.7 243.46,90.11 246.24,90.11 247.55,88.8 259.37,88.8 262.8,92.22 262.8,93.55 v2(263.2,93.95)
  BOTTOM w0.089: UG6.U13 v2(263.2,93.95)
  BOTTOM w0.178: UG9.D18 v2(233.95,91.85)
FBC_D50: length 41.3
  IN5 w0.145: v2(231.77,92.53) 231.88,92.53 232.25,92.16 232.25,91.75 232.64,91.36 233.67,91.36 233.82,91.21 235.12,91.21 235.25,91.08 241.6,91.08 243.39,89.29 246.12,89.29 247.32,88.1 260.28,88.1 263.61,91.43 263.61,92.83 263.59,92.85 263.59,94.91 263.35,95.15 262.8,95.15 v2(262.4,95.55)
  BOTTOM w0.089: UG6.T11 262.4,95.55 v2(262.4,95.55)
  BOTTOM w0.178: UG9.G20 231.77,92.73 v2(231.77,92.53)
FBC_D51: length 35.1
  IN5 w0.145: v2(233.08,92.4) 233.22,92.54 234.65,92.54 234.9,92.29 242.1,92.29 243.31,91.08 246.24,91.08 247.82,89.5 258.99,89.5 259.37,89.88 259.5,89.88 262,92.38 262,94.35 v2(262.4,94.75)
  BOTTOM w0.089: v2(262.4,94.75) 262,94.35 UG6.T13
  BOTTOM w0.178: UG9.E20 233.08,92.82 v2(233.08,92.4)
FBC_D52: length 36.3
  IN5 w0.145: v2(260,95.55) 260.4,95.15 260.4,91.61 259.24,90.45 247.82,90.45 246.49,91.78 243.45,91.78 242.37,92.86 234.87,92.86 234.7,93.03 232.93,93.03 232.22,93.74 232.22,94.22 v2(232.65,94.65)
  BOTTOM w0.089: UG6.N11 v2(260,95.55)
  BOTTOM w0.17: UG9.F23 v2(232.65,94.65)
FBC_D53: length 30.9
  IN5 w0.145: v2(233.25,93.95) 233.65,93.55 234.88,93.55 235,93.43 242.65,93.43 243.6,92.48 246.74,92.48 248.08,91.15 258.64,91.15 259.6,92.1 259.6,93.55 v2(259.2,93.95)
  BOTTOM w0.089: UG6.N13 259.59,94.35 v2(259.2,93.95)
  BOTTOM w0.178: UG9.E21 v2(233.25,93.95)
FBC_D54: length 31.1
  IN5 w0.145: v2(259.2,95.55) 258.8,95.15 258.8,92.38 258.26,91.85 248.33,91.85 247,93.18 243.82,93.18 243,94 235.38,94 234.74,94.64 234.24,94.64 233.95,94.35 v2(233.95,93.95)
  BOTTOM w0.089: UG6.M11 v2(259.2,95.55)
  BOTTOM w0.178: UG9.D21 v2(233.95,93.95)
FBC_D55: length 28
  IN5 w0.145: v2(233.21,94.65) 233.58,95.02 235,95.02 235.44,94.58 243.37,94.58 244.1,93.85 247.34,93.85 248.65,92.54 255.82,92.54 256.77,93.5 257.94,93.5 v2(258.4,93.95)
  BOTTOM w0.089: UG6.M13 258.8,94.35 v2(258.4,93.95)
  BOTTOM w0.17: v2(233.21,94.65) 233.21,94.79 UG9.E23
FBC_D56: length 38.3
  IN1 w0.145: v2(231.25,96.05) 232.12,95.18 235.92,95.18 237.43,93.67 241.79,93.67 241.81,93.69 247.13,93.69 249.38,95.95 254.72,95.95 254.8,96.02 256.69,96.02 258.59,97.92 260.71,97.92 262.88,100.09 262.88,101.47 v2(262.4,101.95)
  BOTTOM w0.089: v2(262.4,101.95) 262.8,101.55 UG6.U4
  BOTTOM w0.178: UG9.G24 v2(231.25,96.05)
FBC_D57: length 39.2
  IN1 w0.129: 234.92,98.22 234.44,97.74
  IN1 w0.145: 234.92,98.22 243.99,98.22 246.63,100.86 249.92,100.86 250.04,100.75 254.83,100.75 255.59,101.52 255.59,103.77 256,104.17 257.51,104.17 258.09,104.75 262.62,104.75 262.8,104.57 262.8,103.95 v2(262.4,103.55) ; v2(230.55,96.85) 231.44,97.74 234.44,97.74
  BOTTOM w0.089: UG6.U2 262.8,103.15 v2(262.4,103.55)
  BOTTOM w0.178: UG9.H26 v2(230.55,96.85)
FBC_D58: length 35.4
  IN1 w0.145: v2(231.95,96.05) 232.37,95.63 236.2,95.63 237.56,94.27 246.82,94.27 249.35,96.8 256.57,96.8 258.44,98.67 260.59,98.67 262.02,100.1 262.02,100.77 v2(262.4,101.15)
  BOTTOM w0.089: UG6.T4 262.4,101.15 v2(262.4,101.15)
  BOTTOM w0.17: UG9.F24 v2(231.95,96.05)
FBC_D59: length 34.8
  IN1 w0.145: v2(261.6,103.55) 261.2,103.95 258.15,103.95 257.43,103.23 256.68,103.23 256.43,102.97 256.43,102.94 256.41,102.92 256.41,101.29 255.88,100.76 255.54,100.76 254.91,100.13 246.83,100.13 244.38,97.67 234.86,97.67 234.64,97.45 232.45,97.45 v2(231.85,96.85)
  BOTTOM w0.089: v2(261.6,103.55) 262,103.15 UG6.T2
  BOTTOM w0.178: UG9.G26 v2(231.85,96.85)
FBC_D60: length 33.4
  IN1 w0.145: v2(259.2,101.95) 259.69,101.46 259.69,100.17 259.01,99.49 258.51,99.49 256.84,97.82 256.15,97.82 255.8,97.47 249.06,97.47 246.45,94.85 237.69,94.85 236.37,96.18 235.32,96.18 234.38,97.12 232.82,97.12 v2(232.55,96.85)
  BOTTOM w0.089: UG6.N4 259.6,101.55 v2(259.2,101.95)
  BOTTOM w0.17: UG9.F26 v2(232.55,96.85)
FBC_D61: length 31.4
  IN1 w0.145: v2(236.8,97.2) 236.8,97.09 238.4,95.49 240.29,95.49 240.3,95.48 245.17,95.48 247.7,98.01 255.45,98.01 255.87,98.43 256.4,98.43 257.99,100.02 257.99,100.44 258.23,100.68 258.65,100.68 258.8,100.82 258.8,102.35 v2(259.2,102.75)
  BOTTOM w0.142: UG9.D26 234,97.5 235.95,97.5 236.04,97.59 236.41,97.59 v2(236.8,97.2)
  BOTTOM w0.178: UG6.N2 259.2,102.75 v2(259.2,102.75)
FBC_D62: length 27.5
  IN1 w0.145: v2(237.55,97.2) 238.59,96.16 244.9,96.16 247.45,98.71 255.21,98.71 255.63,99.13 256.34,99.13 257.41,100.2 257.41,100.97 v2(258.4,101.95)
  BOTTOM w0.089: UG6.M4 258.8,101.55 v2(258.4,101.95)
  BOTTOM w0.142: UG9.B26 235.27,97.15 235.61,96.81 237.16,96.81 v2(237.55,97.2)
FBC_D63: length 29.7
  IN1 w0.145: v2(259.2,103.55) 258.8,103.16 258.12,103.16 257.2,102.24 257.2,101.41 256.87,101.08 256.87,100.68 256.26,100.07 255.64,100.07 254.93,99.36 247.02,99.36 244.4,96.74 239.21,96.74 v2(238.75,97.2)
  BOTTOM w0.142: UG9.C26 234.7,96.8 235.23,96.8 235.46,96.57 238.12,96.57 v2(238.75,97.2)
  BOTTOM w0.178: v2(259.2,103.55) 258.8,103.15 UG6.M2
FBC_DBI0: length 23.2
  IN2 w0.145: v2(252,75.11) 251.6,74.71 251.6,74.01 250.52,72.93 247.6,72.93 245.24,75.3 242.65,75.3 237.7,80.25 236.4,80.25 235.9,80.75 235.9,82 236.03,82.13 v2(236.09,82.13)
  BOTTOM w0.089: UG5.P2 252.39,75.51 v2(252,75.11)
  BOTTOM w0.178: UG9.A5 236.06,82.14 236.07,82.14 236.08,82.13 v2(236.09,82.13)
FBC_DBI1: length 22.1
  IN1 w0.089: 248.94,81.69 250.43,81.69 250.81,82.07 250.81,84.16 250.94,84.29 251.58,84.29 v2(252,84.71)
  IN1 w0.145: 248.94,81.69 246.36,81.69 245.79,82.26 240.77,82.26 238.68,84.35 236.43,84.35 236.3,84.22 234.64,84.22 v2(234.6,84.18)
  BOTTOM w0.089: UG5.P13 v2(252,84.71)
  BOTTOM w0.178: UG9.C8 234.6,84.3 v2(234.6,84.18)
FBC_DBI2: length 39.4
  IN2 w0.145: v2(260.8,83.91) 261.2,84.31 261.75,84.31 262.01,84.57 262.01,85.67 262.02,85.68 262.02,87.51 260.03,89.5 244.65,89.5 242.84,91.31 230.39,91.31 v2(229.85,91.85)
  BOTTOM w0.089: UG5.D13 260.4,84.31 v2(260.8,83.91)
  BOTTOM w0.178: UG9.J18 v2(229.85,91.85)
FBC_DBI3: length 40
  IN2 w0.145: v2(231.95,87.65) 232.34,87.26 235.56,87.26 236.14,87.85 242.49,87.85 243.12,87.21 257.73,87.21 258,86.94 258,81.48 260.41,79.07 260.41,76.32 v2(260,75.91)
  BOTTOM w0.089: UG5.D2 v2(260,75.91)
  BOTTOM w0.17: UG9.F12 v2(231.95,87.65)
FBC_DBI4: length 22
  IN2 w0.145: v2(242.24,102.2) 243.99,103.95 251.6,103.95 v2(252,103.55)
  BOTTOM w0.142: 239.02,99.72 238.94,99.64 235.94,99.64 235.9,99.6 234,99.6 UG9.D29
  BOTTOM w0.178: UG6.D2 v2(252,103.55)
  BOTTOM w0.213: 239.02,99.72 239.15,99.85 240.53,99.85 240.74,100.06 v1(241.07,100.06) 241.63,100.06 242.32,100.75 242.32,101.94 242.24,102.02 v2(242.24,102.2)
FBC_DBI5: length 23.6
  IN5 w0.089: v2(252,93.95) 251.63,94.32 251,94.32 250.81,94.51 250.81,96.67 250.71,96.77
  IN5 w0.145: v2(233.25,98.15) 233.97,98.87 235.2,98.87 235.99,98.09 237.18,98.09 237.64,97.63 239.91,97.63 240.21,97.33 243.78,97.33 244.14,97.69 249.79,97.69 250.71,96.77
  BOTTOM w0.089: v2(252,93.95) 252.39,94.35 UG6.D13
  BOTTOM w0.17: v2(233.25,98.15) UG9.E27
FBC_DBI6: length 36
  IN2 w0.145: v2(260.8,94.75) 261.19,94.36 261.76,94.36 262,94.12 262,91.85 260.35,90.19 247.57,90.19 245.23,92.54 233.64,92.54 233.36,92.82 232.72,92.82 v2(232.55,92.65)
  BOTTOM w0.089: v2(260.8,94.75) 260.4,94.35 UG6.P13
  BOTTOM w0.178: UG9.F20 v2(232.55,92.65)
FBC_DBI7: length 37
  IN2 w0.114: v2(260,103.55) 259.6,103.15 259.6,102.5 259.45,102.36 259.03,102.36 258.8,102.13 258.8,101.79 258.57,101.56 258.19,101.56 257.98,101.35 257.98,99.82 255.5,97.34 255.5,94.59 255.57,94.51 255.57,93.71 255.34,93.48 249.16,93.48
  IN2 w0.145: v2(234.09,96.69) 245.94,96.69 249.16,93.48
  BOTTOM w0.089: v2(260,103.55) 260.4,103.15 UG6.P2
  BOTTOM w0.102: UG9.E26 233.18,97.15 233.53,96.8 233.98,96.8 v2(234.09,96.69)
FBC_EDC0: length 24.5
  IN2 w0.145: v2(251.19,75.91) 250.8,75.51 250.8,74.04 250.54,73.78 247.53,73.78 245.47,75.85 243.8,75.85 238.6,81.05 237.6,81.05 236.95,81.7 236.95,81.85 236.19,82.61 233.81,82.61 v2(233.35,82.15)
  BOTTOM w0.089: UG5.R2 251.59,75.51 v2(251.19,75.91)
  BOTTOM w0.17: UG9.D5 v2(233.35,82.15)
FBC_EDC1: length 32.2
  IN2 w0.145: v2(251.2,83.91) 250.8,83.51 250.8,81.95 252.55,80.2 252.55,77.07 252.4,76.92 252.4,76.49 252.22,76.31 250,76.31 249.33,76.98 244.12,76.98 238.55,82.55 237.38,82.55 236.89,83.04 233.91,83.04 233.65,83.3 233.65,83.96 233.38,84.23 233.38,84.23 v2(233.35,84.25)
  BOTTOM w0.089: UG5.R13 v2(251.2,83.91)
  BOTTOM w0.178: UG9.D8 v2(233.35,84.25)
FBC_EDC2: length 33.6
  IN2 w0.145: v2(261.6,84.71) 261.19,85.12 260.63,85.12 260.39,85.36 260.39,85.69 260.2,85.88 260.2,88.53 259.99,88.74 243.76,88.74 241.85,90.64 233.34,90.64 v2(233.25,90.55)
  BOTTOM w0.089: v2(261.6,84.71) 261.2,84.31 UG5.C13
  BOTTOM w0.1: UG9.E17 v2(233.25,90.55)
FBC_EDC3: length 41.3
  IN2 w0.145: v2(233.25,87.65) 234.14,88.54 242.74,88.54 243.31,87.98 259.06,87.98 259.61,87.43 259.61,82.02 260,81.63 260,80.58 261.2,79.38 261.2,75.51 v2(260.8,75.11)
  BOTTOM w0.089: v2(260.8,75.11) 261.2,75.51 UG5.C2
  BOTTOM w0.17: UG9.E12 v2(233.25,87.65)
FBC_EDC4: length 20.6
  IN2 w0.145: v2(233.25,100.25) 233.64,99.86 234.56,99.86 235.48,100.78 242.08,100.78 244.45,103.15 250.8,103.15 v2(251.2,102.75)
  BOTTOM w0.178: UG9.E30 v2(233.25,100.25) ; UG6.C2 v2(251.2,102.75)
FBC_EDC5: length 20.5
  IN2 w0.145: v2(236.8,99.25) 237.46,98.59 250.16,98.59 250.79,97.96 250.79,95.16 v2(251.2,94.75)
  BOTTOM w0.089: UG6.C13 v2(251.2,94.75)
  BOTTOM w0.142: UG9.B29 235.2,99.25 235.6,98.85 236.4,98.85 v2(236.8,99.25)
FBC_EDC6: length 34.7
  IN2 w0.145: v2(261.6,93.95) 261.2,93.55 261.2,92.2 259.89,90.89 248.01,90.89 245.41,93.5 231.7,93.5 v2(231.25,93.95)
  BOTTOM w0.089: UG6.R13 v2(261.6,93.95)
  BOTTOM w0.178: UG9.G21 v2(231.25,93.95)
FBC_EDC7: length 37.2
  IN2 w0.114: 255.62,92.54 255.96,92.88 255.96,93.33 256.4,93.77 256.4,96.65 257.01,97.26 257.01,97.52 259.64,100.15 259.64,100.95 260.4,101.71 260.4,102.35 v2(260.8,102.75)
  IN2 w0.145: 255.62,92.54 248.98,92.54 245.8,95.71 233.75,95.71 233.36,96.1 v2(233.25,96.1)
  BOTTOM w0.089: UG6.R2 260.8,102.75 v2(260.8,102.75)
  BOTTOM w0.178: v2(233.25,96.1) 232.95,95.8 UG9.E24
FBC_WCK01: length 26.2
  IN2 w0.119: v2(252,76.71) 251.61,77.11 251.61,78.55 250.38,79.78 243.19,79.78 238.55,84.42 235.97,84.42 235.43,84.95 231.9,84.95 231.78,84.83 231.78,84.43 v2(231.95,84.25)
  BOTTOM w0.089: v2(252,76.71) 252.39,77.11 UG5.P4
  BOTTOM w0.119: UG9.F8 v2(231.95,84.25)
FBC_WCK01#: length 26.2
  IN2 w0.119: v2(231.39,84.1) 231.57,84.28 231.57,84.91 231.82,85.16 235.52,85.16 236.06,84.62 238.64,84.62 243.28,79.99 250.47,79.99 251.82,78.64 251.82,77.69 v2(252,77.51)
  BOTTOM w0.089: UG5.P5 v2(252,77.51)
  BOTTOM w0.119: v2(231.39,84.1) 231.55,84.26 UG9.G8
FBC_WCK23: length 37.3
  IN2 w0.119: v2(260.01,77.5) 259.97,77.5 259.38,78.09 259.38,78.81 257.3,80.89 257.3,84.15 255.31,86.13 242.21,86.13 241.56,86.78 230.77,86.78 230.55,87 v2(230.55,87.65)
  BOTTOM w0.089: UG5.D4 v2(260.01,77.5)
  BOTTOM w0.119: UG9.H12 v2(230.55,87.65)
FBC_WCK23#: length 37.2
  IN2 w0.119: v2(260,78.33) 259.77,78.11 259.66,78.11 259.59,78.17 259.59,78.9 257.51,80.98 257.51,84.23 255.4,86.34 242.29,86.34 241.65,86.99 230.86,86.99 230.76,87.09 230.76,87.3 231.11,87.65 v2(231.25,87.65)
  BOTTOM w0.089: UG5.D5 260.4,77.93 v2(260,78.33)
  BOTTOM w0.119: UG9.G12 v2(231.25,87.65)
FBC_WCK45: length 28.9
  IN2 w0.119: v2(229.85,98.15) 229.85,97.56 230.14,97.28 234.69,97.28 235.66,98.24 235.66,99.45 235.99,99.78 252.65,99.78 253.33,100.47 253.33,101.49 252.91,101.91 v2(252.83,101.91)
  BOTTOM w0.089: UG6.D4 252.75,101.91 v2(252.83,101.91)
  BOTTOM w0.119: UG9.J27 v2(229.85,98.15)
FBC_WCK45#: length 28.7
  IN2 w0.119: v2(252.69,101.14) 252.69,101.4 252.82,101.53 253,101.53 253.13,101.4 253.13,100.56 252.56,99.99 235.9,99.99 235.45,99.53 235.45,98.33 234.6,97.48 230.22,97.48 230.06,97.65 230.06,97.82 230.38,98.15 v2(230.55,98.15)
  BOTTOM w0.089: v2(252.69,101.14) 252.52,101.14 252.4,101.02 UG6.D5
  BOTTOM w0.119: v2(230.55,98.15) 230.55,97.98 230.68,97.85 UG9.H27
FBC_WCK67: length 39.9
  IN2 w0.119: v2(260.8,101.15) 260.8,101.11 261.25,100.65 261.25,99.19 260.85,98.8 259.31,98.8 257.6,97.09 257.6,93.77 256.09,92.26 256.09,92.24 255.51,91.66 248.59,91.66 245.6,94.64 233.97,94.64 233.28,95.34 231.88,95.34 231.67,95.13 231.67,94.93 v2(231.85,94.75)
  BOTTOM w0.089: v2(260.8,101.15) 260.8,101.15 UG6.P4
  BOTTOM w0.119: UG9.G23 v2(231.85,94.75)
FBC_WCK67#: length 39.9
  IN2 w0.119: v2(231.15,94.75) 231.31,94.75 231.46,94.9 231.46,95.21 231.8,95.55 233.36,95.55 234.06,94.85 245.69,94.85 248.67,91.86 255.42,91.86 255.89,92.33 255.89,92.35 257.4,93.86 257.4,97.18 259.22,99.01 260.77,99.01 261.04,99.28 261.04,100.57 260.93,100.67 260.77,100.67 260.65,100.55 v2(260.65,100.33)
  BOTTOM w0.089: v2(260.65,100.33) 260.65,100.5 UG6.P5
  BOTTOM w0.119: UG9.H23 v2(231.15,94.75)
FBCAL_GND: length 1.2
  TOP w0.089: v2(226.95,109.45) 226.45,109.95 RG68.1
  BOTTOM w0.114: UG9.P44 v2(226.95,109.45)
FBCAL_TERM: length 2.4
  TOP w0.1: RG69.1 226.03,111.56 226.03,110.53 v2(225.65,110.15)
  BOTTOM w0.114: UG9.R45 v2(225.65,110.15)
FBCAL_VDDQ: length 1.2
  TOP w0.089: v2(225.65,109.45) 226.04,109.45 RG67.1
  BOTTOM w0.114: UG9.R44 v2(225.65,109.45)
FBRTN: length 79.7
  TOP w0.14: PC6002.1 153.06,136.66 v2(152.35,135.94)
  TOP w0.203: PU6000.32 156.94,135.15 156.62,134.83 v2(156.25,134.83)
  TOP w0.254: v2(164.26,136.81) 164.87,136.81 v1(165.02,136.66) 165.28,136.4 PC6015.2 PR6062.2
  IN1 w0.254: v2(190.41,105.57) 192.71,105.57 195.14,107.99 195.14,109.25 v2(195.7,109.82) ; v2(156.25,134.83) 155.34,134.83 155.17,134.66 154.18,134.66 152.9,135.94 v2(152.35,135.94)
  IN2 w0.254: v2(190.41,105.57) 190.22,105.57 190.19,105.59 189.79,105.59 189.77,105.57 189.33,105.57 188.69,104.92 184.32,104.92 181.14,108.1 181.14,115.66 179.86,116.94 175.6,116.94 172.82,119.73 172.82,122.79 170.45,125.17 170.45,125.91 170.38,125.97 170.38,128.58 168.59,130.37 167.02,130.37 162.98,134.41 162.98,135.98 163.81,136.81 v2(164.26,136.81)
  BOTTOM w0.254: PR6026.1 196.68,110.26 196.24,109.82 v2(195.7,109.82) 195.31,109.82 PR6030.1 ; v2(164.26,136.81) 163.3,136.81 161.89,135.4 156.82,135.4 v2(156.25,134.83)
FBVDD/Q_EN: length 63
  TOP w0.14: v1(231.86,55.65) 232.21,56 v2(232.73,56)
  TOP w0.254: PR803.1 232.89,55.84 v2(232.73,56) ; UG27.4 209.57,78.21 209.32,78.46 RG557.1 208.57,78.51 v2(208.1,78.99)
  IN5 w0.254: v2(208.1,78.99) 208.1,78.61 208.7,78.01 211.3,78.01 212,78.7 213.79,78.7 214.42,78.08 234.21,78.08 236.83,75.47 v2(236.83,74.39)
  BOTTOM w0.254: QG513.2 241.97,74.12 241.72,73.88 240.51,73.88 240.01,74.39 v2(236.83,74.39) 236.77,74.33 236.77,62.91 234.1,60.24 234.1,56.48 233.62,56 v2(232.73,56)
FCCM_GT: length 40.5
  TOP w0.203: v2(133.4,135.75) 133.4,136.01 134.33,136.93 PU5000.11
  IN1 w0.254: v2(114.59,117.63) 114.11,118.11 114.11,125.86 v2(114.87,126.62)
  IN2 w0.254: v2(133.4,135.75) 133.21,135.94 132.75,135.94 132.32,136.37 129.82,136.37 129.37,136.82 123.88,136.82 123.17,136.11 120.49,136.11 116.05,131.67 116.05,127.47 115.2,126.62 v2(114.87,126.62)
  BOTTOM w0.127: v1(114.12,125.61) 114.12,125.88 v2(114.87,126.62)
  BOTTOM w0.254: v2(114.59,117.63) 114.95,117.99 PR5204.1
  BOTTOM w0.305: PR5215.1 115.53,126.09 115,126.62 v2(114.87,126.62)
FCCM_SA: length 35
  TOP w0.203: PU5000.34 141.38,140.13 141.85,140.6 142,140.6 142.26,140.87 v2(142.26,141.59)
  TOP w0.254: PR5223.1 v2(163.17,130.58)
  IN4 w0.254: v2(142.26,141.59) 143.45,142.78 150.66,142.78 152.06,141.38 160.31,141.38 162.24,139.45 162.24,131.19 162.85,130.58 v2(163.17,130.58)
  BOTTOM w0.14: v2(142.26,141.59) v1(142.26,142.33)
FCCM_VCORE: length 29.8
  TOP w0.14: v1(157.07,131.17) 156.78,130.88 v2(156.57,130.88)
  TOP w0.203: PU5000.24 140.07,135.39 140.28,135.19 v2(140.76,135.19)
  IN1 w0.254: v2(141.07,131.16) 141.07,134.5 140.82,134.75 140.82,135.12 v2(140.76,135.19) 140.63,135.32 140.63,136.08 140.96,136.41 141.42,136.41 141.69,136.13 141.69,135.77 141.95,135.51 142.16,135.51 143.1,134.57 145.14,134.57 147.37,132.34 149.16,132.34 150.03,131.47 v2(150.03,131.28)
  IN2 w0.254: v2(156.57,130.88) 155.84,130.88 155.49,130.52 153.9,130.52 153.14,131.28 v2(150.03,131.28)
  BOTTOM w0.254: PR5129.1 158.48,130.79 158.04,131.23 157.15,131.23 156.8,130.88 v2(156.57,130.88) ; PR5104.1 150.29,131.03 150.03,131.28 v2(150.03,131.28) ; v2(141.07,131.16) 140.95,131.03 PR5117.1
FFS_INT1: length 45.8
  TOP w0.14: U5603.12 266.42,9.93 266.74,10.29 RS40.2 266.74,12 v2(266.74,12) 266.74,12.56 v4(266.26,13.05)
  IN2 w0.097: v2(283.76,32.09) 283.76,29.11 283.68,29.04 283.68,27.06 281.08,24.46 281.08,11.46 277.17,7.55 273.18,7.55 v2(272.05,8.69)
  IN5 w0.097: v2(272.05,8.69) 272.05,9.8 270.96,10.9 267.84,10.9 v2(266.74,12)
  BOTTOM w0.076: UH2.BC27 283.76,31.55 v2(283.76,32.09)
FFS_INT2: length 59.9
  TOP w0.14: v4(268.21,13.24) v2(267.61,12.64) RS41.2 267.61,10.04 266.92,9.35 U5603.11
  IN1 w0.097: v2(254.57,21.3) 254.57,21.26 254.92,20.91 256.6,20.91 264.4,13.11 267.13,13.11 v2(267.61,12.64)
  IN2 w0.097: v2(277.58,35.76) 277.07,35.24 277.07,33.68 277.62,33.13 277.62,32.45 277.89,32.19 277.89,31.37 277.38,30.86 276.98,30.86 276.14,30.03 v2(276.14,28.93)
  BOTTOM w0.076: v2(276.14,28.93) 276.14,28.87 275.75,28.48 ; UH2.AN41 277.48,36.04 277.58,35.78 v2(277.58,35.76)
  BOTTOM w0.14: 275.75,28.48 275.72,28.45 271.99,28.45 271.57,28.87 268.4,28.87 265.53,26 262.61,26 261.75,25.14 258.2,25.14 257.02,23.97 257.02,22.04 255.87,20.89 254.99,20.89 v2(254.57,21.3) 254.57,21.54 254.77,21.74 255,21.74 255.31,22.05 255.31,23.23
FFS_INT2_Q: length 15.9
  BOTTOM w0.14: JHDD1.9 244.6,27.56 244.46,27.42 244.46,26.29 244.84,25.91 244.84,23.82 v2(245.18,23.48) 245.74,22.93 252.71,22.93 253.01,23.23 QC5.6 254.66,22.25 RS1.2
FPR_SCAN#: length 124.4
  TOP w0.14: v2(259.32,16.55) 259.39,16.49 268.62,16.49 271.63,13.48 v2(271.63,9.25) ; v2(304.71,9.2) 304.4,8.88 UE1.42 304.4,6.37 304.59,6.18 v2(304.59,5.79) v4(304.59,5.1)
  IN1 w0.097: v2(223.69,23.75) 225.05,25.11 236.56,25.11 239.87,21.8 251.86,21.8 253.13,20.54 256.69,20.54 259.32,17.91 v2(259.32,16.55) ; v2(304.59,5.79) 303.77,4.97 301.91,4.97 300.3,6.57 295.07,6.57 294.24,7.4 286.39,7.4 285.78,8.01 278.43,8.01 276.94,9.49 271.87,9.49 v2(271.63,9.25) ; v2(212.99,23.72) 213.4,24.13 220.4,24.13 v2(220.78,23.75)
  BOTTOM w0.14: v2(220.78,23.75) 220.78,27.07 221.79,28.08 D5223.3 223.08,28.08 223.69,27.46 v2(223.69,23.75) ; RE143.1 303.32,10.3 304.33,10.3 304.71,9.92 v2(304.71,9.2) ; v2(212.99,23.72) 212.99,26.16 213.15,26.32 JPW.10
FRAME_LOCK#: length 3.3
  BOTTOM w0.089: 203.18,78.89 203.18,80.1 203.42,80.35 UG9.BG2
  BOTTOM w0.14: RG502.1 203.18,77.54 203.18,78.89
FSW_GPU_R: length 2.2
  TOP w0.14: PR6038.2 164.36,138.56 v1(165.1,139.3)
  TOP w0.254: PR6038.2 163.55,138.27 PR6035.2
GC6_EVENT#_D: length 4.7
  BOTTOM w0.089: 206.13,78.89 205.65,79.37 UG9.BD1
  BOTTOM w0.14: DG2.2 205.6,76.5 205.74,76.64 RG164.1 206.49,77.09 v1(206.92,77.52) 206.92,78.1 206.13,78.89
GC6_THM_DIS#: length 34.6
  TOP w0.14: v2(297.85,12.69) 297.96,12.59 UE1.23
  IN5 w0.097: v2(285.58,29.96) 285.58,28.32 284.31,27.05 284.31,25.56 284.25,25.49 284.25,24.54 284.02,24.31 284.02,23.06 284.4,22.69 285.61,22.69 285.86,22.43 288.04,22.43 288.08,22.47 288.84,22.47 293.09,22.47 294.5,21.06 294.5,17.55 296.15,15.91 297.37,15.91 298.06,15.22 298.06,12.89 v2(297.85,12.69)
  BOTTOM w0.076: 286.04,28.48 285.58,28.94 v2(285.58,29.96) 285.58,30.78 UH2.BD24
  BOTTOM w0.14: RH573.1 286.08,28.44 286.04,28.48
GPIO3_OC_WARN#: length 33.1
  TOP w0.089: v2(208.26,82.26) 207.67,82.26 207.37,81.96 RG522.1
  IN1 w0.089: 209.27,78.19 209.27,80.95 208.26,81.96 v2(208.26,82.26)
  IN1 w0.097: 209.27,78.19 209.27,74.16 210.19,73.24 210.69,73.24 211.32,72.61 221.47,72.61 222.1,73.24 222.1,75.62 v2(222.83,76.35)
  BOTTOM w0.114: UG9.BB4 207.05,81.81 207.37,82.13 208.13,82.13 v2(208.26,82.26)
  BOTTOM w0.127: v1(220.37,76.91) 220.57,77.12 RG529.2
  BOTTOM w0.14: UG11.8 223.67,75.29 223.37,75.59 223.37,75.81 v2(222.83,76.35) 222.76,76.42 222.38,76.42 221.74,77.05 RG529.2
GPU_B+: length 385.6
  TOP w2.032: 95.4,34.47 94.03,34.47 93.4,35.11 88.41,35.11 87.06,33.76 86.25,33.76 83,30.51 83,29.01 85.31,26.7 98.27,26.7 99.29,25.68 116.69,25.68 121.01,30 139.93,30 143.36,26.57 156.16,26.57 156.33,26.74 163.2,26.74 164.25,25.68 184.06,25.68 185.52,27.14 230.62,27.14 232.54,29.06 239.14,29.06 240.53,30.44 241.91,30.44 243.14,31.68 245.35,31.68
  IN2 w1.016: 246.8,32.41 247.55,31.66 251.45,31.66 253.91,34.13 256.13,34.13 261.34,39.33 261.34,57.18 258.42,60.1 245.15,60.1
  IN4 w2.032: 96.11,37.3 97.07,38.26 97.07,69.92 97.93,70.78 97.93,72.63 99.04,73.74 103.85,73.74 105.23,75.12 105.23,77.63 107.8,80.2 107.8,82.77 109.83,84.8 110.71,84.8 110.88,84.98 111.99,84.98 114.99,87.98 114.99,92.1 116.79,93.9 116.79,96.4 118.07,97.68 120.52,97.68 121.71,98.86 121.71,107.09 119.99,108.8 118.85,108.8
  IN5 w1.016: 246.04,34.51 246.38,34.17 249.66,34.17 251.08,35.59 256.31,35.59 261.34,40.62 261.34,60.99 259.12,63.21 245.34,63.21 244.26,62.13
  vias: v2(95,35.84) v2(95.58,35.84) v2(96.17,35.84) v2(96.75,35.84) v2(116.28,110.34) v2(116.92,110.34) v2(117.55,110.34) v2(118.19,110.34) v2(242.99,61.12) v2(243.63,61.12) v2(244.26,61.12) v2(244.9,61.12) v2(245.33,33.29) v2(245.53,61.12) v2(245.91,33.29) v2(246.5,33.29) v2(247.08,33.29) v4(246.91,31.54)
GPU_BUFRST#: length 1
  TOP w0.114: v2(203.95,85.55) 204.26,85.86 T6.1
  BOTTOM w0.114: UG9.BF9 v2(203.95,85.55)
GPU_EVENT#: length 112.6
  IN3 w0.124: v2(205.28,75.76) 205.28,75.45 205.43,75.3 206.89,75.3 206.9,75.31 207.41,75.31 207.55,75.18 209.79,75.18 209.96,75.01 210.7,75.01 213.24,72.47 217.18,72.47 221.17,68.48 222.11,68.48 223.48,67.11 228.3,67.11 230.36,65.05 235.65,65.05 236.05,64.64 265.53,64.64 270.97,59.21 270.97,52.73 271.46,52.24 271.46,45.94 271.78,45.61 271.78,40.93 271.46,40.6 271.46,38.46 272.71,37.21 272.71,36.37 273.17,35.9 273.83,35.9 274.02,36.09 274.97,36.09 275.73,35.33 278.02,35.33 278.07,35.28 278.39,35.28 279,35.89 281.04,35.89 281.52,36.38 283.01,36.38 283.39,35.99 284.22,35.99 v2(284.8,35.42)
  BOTTOM w0.089: UH2.AR24 284.88,35.34 v2(284.8,35.42)
  BOTTOM w0.127: DG2.1 205.6,74.22 v1(205.44,74.06)
  BOTTOM w0.14: v2(205.28,75.76) 205.28,75.64 205.6,75.33 DG2.1
