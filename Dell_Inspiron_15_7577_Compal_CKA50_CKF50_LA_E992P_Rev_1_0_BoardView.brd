# Allegro board Dell_Inspiron_15_7577_Compal_CKA50_CKF50_LA_E992P_Rev_1_0_BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_D41: length 98.6
  IN1 w0.076: v2(174.45,75.16) 174.45,74.42 175.63,73.24 175.63,71.4 175.84,71.19
  IN1 w0.097: 175.84,71.19 176.26,70.77 176.26,64.29 191.76,48.8 197.04,48.8 197.16,48.68 197.16,48.38 197.25,48.29 197.45,48.29 197.54,48.38 197.54,48.68 197.66,48.8 197.82,48.8 197.93,48.68 197.93,48.04 198.04,47.92 198.2,47.92 198.31,48.04 198.31,48.68 198.43,48.8 198.59,48.8 198.7,48.68 198.7,48.04 198.81,47.92 198.97,47.92 199.09,48.04 199.09,48.68 199.2,48.8 199.36,48.8 199.47,48.68 199.47,48.04 199.59,47.92 199.75,47.92 199.86,48.04 199.86,48.68 199.97,48.8 200.13,48.8 200.24,48.68 200.24,48.04 200.36,47.92 200.52,47.92 200.63,48.04 200.63,48.68 200.74,48.8 200.9,48.8 201.02,48.68 201.02,48.04 201.13,47.92 201.29,47.92 201.4,48.04 201.4,48.68 201.52,48.8 201.68,48.8 201.79,48.68 201.79,48.04 201.9,47.92 202.06,47.92 202.18,48.04 202.18,48.68 202.29,48.8 203.37,48.8 204.19,47.97 221.04,47.97 221.45,48.38 226.42,48.38 226.83,47.97 226.83,47.97 230.46,44.34 230.46,42.36 230.23,42.13 230.23,37.78 v2(230.95,37.06)
  BOTTOM w0.076: v2(174.45,75.16) 174.45,76.13 173.78,76.79 173.78,77.06 173.2,77.65 173.2,77.8 173.09,77.92 UH1.M1
  BOTTOM w0.14: v2(230.95,37.06) 230.44,37.06 229.58,36.19 JDIMM2.194
DDR_B_D42: length 98.5
  IN1 w0.076: v2(174.27,79.81) 174.52,79.56 175.15,79.56 176.65,78.06
  IN1 w0.097: v2(234.25,38.52) 234.25,38.57 234.68,39 234.68,45.08 229.34,50.41 229.34,50.91 227.52,52.73 202.03,52.73 201.49,52.19 201.49,52.06 201.38,51.94 201.21,51.94 201.1,52.06 201.1,52.62 200.99,52.73 200.83,52.73 200.72,52.62 200.72,52.06 200.6,51.94 200.44,51.94 200.33,52.06 200.33,52.62 200.22,52.73 200.06,52.73 199.94,52.62 199.94,52.06 199.83,51.94 199.67,51.94 199.56,52.06 199.56,52.62 199.44,52.73 199.28,52.73 199.17,52.62 199.17,52.06 199.06,51.94 198.9,51.94 198.79,52.06 198.79,52.38 198.69,52.48 198.5,52.48 198.4,52.38 198.4,52.06 198.29,51.94 194.16,51.94 179.41,66.69 179.41,74.16 176.65,76.93
  IN1 w0.102: 176.65,76.93 176.65,78.06
  BOTTOM w0.076: UH1.L4 v2(174.27,79.81)
  BOTTOM w0.14: v2(234.25,38.52) 234.76,39.03 234.76,39.94 234.09,40.62 233.69,40.62 232.83,41.48 JDIMM2.207
DDR_B_D43: length 97.8
  IN1 w0.097: v2(234.23,37.25) 234.23,37.3 233.85,37.68 233.85,40.32 233.92,40.39 233.92,44.98 229.03,49.88 228.52,49.88 227.06,51.34 227.02,51.39 226.43,51.98 213.57,51.98 213.48,51.88 213.48,51.45 213.37,51.34 213.17,51.34 213.06,51.46 213.06,51.88 212.94,51.99 212.78,51.99 212.67,51.88 212.67,51.46 212.56,51.34 212.4,51.34 212.28,51.46 212.28,51.88 212.17,51.99 212.01,51.99 211.9,51.88 211.9,51.46 211.78,51.34 211.62,51.34 211.51,51.46 211.51,51.88 211.4,51.99 211.24,51.99 211.13,51.88 211.13,51.46 211.01,51.34 210.85,51.34 210.74,51.46 210.74,51.88 210.63,51.99 210.47,51.99 210.35,51.88 210.35,51.46 210.24,51.34 210.08,51.34 209.97,51.46 209.97,51.88 209.85,51.99 209.69,51.99 209.58,51.88 209.58,51.46 209.47,51.34 209.31,51.34 209.19,51.46 209.19,51.88 209.08,51.99 208.92,51.99 208.81,51.88 208.81,51.46 208.7,51.34 208.54,51.34 208.42,51.46 208.42,51.88 208.31,51.99 208.15,51.99 208.04,51.88 208.04,51.46 207.92,51.34 193.91,51.34 178.81,66.44 178.81,73.86 174.61,78.06
  IN1 w0.102: 174.61,78.06 174.61,78.3 174.46,78.45 v2(174.27,78.45)
  BOTTOM w0.076: UH1.L2 v2(174.27,78.45)
  BOTTOM w0.14: JDIMM2.208 233.07,35.96 233.31,36.2 233.31,36.88 233.68,37.25 v2(234.23,37.25)
DDR_B_D44: length 98.5
  IN1 w0.076: v2(172.65,76.96) 174.08,76.96 175.62,75.42 175.65,75.42
  IN1 w0.097: 175.65,75.42 177.16,73.91 177.16,65.76 193.23,49.7 205.29,49.7 205.41,49.58 205.41,49.46 205.5,49.37 205.7,49.37 205.79,49.46 205.79,49.58 205.9,49.7 206.06,49.7 206.18,49.58 206.18,48.98 206.29,48.87 206.45,48.87 206.56,48.98 206.56,49.58 206.68,49.7 206.84,49.7 206.95,49.58 206.95,48.98 207.06,48.87 207.22,48.87 207.34,48.98 207.34,49.58 207.45,49.7 207.61,49.7 207.72,49.58 207.72,48.98 207.84,48.87 208,48.87 208.11,48.98 208.11,49.58 208.22,49.7 208.38,49.7 208.49,49.58 208.49,48.98 208.61,48.87 208.77,48.87 208.88,48.98 208.88,49.58 208.99,49.7 226.38,49.7 226.39,49.69 231.9,44.17 231.9,39.3 v2(230.94,38.33)
  BOTTOM w0.076: v2(172.65,76.96) 172.65,77.52 172.48,77.69 172.48,79.54 UH1.M5
  BOTTOM w0.14: v2(230.94,38.33) 230.78,38.33 230.04,37.6 230.04,37.14 228.58,35.68 JDIMM2.190
DDR_B_D45: length 98.4
  IN1 w0.076: v2(174,75.61) 174.73,75.61 176.56,73.78 176.56,72.47
  IN1 w0.097: 176.56,72.47 176.56,64.42 191.89,49.1 203.49,49.1 204.32,48.27 213.74,48.27 213.85,48.38 213.85,48.98 213.96,49.1 214.12,49.1 214.24,48.98 214.24,48.38 214.35,48.27 214.51,48.27 214.62,48.38 214.62,48.98 214.74,49.1 214.9,49.1 215.01,48.98 215.01,48.38 215.12,48.27 215.28,48.27 215.39,48.38 215.39,48.98 215.51,49.1 215.67,49.1 215.78,48.98 215.78,48.38 215.89,48.27 216.05,48.27 216.17,48.38 216.17,48.98 216.28,49.1 216.44,49.1 216.55,48.98 216.55,48.38 216.67,48.27 216.83,48.27 216.94,48.38 216.94,48.98 217.05,49.1 217.21,49.1 217.32,48.98 217.32,48.38 217.44,48.27 217.6,48.27 217.71,48.38 217.71,48.98 217.82,49.1 217.98,49.1 218.1,48.98 218.1,48.38 218.21,48.27 218.37,48.27 218.48,48.38 218.48,48.98 218.6,49.1 218.76,49.1 218.87,48.98 218.87,48.38 218.98,48.27 219.14,48.27 219.26,48.38 219.26,48.98 219.37,49.1 219.53,49.1 219.64,48.98 219.64,48.38 219.75,48.27 219.91,48.27 220.03,48.38 220.03,48.98 220.14,49.1 220.3,49.1 220.41,48.98 220.41,48.38 220.53,48.27 220.91,48.27 221.33,48.68 226.54,48.68 226.96,48.27 226.96,48.27 227.64,47.59 231.29,43.93 231.29,41.23 v2(230.94,40.87)
  BOTTOM w0.076: UH1.M2 172.81,78.56 172.81,77.9 173.01,77.7 173.01,77.53 173.5,77.04 173.5,76.7 174,76.2 v2(174,75.61)
  BOTTOM w0.14: JDIMM2.195 229.83,41.69 230.64,40.87 v2(230.94,40.87)
DDR_B_D46: length 98.3
  IN1 w0.076: 176.89,78.26 174.69,80.46 v2(174.27,80.46)
  IN1 w0.097: 176.89,78.26 176.89,77 177.5,76.39 177.67,76.39 179.71,74.34 179.71,66.82 193.41,53.11 197.41,53.11 197.53,53 197.53,52.66 197.64,52.54 197.8,52.54 197.91,52.66 197.91,52.92 198.03,53.03 227.65,53.03 229.64,51.04 229.64,50.54 234.98,45.2 234.98,40.03 235.86,39.14 235.86,35.89 235.54,35.56 232.67,35.56 232.36,35.87 v2(232.36,36.58)
  BOTTOM w0.076: UH1.L5 v2(174.27,80.46)
  BOTTOM w0.14: v2(232.36,36.58) 232.52,36.42 232.52,36.22 232.07,35.78 JDIMM2.204
DDR_B_D47: length 98.6
  IN1 w0.076: v2(174.27,77.86) 173.91,78.22 173.91,78.59 174.16,78.84 175.27,78.84 175.55,78.56
  IN1 w0.097: 175.55,77.54 179.11,73.98 179.11,66.57 194.04,51.64 201.84,51.64 201.95,51.76 201.95,52.18 202.07,52.29 202.23,52.29 202.34,52.18 202.34,51.76 202.45,51.64 202.61,51.64 202.73,51.76 202.73,52.18 202.84,52.29 203,52.29 203.11,52.18 203.11,51.76 203.23,51.64 203.39,51.64 203.5,51.76 203.5,52.18 203.61,52.29 203.77,52.29 203.88,52.18 203.88,51.76 204,51.64 204.22,51.64 204.33,51.76 204.33,52.18 204.45,52.29 204.61,52.29 204.72,52.18 204.72,51.76 204.83,51.64 204.99,51.64 205.11,51.76 205.11,52.18 205.22,52.29 205.38,52.29 205.49,52.18 205.49,51.76 205.61,51.64 205.77,51.64 205.88,51.76 205.88,52.18 205.99,52.29 206.15,52.29 206.26,52.18 206.26,51.76 206.38,51.64 206.54,51.64 206.65,51.76 206.65,52.18 206.76,52.29 206.92,52.29 207.04,52.18 207.04,51.76 207.15,51.64 207.31,51.64 207.42,51.76 207.42,52.18 207.54,52.29 226.54,52.29 228.65,50.18 229.15,50.18 234.25,45.08 v2(234.25,39.79)
  IN1 w0.102: 175.55,77.54 175.55,78.56
  BOTTOM w0.076: UH1.L1 v2(174.27,77.86)
  BOTTOM w0.14: JDIMM2.203 231.83,41.74 232.3,41.26 232.3,41.02 233.52,39.8 234.25,39.8 v2(234.25,39.79)
DDR_B_D48: length 104.9
  IN2 w0.076: v2(170.78,85.02) 170.25,84.49 170.25,82.98 170.09,82.83 170.09,78.04 170.09,77.67 173.78,73.98 173.78,72.53
  IN2 w0.097: v2(235.27,37.79) 235.07,37.79 234.77,38.1 234.77,39.87 234.26,40.38 233.1,40.38 232.56,40.38 231.05,41.88 227.17,41.88 226.72,41.43 211.17,41.43 211.05,41.32 211.05,41.04 210.94,40.92 210.78,40.92 210.67,41.04 210.67,41.32 210.56,41.43 210.33,41.43 210.22,41.32 210.22,41.04 210.11,40.92 209.95,40.92 209.83,41.04 209.83,41.32 209.72,41.43 209.56,41.43 209.45,41.32 209.45,41.04 209.33,40.92 209.17,40.92 209.06,41.04 209.06,41.32 208.95,41.43 208.79,41.43 208.67,41.32 208.67,41.04 208.56,40.92 208.4,40.92 208.29,41.04 208.29,41.32 208.18,41.43 208.02,41.43 207.9,41.32 207.9,41.04 207.79,40.92 207.63,40.92 207.52,41.04 207.52,41.32 207.4,41.43 206.89,41.43 197.63,50.69 186.05,50.69 173.78,62.97 173.78,72.53
  BOTTOM w0.076: UH1.R11 v2(170.78,85.02)
  BOTTOM w0.14: v2(235.27,37.79) 234.81,37.34 234.81,35.89 235.07,35.63 JDIMM2.216
DDR_B_D49: length 105
  IN2 w0.076: v2(171.69,85.02) 172.23,84.49 172.23,83.14 172.6,82.77 172.6,81.85 172.61,81.84 172.61,78.52 175.4,75.72 175.73,75.72 176.19,75.72 176.63,75.28
  IN2 w0.097: v2(238.18,36.99) 238.34,36.99 240.35,39.01 240.35,41.62 240.35,41.62 240.35,41.87 239.39,42.83 237.46,42.83 235.62,44.67 234.89,44.67 233.24,46.32 210.65,46.32 209.9,47.06 206.26,47.06 199.19,54.14 188.11,54.14 187.74,54.51 187.11,54.51 177.46,64.16 177.46,64.8 177.46,64.8 177.46,65.4 177.46,65.4 177.46,74.45 176.63,75.28
  BOTTOM w0.076: UH1.P11 v2(171.69,85.02)
  BOTTOM w0.14: JDIMM2.228 238.07,35.45 238.32,35.69 238.32,35.86 238.68,36.22 238.68,36.49 v2(238.18,36.99)
DDR_B_D50: length 104.6
  IN2 w0.076: v2(171.66,82.46) 172.09,82.03 172.09,81.27 172.11,81.25 172.11,78.24 175.85,74.49
  IN2 w0.097: 175.85,74.49 176.5,73.84 176.5,63.84 187.1,53.24 198.81,53.24 206.69,45.37 214.75,45.37 214.86,45.25 214.86,44.94 214.98,44.82 215.14,44.82 215.25,44.94 215.25,45.25 215.36,45.37 215.52,45.37 215.64,45.25 215.64,44.94 215.75,44.82 215.91,44.82 216.02,44.94 216.02,45.25 216.14,45.37 216.3,45.37 216.41,45.25 216.41,44.94 216.52,44.82 216.68,44.82 216.8,44.94 216.8,45.25 216.91,45.37 218.83,45.37 218.94,45.25 218.94,44.78 219.06,44.67 219.22,44.67 219.33,44.78 219.33,45.25 219.44,45.37 219.6,45.37 219.72,45.25 219.72,44.78 219.83,44.67 219.99,44.67 220.1,44.78 220.1,45.25 220.22,45.37 220.38,45.37 220.49,45.25 220.49,44.78 220.6,44.67 220.76,44.67 220.88,44.78 220.88,45.25 220.99,45.37 221.15,45.37 221.26,45.25 221.26,44.78 221.37,44.67 221.53,44.67 221.65,44.78 221.65,45.25 221.76,45.37 224.94,45.37 225.05,45.25 225.05,44.91 225.17,44.8 225.33,44.8 225.44,44.91 225.44,45.25 225.55,45.37 225.95,45.37 226.06,45.25 226.06,45.08 226.16,44.99 226.35,44.99 226.45,45.08 226.45,45.25 226.56,45.37 232.92,45.37 236.35,41.94 238,41.94 239.16,40.78 v2(239.34,40.78)
  BOTTOM w0.076: UH1.P7 v2(171.66,82.46)
  BOTTOM w0.14: v2(239.34,40.78) 239.26,40.78 238.32,41.71 JDIMM2.229
DDR_B_D51: length 105.1
  IN2 w0.076: v2(170.78,83.07) 170.78,82.94 170.42,82.59 170.42,77.8 174.19,74.03 174.19,73.19 174.28,73.1
  IN2 w0.097: 174.28,73.1 174.37,73 174.37,63.22 186.3,51.29 197.87,51.29 206.68,42.48 207.54,42.48 210.92,42.48 211.04,42.37 211.04,42.11 211.12,42.03 211.34,42.03 211.42,42.11 211.42,42.37 211.53,42.48 211.78,42.48 211.9,42.37 211.9,42.14 212.01,42.03 212.17,42.03 212.28,42.14 212.28,42.37 212.39,42.48 212.55,42.48 212.67,42.37 212.67,42.14 212.78,42.03 212.94,42.03 213.05,42.14 213.05,42.37 213.17,42.48 213.33,42.48 213.44,42.37 213.44,42.14 213.55,42.03 213.71,42.03 213.83,42.14 213.83,42.37 213.94,42.48 214.1,42.48 214.21,42.37 214.21,42.14 214.33,42.03 214.49,42.03 214.6,42.14 214.6,42.37 214.71,42.48 214.97,42.48 215.08,42.37 215.08,42.14 215.19,42.03 215.35,42.03 215.47,42.14 215.47,42.37 215.58,42.48 215.74,42.48 215.85,42.37 215.85,42.14 215.97,42.03 216.13,42.03 216.24,42.14 216.24,42.37 216.35,42.48 216.51,42.48 216.62,42.37 216.62,42.14 216.74,42.03 216.9,42.03 217.01,42.14 217.01,42.37 217.12,42.48 217.28,42.48 217.4,42.37 217.4,42.14 217.51,42.03 217.67,42.03 217.78,42.14 217.78,42.37 217.9,42.48 218.06,42.48 218.17,42.37 218.17,42.14 218.28,42.03 218.44,42.03 218.56,42.14 218.56,42.37 218.67,42.48 218.83,42.48 218.94,42.37 218.94,42.14 219.05,42.03 219.21,42.03 219.33,42.14 219.33,42.37 219.44,42.48 219.6,42.48 219.71,42.37 219.71,42.14 219.83,42.03 226.47,42.03 226.93,42.48 231.3,42.48 232.8,40.98 234.51,40.98 235.64,39.85 v2(236.27,39.85)
  BOTTOM w0.076: UH1.R8 v2(170.78,83.07)
  BOTTOM w0.14: v2(236.27,39.85) 236.27,39.87 234.83,41.32 JDIMM2.215
DDR_B_D52: length 104.9
  IN2 w0.076: v2(170.78,84.37) 170.41,84 170.41,82.86 170.26,82.71 170.26,77.97 170.26,77.73 174.03,73.96 174.03,72.74 174.02,72.73 174.02,72.71 174.04,72.69
  IN2 w0.097: v2(236.27,38.58) 236.27,38.6 235.87,39.01 235.87,39.21 235.79,39.29 235.62,39.29 235.5,39.17 235.34,39.17 235.23,39.29 235.23,39.45 235.34,39.56 235.34,39.72 234.38,40.68 232.98,40.68 232.68,40.68 231.18,42.18 227.05,42.18 226.6,41.73 210.67,41.73 210.56,41.84 210.56,42.07 210.45,42.18 210.29,42.18 210.17,42.07 210.17,41.84 210.06,41.73 209.9,41.73 209.79,41.84 209.79,42.07 209.67,42.18 209.51,42.18 209.4,42.07 209.4,41.84 209.29,41.73 209.13,41.73 209.01,41.84 209.01,42.07 208.9,42.18 208.74,42.18 208.63,42.07 208.63,41.84 208.52,41.73 208.36,41.73 208.24,41.84 208.24,42.07 208.13,42.18 207.97,42.18 207.86,42.07 207.86,41.84 207.74,41.73 207.01,41.73 197.75,50.99 186.17,50.99 174.07,63.09 174.07,72.65 174.04,72.69
  BOTTOM w0.076: UH1.R10 v2(170.78,84.37)
  BOTTOM w0.14: JDIMM2.211 233.83,41.98 235.78,40.02 235.78,39.08 v2(236.27,38.58)
DDR_B_D53: length 104.5
  IN2 w0.076: 176.39,75.03 175.87,75.56 175.33,75.56 172.44,78.45 172.44,81.62 172.43,81.63 172.43,82.57 172.06,82.95 172.06,84.28 171.96,84.37 v2(171.69,84.37)
  IN2 w0.097: v2(238.24,38.26) 238.96,38.26 240.05,39.36 240.05,41.74 239.26,42.54 236.6,42.54 233.34,45.79 233.34,45.79 233.12,46.02 210.53,46.02 209.78,46.76 206.14,46.76 199.06,53.84 187.99,53.84 187.67,54.16 187.04,54.16 177.11,64.08 177.11,74.31 176.39,75.03
  BOTTOM w0.076: UH1.P10 v2(171.69,84.37)
  BOTTOM w0.14: v2(238.24,38.26) 238.05,38.07 238.04,38.07 237.68,37.71 237.68,37.29 237.07,36.68 JDIMM2.224
DDR_B_D54: length 104.3
  IN2 w0.076: 174.6,73.24 174.36,73.49 174.36,74.1 170.78,77.68 v2(170.78,82.42)
  IN2 w0.097: v2(234.23,35.97) 235.19,35.97 236.7,37.47 236.7,40 236.41,40.29 235.63,40.29 234.63,41.28 232.98,41.28 231.48,42.78 225.86,42.78 225.74,42.67 225.74,42.44 225.63,42.33 225.47,42.33 225.36,42.44 225.36,42.67 225.24,42.78 225.08,42.78 224.97,42.67 224.97,42.44 224.86,42.33 224.7,42.33 224.58,42.44 224.58,42.67 224.47,42.78 224.31,42.78 224.2,42.67 224.2,42.44 224.09,42.33 223.93,42.33 223.81,42.44 223.81,42.67 223.7,42.78 223.54,42.78 223.43,42.67 223.43,42.44 223.31,42.33 223.15,42.33 223.04,42.44 223.04,42.67 222.93,42.78 222.77,42.78 222.65,42.67 222.65,42.44 222.54,42.33 222.38,42.33 222.27,42.44 222.27,42.67 222.16,42.78 221.99,42.78 221.88,42.67 221.88,42.44 221.77,42.33 221.61,42.33 221.5,42.44 221.5,42.67 221.38,42.78 221.05,42.78 220.93,42.67 220.93,42.5 220.82,42.38 220.66,42.38 220.55,42.5 220.55,42.67 220.43,42.78 207.41,42.78 206.81,42.78 198,51.59 186.42,51.59 174.67,63.34 174.67,73.17 174.6,73.24
  BOTTOM w0.076: UH1.R7 v2(170.78,82.42)
  BOTTOM w0.14: JDIMM2.212 234.07,35.82 v2(234.23,35.97)
DDR_B_D55: length 104.7
  IN2 w0.076: 176.06,74.71 175.38,75.39 175.26,75.39 172.28,78.38 172.28,81.41 172.27,81.42 172.27,82.5 v2(171.66,83.11)
  IN2 w0.097: v2(239.34,40.2) 239.5,40.2 239.75,40.45 239.75,41.62 239.14,42.24 236.47,42.24 233.04,45.67 226.43,45.67 226.38,45.61 226.13,45.61 226.07,45.67 225.43,45.67 225.37,45.61 225.13,45.61 225.07,45.67 221.64,45.67 221.58,45.61 221.33,45.61 221.27,45.67 220.86,45.67 220.81,45.61 220.56,45.61 220.5,45.67 220.09,45.67 220.03,45.61 219.79,45.61 219.73,45.67 219.32,45.67 219.26,45.61 219.02,45.61 218.96,45.67 216.78,45.67 216.73,45.61 216.48,45.61 216.42,45.67 216.01,45.67 215.95,45.61 215.71,45.61 215.65,45.67 215.24,45.67 215.18,45.61 214.94,45.61 214.88,45.67 209.84,45.67 209.79,45.72 209.79,46.08 209.68,46.2 209.52,46.2 209.4,46.08 209.4,45.72 209.35,45.67 209.07,45.67 209.02,45.72 209.02,46.27 208.9,46.39 208.74,46.39 208.63,46.27 208.63,45.72 208.58,45.67 208.3,45.67 208.24,45.72 208.24,46.27 208.13,46.39 207.97,46.39 207.86,46.27 207.86,45.72 207.8,45.67 207.53,45.67 207.47,45.72 207.47,46.27 207.36,46.39 207.2,46.39 207.09,46.27 207.09,45.72 207.03,45.67 206.81,45.67 198.94,53.54 187.86,53.54 187.55,53.86 186.91,53.86 176.81,63.96 176.81,73.96 176.06,74.71
  BOTTOM w0.076: UH1.P8 v2(171.66,83.11)
  BOTTOM w0.14: JDIMM2.225 237.32,41.84 237.83,41.33 238.32,41.33 238.92,40.73 238.92,40.58 239.17,40.33 239.21,40.33 v2(239.34,40.2)
DDR_B_D56: length 103.1
  IN2 w0.076: v2(174.41,84.37) 174.85,83.93 174.85,83.61 175.9,82.57 175.9,81.89 178.6,79.19
  IN2 w0.097: v2(243.8,36.18) 243.8,36.76 245.18,38.13 245.18,39.3 245.23,39.35 245.23,39.36 245.35,39.48 245.35,43.96 241.69,47.63 238.7,47.63 235.71,50.61 217.21,50.61 214.57,53.25 206.3,53.25 200.69,58.86 191.61,58.86 189.84,60.63 189.84,61.71 186.14,65.41 186.14,67.1 182.6,70.64 182.6,75.22 178.75,79.07 178.72,79.07 178.6,79.19
  BOTTOM w0.076: UH1.L11 174.08,84.7 v2(174.41,84.37)
  BOTTOM w0.14: JDIMM2.250 243.58,35.95 v2(243.8,36.18)
DDR_B_D57: length 103.1
  IN2 w0.076: v2(173.52,85.02) 172.98,84.48 172.98,83.51 172.76,83.29 172.76,81.99 172.77,81.98 172.77,78.58 175.47,75.89 177.05,75.89 177.15,75.79
  IN2 w0.097: 177.15,75.79 178.19,74.76 178.19,65.1 188.42,54.87 199.49,54.87 206.39,47.97 209.4,47.97 209.86,48.43 210.35,48.43 210.46,48.32 210.46,47.79 210.6,47.65 210.74,47.65 210.85,47.77 210.85,48.32 210.96,48.43 211.12,48.43 211.23,48.32 211.23,47.77 211.35,47.65 211.51,47.65 211.62,47.77 211.62,48.32 211.73,48.43 212.16,48.43 212.26,48.34 212.26,48.13 212.35,48.03 212.55,48.03 212.64,48.13 212.64,48.34 212.74,48.43 213.21,48.43 214.59,47.05 233.54,47.05 233.7,46.89 234.54,46.89 237.87,43.57 239.69,43.57 241.36,41.89 v2(241.36,41.41)
  BOTTOM w0.076: UH1.M11 v2(173.52,85.02)
  BOTTOM w0.14: JDIMM2.237 240.32,41.73 240.6,41.46 241.32,41.46 v2(241.36,41.41)
DDR_B_D58: length 102.9
  IN2 w0.076: 178.6,77.95 178.38,78.17 178.38,78.36 176.17,80.57 175.74,80.57 174.51,81.8 v2(174.36,81.8)
  IN2 w0.097: 178.6,77.95 180.98,75.57 180.98,69.11 184.59,65.5 184.59,63.75 185.17,63.17 186.1,63.17 188.76,60.5 188.76,60.29 191.09,57.96 200.32,57.96 205.93,52.35 208.49,52.35 208.6,52.24 208.6,51.9 208.72,51.79 208.88,51.79 208.99,51.9 208.99,52.24 209.1,52.35 209.26,52.35 209.37,52.24 209.37,51.9 209.49,51.79 209.65,51.79 209.76,51.9 209.76,52.24 209.87,52.35 210.03,52.35 210.15,52.24 210.15,51.9 210.26,51.79 210.42,51.79 210.53,51.9 210.53,52.24 210.65,52.35 210.81,52.35 210.92,52.24 210.92,51.9 211.03,51.79 211.19,51.79 211.3,51.9 211.3,52.24 211.42,52.35 211.58,52.35 211.69,52.24 211.69,51.9 211.8,51.79 211.96,51.79 212.08,51.9 212.08,52.24 212.19,52.35 212.35,52.35 212.46,52.24 212.46,51.9 212.58,51.79 212.74,51.79 212.85,51.9 212.85,52.24 212.96,52.35 213.12,52.35 213.24,52.24 213.24,51.9 213.34,51.8 213.73,51.8 213.9,51.97 214.04,51.97 214.17,51.83 214.17,51.7 214,51.52 214,51.39 215.67,49.72 235.32,49.72 238.31,46.73 241.31,46.73 242.35,45.69 242.35,44.87 244.07,43.15 244.07,41.03 v2(243.7,40.67)
  BOTTOM w0.076: v2(174.36,81.8) 174.07,82.1 UH1.L7
  BOTTOM w0.14: v2(243.7,40.67) 243.7,40.67 243.33,41.04 JDIMM2.249
DDR_B_D59: length 103.3
  IN2 w0.076: 177.57,76.22 177.31,76.48 176.35,76.48 174.77,78.07 174.77,78.47 174.41,78.83 174.16,78.83 173.1,79.89 173.1,82.22 173.09,82.23 173.09,82.72 v2(173.45,83.07)
  IN2 w0.097: v2(241.36,38.87) 241.85,39.35 241.85,40.07 242.08,40.3 242.08,42.15 239.5,44.73 237.55,44.73 234.79,47.49 233.95,47.49 233.79,47.65 214.98,47.65 213.52,49.11 209.02,49.11 208.95,49.05 206.16,49.05 199.74,55.47 188.66,55.47 178.87,65.27 178.87,74.92 177.57,76.22
  BOTTOM w0.076: UH1.M8 v2(173.45,83.07)
  BOTTOM w0.14: v2(241.36,38.87) 240.96,38.87 239.45,37.36 239.45,35.89 239.07,35.51 JDIMM2.232
DDR_B_D60: length 102.8
  IN2 w0.076: 178.6,78.77 178.6,78.77 178.3,79.07 178.3,79.26 175.73,81.83 175.73,82.41 v2(174.41,83.73)
  IN2 w0.097: v2(243.8,37.45) 243.8,38.11 244.39,38.7 244.39,39.42 244.46,39.49 244.46,40.57 244.67,40.79 244.67,40.82 244.67,43.4 242.98,45.09 242.98,45.91 241.56,47.33 238.56,47.33 235.57,50.32 217.09,50.32 216.48,50.92 216.35,50.92 216.24,50.81 216.15,50.81 215.96,51 215.96,51.08 216.07,51.19 216.07,51.33 214.45,52.95 206.18,52.95 200.57,58.56 191.49,58.56 189.52,60.52 189.52,61.6 185.84,65.28 185.84,66.98 182.28,70.53 182.28,75.11 178.63,78.77 178.6,78.77
  BOTTOM w0.076: UH1.L10 174.09,84.05 v2(174.41,83.73)
  BOTTOM w0.14: JDIMM2.246 242.58,35.73 242.65,35.81 242.65,36.3 v2(243.8,37.45)
DDR_B_D61: length 102.8
  IN2 w0.076: v2(173.52,84.37) 173.15,84 173.15,83.42 172.93,83.2 172.93,82.09 172.94,82.09 172.94,78.65 175.44,76.15 177.22,76.15 177.36,76.01
  IN2 w0.097: 177.36,76.01 178.53,74.84 178.53,65.18 188.54,55.17 199.61,55.17 206.05,48.73 206.98,48.73 207.09,48.62 207.09,48.46 207.2,48.35 207.36,48.35 207.48,48.46 207.48,48.62 207.59,48.73 207.85,48.73 207.98,48.61 208.14,48.61 208.26,48.73 213.34,48.73 214.72,47.35 233.67,47.35 233.83,47.19 234.67,47.19 237.99,43.87 239.81,43.87 241.78,41.9 241.78,40.43 241.53,40.17 241.53,40.15 241.52,40.14 v2(241.36,40.14)
  BOTTOM w0.076: UH1.M10 v2(173.52,84.37)
  BOTTOM w0.14: JDIMM2.233 239.32,42.01 240.32,41.02 240.32,40.64 240.83,40.14 v2(241.36,40.14)
DDR_B_D62: length 103
  IN2 w0.076: v2(173.45,82.41) 173.45,81.13 173.76,80.82 174.42,80.82 174.75,80.48 174.75,79.71 176.77,77.69 176.77,77.44 177.79,76.43
  IN2 w0.097: 177.79,76.43 179.21,75.01 179.21,65.35 188.25,56.31 199.32,56.31 205.5,50.13 206.37,50.13 206.48,50.02 206.48,49.48 206.59,49.37 206.75,49.37 206.87,49.48 206.87,50.02 206.98,50.13 207.2,50.13 207.37,49.97 207.53,49.97 207.69,50.13 212.92,50.13 215.11,47.95 234.76,47.95 237.68,45.03 239.71,45.03 242.38,42.35 242.38,40.18 242.22,40.02 242.15,39.94 242.15,38.49 241.14,37.48 241.14,37.04 v2(240.1,36.01)
  BOTTOM w0.076: UH1.M7 v2(173.45,82.41)
  BOTTOM w0.14: v2(240.1,36.01) 240.07,35.98 JDIMM2.236
DDR_B_D63: length 102.9
  IN2 w0.076: v2(174.36,82.44) 175.59,81.21 175.59,80.95 175.81,80.74 176.23,80.74 178.6,78.37
  IN2 w0.097: v2(243.75,39.21) 244.16,39.61 244.16,40.7 244.37,40.91 244.37,43.02 244.37,43.27 242.65,45 242.65,45.82 241.44,47.03 238.43,47.03 235.45,50.02 216.5,50.02 215.41,51.1 215.41,51.42 215.3,51.53 215.14,51.53 214.79,51.18 214.63,51.18 214.52,51.3 214.52,51.46 214.87,51.8 214.87,51.96 214.18,52.65 206.05,52.65 200.44,58.26 191.24,58.26 189.14,60.35 189.14,60.54 186.22,63.46 185.29,63.46 184.95,63.81 184.95,65.56 181.28,69.23 181.28,75.69 178.6,78.37
  BOTTOM w0.076: UH1.L8 174.05,82.75 v2(174.36,82.44)
  BOTTOM w0.14: v2(243.75,39.21) 242.75,39.21 242.32,39.63 JDIMM2.245
DDR_B_DQS0: length 58.4
  IN1 w0.076: 165.33,70.13 165.33,70.15 165.34,70.16 165.34,72.77 165.78,73.21 v2(165.78,73.51)
  IN1 w0.097: v2(181.4,40.07) 181.19,40.28 181.16,40.28 180.53,40.28 170.98,49.83 170.98,50.19 171.52,50.72 171.52,50.92 171.37,51.06 171.17,51.06 170.64,50.53 170.29,50.53 170.04,50.78 170.04,51.13 170.57,51.67 170.57,51.87 170.43,52.01 170.23,52.01 169.7,51.48 169.34,51.48 169.09,51.73 169.09,52.08 169.62,52.61 169.62,52.81 169.48,52.95 169.28,52.95 168.75,52.42 168.4,52.42 168.15,52.67 168.15,53.02 168.68,53.56 168.68,53.76 168.54,53.9 168.34,53.9 167.8,53.37 167.45,53.37 165.27,55.55 165.27,70.08 165.33,70.13
  BOTTOM w0.076: v2(165.78,73.51) 165.99,73.51 166.16,73.69 166.16,77.61 165.82,77.95 165.82,79.21 UH1.AB3
  BOTTOM w0.14: v2(181.4,40.07) 181.54,40.21 182.12,40.21 182.53,40.62 182.53,41.24 182.21,41.56 182.21,41.76 182.33,41.87 JDIMM2.13
DDR_B_DQS1: length 56.3
  IN1 w0.076: 169.72,67.49 169.72,67.51 169.71,67.52 169.71,71.79 170.35,72.42 170.35,73.5 169.91,73.94 168.96,73.94 v2(168.96,73.94)
  IN1 w0.097: v2(187.32,37.86) 187.32,37.84 187.22,37.75 186.95,37.75 186.86,37.84 186.86,38.14 187.09,38.37 187.09,38.99 187.86,39.77 187.86,42.53 169.72,60.67 169.72,67.49
  BOTTOM w0.076: v2(168.96,73.94) 169.33,73.94 169.47,74.08 169.47,75.63 168.33,76.77 168.33,78.06 168.35,78.08 168.35,79.19 UH1.V3
  BOTTOM w0.14: v2(187.32,37.86) 187.32,37.86 187.69,37.49 187.78,37.49 188.09,37.19 188.09,36.07 187.8,35.79 187.8,35.75 187.57,35.52 JDIMM2.34
DDR_B_DQS2: length 69.4
  IN2 w0.076: 165.58,72.53 165.58,72.61 165.56,72.63 165.56,72.64 164.25,73.95 164.25,78.24 165.38,79.37 165.38,81.43 165.82,81.88 165.82,83.75 165.9,83.82 166.08,83.82 166.22,83.68 v2(166.22,83.63)
  IN2 w0.097: v2(193.25,38.51) 193.33,38.42 193.33,38.29 193.24,38.19 192.89,38.19 192.64,38.44 192.64,41.7 190.64,43.7 183.19,43.7 165.58,61.31 165.58,72.53
  BOTTOM w0.076: UH1.AA9 v2(166.22,83.63)
  BOTTOM w0.14: JDIMM2.55 192.83,42.14 192.77,42.09 192.77,38.43 192.91,38.29 193.11,38.29 193.25,38.43 v2(193.25,38.51)
DDR_B_DQS3: length 75.9
  IN2 w0.076: 171.33,72.53 171.33,72.54 171.32,72.55 171.32,72.6 171.31,72.61 171.31,74.3 168.56,77.05 168.56,78.38 168.35,78.59 168.18,78.59 168.07,78.7 168.07,78.86 168.18,78.97 168.35,78.97 168.56,79.18 168.56,79.56 168.35,79.77 168.21,79.77 168.1,79.88 168.1,80.04 168.21,80.15 168.35,80.15 168.56,80.36 168.56,80.65 168.35,80.86 168.21,80.86 168.1,80.97 168.1,81.13 168.21,81.24 168.35,81.24 168.56,81.45 168.56,83.33 v2(168.95,83.72)
  IN2 w0.097: 171.33,72.53 171.33,62.08 185.07,48.33 194.69,48.33 195.12,47.9 195.12,47.44 195.31,47.25 195.76,47.25 196.06,46.96 196.06,46.5 196.25,46.31 196.71,46.31 199.11,43.91 199.11,43.53 198.86,43.28 198.01,43.28 197.87,43.14 197.87,42.94 198.01,42.8 198.86,42.8 199.11,42.55 199.11,40.09 198.91,39.89 197.82,39.89 197.68,39.75 197.68,39.55 197.82,39.4 198.91,39.4 199.11,39.2 199.11,37.56 198.99,37.43 198.73,37.43 v2(198.51,37.21)
  BOTTOM w0.076: UH1.V9 v2(168.95,83.72)
  BOTTOM w0.14: v2(198.51,37.21) 198.3,37.42 198.15,37.42 197.96,37.23 197.96,35.84 198.08,35.73 JDIMM2.76
DDR_B_DQS4: length 91.8
  IN1 w0.076: 173.9,69.25 173.9,69.27 173.89,69.28 173.89,73.72 173.33,74.28 173.08,74.28 172.89,74.08 172.62,74.08 172.52,73.98 172.41,73.98 172.32,74.07 v2(172.32,74.18)
  IN1 w0.097: 173.9,69.25 173.9,63.31 191.7,45.51 203.47,45.51 203.72,45.26 203.72,44.28 203.86,44.14 204.06,44.14 204.2,44.28 204.2,45.26 204.45,45.51 204.81,45.51 205.06,45.26 205.06,44.28 205.2,44.14 205.4,44.14 205.54,44.28 205.54,45.26 205.79,45.51 225.01,45.51 225.62,44.91 225.62,41.65 226.86,40.41 227.05,40.41 227.18,40.54 227.18,40.72 v2(227.17,40.73)
  BOTTOM w0.076: v2(172.32,74.18) 172.32,74.19 172.34,74.22 172.34,75.41 171.55,76.21 171.55,77.04 170.86,77.72 170.86,77.73 170.88,77.74 170.86,77.76 170.86,79.28 170.88,79.29 170.86,79.3 170.86,79.32 170.97,79.42 170.97,79.54 170.86,79.65 170.73,79.65 170.57,79.49 UH1.R3
  BOTTOM w0.14: v2(227.17,40.73) 227,40.57 226.89,40.57 225.68,41.78 225.68,41.98 225.83,42.12 JDIMM2.179
DDR_B_DQS5: length 98.5
  IN1 w0.076: v2(175.17,76.96) 174.84,76.96 174.75,76.87 174.75,76.76 175.35,76.16 175.97,76.16
  IN1 w0.097: 175.97,76.16 178.08,74.05 178.08,66.14 193.61,50.61 214.7,50.61 214.84,50.75 214.84,51 215.09,51.25 215.44,51.25 215.69,51 215.69,50.75 215.84,50.61 216.06,50.61 216.2,50.75 216.2,51 216.45,51.25 216.8,51.25 217.05,51 217.05,50.75 217.2,50.61 217.4,50.61 217.54,50.75 217.54,51 217.79,51.25 218.14,51.25 218.39,51 218.39,50.75 218.53,50.61 218.73,50.61 218.87,50.75 218.87,51 219.12,51.25 219.48,51.25 219.73,51 219.73,50.75 219.87,50.61 220.34,50.61 220.49,50.75 220.49,51 220.73,51.25 221.09,51.25 221.34,51 221.34,50.75 221.48,50.61 221.68,50.61 221.82,50.75 221.82,51 222.07,51.25 222.43,51.25 222.67,51 222.67,50.75 222.82,50.61 223.02,50.61 223.16,50.75 223.16,51 223.41,51.25 223.76,51.25 224.01,51 224.01,50.75 224.15,50.61 224.35,50.61 224.49,50.75 224.49,51 224.74,51.25 226.12,51.25 226.71,50.66 226.77,50.6 233.06,44.31 233.06,38.23 232.85,38.03 232.6,38.03 v2(232.37,37.8)
  BOTTOM w0.076: UH1.M3 173.37,79.21 173.37,77.96 173.5,77.82 173.5,77.71 173.53,77.68 173.53,77.66 174.37,76.82 174.67,76.82 174.8,76.96 v2(175.17,76.96)
  BOTTOM w0.14: JDIMM2.200 231.07,35.73 230.96,35.84 230.96,36.04 231.84,36.92 231.84,37.89 231.9,37.95 232.23,37.95 v2(232.37,37.8)
DDR_B_DQS6: length 104.9
  IN2 w0.076: v2(171.69,83.73) 171.69,83.91 171.61,83.99 171.25,83.99 171.17,83.92 171.17,83.58 171.3,83.45 171.3,77.66 174.82,74.14 174.97,74.14 175.18,73.94 175.19,73.94 175.23,73.9 175.24,73.9 175.25,73.89
  IN2 w0.097: v2(238.24,40.22) 238.25,40.2 238.25,40.07 238.16,39.97 237.85,39.97 237.61,40.2 237.61,40.38 236.79,41.2 236.01,41.2 235.01,42.2 233.36,42.2 231.86,43.7 215.71,43.7 215.56,43.84 215.56,43.89 215.36,44.09 214.92,44.09 214.71,43.89 214.71,43.84 214.57,43.7 213.2,43.7 213.06,43.84 213.06,44.39 212.81,44.64 212.46,44.64 212.21,44.39 212.21,43.84 212.07,43.7 211.87,43.7 211.73,43.84 211.73,44.39 211.48,44.64 211.12,44.64 210.87,44.39 210.87,43.84 210.73,43.7 208.72,43.7 208.58,43.84 208.58,44.39 208.33,44.64 207.98,44.64 207.73,44.39 207.73,43.84 207.59,43.7 207.19,43.7 198.38,52.51 186.8,52.51 175.59,63.72 175.59,73.55 175.25,73.89
  BOTTOM w0.076: UH1.P9 171.69,83.72 v2(171.69,83.73)
  BOTTOM w0.14: JDIMM2.221 236.32,41.87 236.21,41.76 236.21,41.55 237.65,40.11 237.77,40.11 238.13,40.11 v2(238.24,40.22)
DDR_B_DQS7: length 103.2
  IN2 w0.076: 178.44,77.08 178.42,77.09 178.41,77.09 178.24,77.25 178.24,77.46 174.5,81.2 174.45,81.2 173.99,81.66 173.99,83.24 174.08,83.33 174.29,83.33 174.41,83.21 v2(174.41,83.07)
  IN2 w0.097: v2(242.24,36.68) 242.54,36.98 242.86,36.98 243.06,37.19 243.06,39.56 243.3,39.8 243.3,42.88 241.49,44.69 241.49,44.83 241.09,45.24 240.94,45.24 240.19,46 238.01,46 235.14,48.87 215.49,48.87 213.3,51.05 206.06,51.05 201.37,55.74 201.37,55.87 200.02,57.23 189.83,57.23 180.13,66.93 180.13,75.38 178.44,77.08
  BOTTOM w0.076: UH1.L9 174.08,83.4 v2(174.41,83.07)
  BOTTOM w0.14: JDIMM2.242 241.58,35.73 241.46,35.84 241.46,36.64 241.71,36.88 242.04,36.88 v2(242.24,36.68)
DDR_B_DQS#0: length 58.3
  IN1 w0.076: v2(166.2,73.11) 166.11,73.2 166,73.2 165.5,72.7 165.5,70.16 165.51,70.15 165.51,70.15 165.5,70.14 165.5,70.06 165.46,70.02 165.46,70.01 165.46,70
  IN1 w0.097: 165.46,70 165.46,55.62 167.53,53.55 167.73,53.55 168.26,54.08 168.61,54.08 168.86,53.83 168.86,53.48 168.33,52.95 168.33,52.75 168.47,52.61 168.67,52.61 169.21,53.14 169.56,53.14 169.81,52.89 169.81,52.53 169.28,52 169.28,51.8 169.42,51.66 169.62,51.66 170.15,52.19 170.5,52.19 170.76,51.94 170.76,51.59 170.22,51.06 170.22,50.86 170.36,50.72 170.56,50.72 171.1,51.25 171.45,51.25 171.7,51 171.7,50.64 171.17,50.11 171.17,49.91 180.61,40.47 181.16,40.47 181.23,40.47 181.23,40.48 181.37,40.48 181.46,40.56 v2(181.46,40.67)
  BOTTOM w0.076: UH1.AA3 166.28,79.6 166.21,79.68 166.08,79.68 165.99,79.58 165.99,78.06 166.33,77.72 166.33,73.62 166.2,73.49 166.2,73.4
  BOTTOM w0.14: JDIMM2.11 181.83,41.87 181.94,41.76 181.94,41.44 182.25,41.13 182.25,40.74 182,40.49 181.64,40.49 v2(181.46,40.67) ; 166.2,73.4 v2(166.2,73.11)
DDR_B_DQS#1: length 56.2
  IN1 w0.076: 169.54,67.49 169.54,67.51 169.55,67.52 169.55,71.85 170.18,72.49 170.18,73.43 169.84,73.78 169.41,73.78 169.34,73.7 v2(169.34,73.5)
  IN1 w0.097: v2(187.36,37.21) 187.36,37.36 187.27,37.45 187.15,37.45 187.04,37.56 186.88,37.56 186.67,37.77 186.67,38.21 186.9,38.44 186.9,39.07 187.68,39.85 187.68,42.45 169.54,60.59 169.54,67.49
  BOTTOM w0.076: v2(169.34,73.5) 169.34,73.72 169.63,74.01 169.63,75.74 168.52,76.85 168.52,78.06 168.51,78.06 168.51,79.44 168.63,79.56 168.73,79.56 168.79,79.5 UH1.U3
  BOTTOM w0.14: JDIMM2.32 187.08,35.42 187.52,35.86 187.52,35.9 187.81,36.19 187.81,37.07 187.67,37.21 v2(187.36,37.21)
DDR_B_DQS#2: length 69.4
  IN2 w0.076: 165.4,72.53 165.4,72.57 164.09,73.88 164.09,78.3 165.22,79.44 165.22,81.87 165.62,82.27 165.62,83.36 v2(165.33,83.65)
  IN2 w0.097: 165.4,72.53 165.4,61.23 183.11,43.52 190.56,43.52 192.46,41.62 192.46,38.36 192.81,38.01 192.96,38.01 v2(193.23,37.74)
  BOTTOM w0.076: UH1.AC9 v2(165.33,83.65)
  BOTTOM w0.14: v2(193.23,37.74) 193.02,37.95 192.83,37.95 192.49,38.28 192.49,42.01 192.32,42.18 JDIMM2.53
DDR_B_DQS#3: length 76
  IN2 w0.076: 171.14,72.53 171.14,74.23 168.39,76.98 168.39,78.31 168.28,78.42 168.11,78.42 167.91,78.63 167.91,78.93 168.11,79.14 168.28,79.14 168.39,79.25 168.39,79.49 168.28,79.61 168.14,79.61 167.93,79.81 167.93,80.11 168.14,80.32 168.28,80.32 168.39,80.43 168.39,80.59 168.28,80.7 168.14,80.7 167.93,80.91 167.93,81.2 168.14,81.41 168.28,81.41 168.39,81.52 168.39,83.39 v2(168.06,83.72)
  IN2 w0.097: 171.14,72.53 171.14,62 184.99,48.15 194.61,48.15 194.93,47.82 194.93,47.37 195.23,47.07 195.69,47.07 195.88,46.88 195.88,46.42 196.18,46.12 196.63,46.12 198.93,43.83 198.93,43.61 198.78,43.47 197.93,43.47 197.68,43.22 197.68,42.86 197.93,42.61 198.78,42.61 198.93,42.47 198.93,40.17 198.83,40.07 197.74,40.07 197.49,39.82 197.49,39.47 197.74,39.22 198.83,39.22 198.93,39.12 198.93,37.63 198.91,37.62 198.68,37.62 v2(198.51,37.8)
  BOTTOM w0.076: UH1.W9 v2(168.06,83.72)
  BOTTOM w0.14: JDIMM2.74 197.57,35.73 197.69,35.84 197.69,37.35 198.03,37.7 198.41,37.7 v2(198.51,37.8)
DDR_B_DQS#4: length 91.8
  IN1 w0.076: v2(172.77,73.73) 173.15,74.11 173.26,74.11 173.73,73.65 173.73,69.28 173.72,69.27 173.72,69.25
  IN1 w0.097: 173.72,69.25 173.72,63.24 191.63,45.33 203.39,45.33 203.53,45.19 203.53,44.2 203.78,43.95 204.14,43.95 204.39,44.2 204.39,45.19 204.53,45.33 204.73,45.33 204.87,45.19 204.87,44.2 205.12,43.95 205.47,43.95 205.72,44.2 205.72,45.19 205.87,45.33 224.93,45.33 225.43,44.83 225.43,41.57 226.78,40.22 226.93,40.22 v2(227.17,39.98)
  BOTTOM w0.076: UH1.P3 171.03,79.21 171.03,77.83 171.74,77.12 171.74,76.29 172.53,75.49 172.53,74.58 172.87,74.25 172.87,73.86 172.77,73.76 v2(172.77,73.73)
  BOTTOM w0.14: JDIMM2.177 225.32,42.08 225.4,42 225.4,41.66 226.78,40.29 226.94,40.29 227.17,40.06 v2(227.17,39.98)
DDR_B_DQS#5: length 98.5
  IN1 w0.076: 175.88,75.99 175.87,76 175.28,76 174.59,76.69 174.59,76.94 174.72,77.07 v2(174.72,77.41)
  IN1 w0.097: v2(232.37,38.41) 232.57,38.21 232.78,38.21 232.87,38.31 232.87,44.24 226.68,50.43 226.64,50.47 226.05,51.06 224.82,51.06 224.68,50.92 224.68,50.68 224.43,50.43 224.07,50.43 223.83,50.68 223.83,50.92 223.68,51.06 223.48,51.06 223.34,50.92 223.34,50.68 223.09,50.43 222.74,50.43 222.49,50.68 222.49,50.92 222.35,51.06 222.15,51.06 222.01,50.92 222.01,50.68 221.76,50.43 221.4,50.43 221.15,50.68 221.15,50.92 221.01,51.06 220.81,51.06 220.67,50.92 220.67,50.68 220.42,50.43 219.79,50.43 219.54,50.68 219.54,50.92 219.4,51.06 219.2,51.06 219.06,50.92 219.06,50.68 218.81,50.43 218.45,50.43 218.2,50.68 218.2,50.92 218.06,51.06 217.86,51.06 217.72,50.92 217.72,50.68 217.47,50.43 217.12,50.43 216.87,50.68 216.87,50.92 216.73,51.06 216.53,51.06 216.39,50.92 216.39,50.68 216.14,50.43 215.76,50.43 215.51,50.68 215.51,50.92 215.37,51.06 215.17,51.06 215.03,50.92 215.03,50.68 214.78,50.43 193.53,50.43 177.9,66.06 177.9,73.97 175.88,75.99
  BOTTOM w0.076: v2(174.72,77.41) 174.72,77.11 174.6,76.99 174.44,76.99 173.69,77.73 173.69,77.9 173.53,78.06 173.53,79.41 173.61,79.49 UH1.L3
  BOTTOM w0.14: JDIMM2.198 230.58,35.73 230.69,35.84 230.69,36.16 231.56,37.03 231.56,38 231.79,38.23 232.19,38.23 v2(232.37,38.41)
DDR_B_DQS#6: length 104.9
  IN2 w0.076: v2(170.78,83.72) 170.79,83.72 171.13,83.38 171.13,77.59 174.75,73.98 174.9,73.98 175.12,73.76
  IN2 w0.097: 175.12,73.76 175.41,73.47 175.41,63.64 186.72,52.32 198.3,52.32 207.11,43.52 207.66,43.52 207.91,43.77 207.91,44.31 208.05,44.45 208.25,44.45 208.4,44.31 208.4,43.77 208.65,43.52 210.81,43.52 211.06,43.77 211.06,44.31 211.2,44.45 211.4,44.45 211.54,44.31 211.54,43.77 211.79,43.52 212.15,43.52 212.4,43.77 212.4,44.31 212.54,44.45 212.74,44.45 212.88,44.31 212.88,43.77 213.13,43.52 214.65,43.52 214.9,43.77 214.9,43.81 214.99,43.91 215.28,43.91 215.38,43.81 215.38,43.77 215.63,43.52 231.78,43.52 233.28,42.01 234.93,42.01 235.93,41.02 236.71,41.02 237.43,40.3 237.43,40.12 237.77,39.78 238.1,39.78 238.25,39.64 v2(238.25,39.53)
  BOTTOM w0.076: UH1.R9 v2(170.78,83.72)
  BOTTOM w0.14: JDIMM2.219 235.83,41.87 235.94,41.76 235.94,41.43 237.54,39.83 237.88,39.83 237.89,39.83 237.95,39.83 v2(238.25,39.53)
DDR_B_DQS#7: length 103.2
  IN2 w0.076: v2(173.53,83.72) 173.83,83.43 173.83,81.59 174.38,81.04 174.43,81.04 178.08,77.39 178.08,77.19 178.3,76.97 178.3,76.95 178.3,76.95
  IN2 w0.097: v2(242.23,37.39) 242.24,37.39 242.46,37.17 242.78,37.17 242.88,37.27 242.88,39.64 243.11,39.87 243.11,42.81 241.31,44.62 241.31,44.76 241.01,45.05 240.87,45.05 240.11,45.81 237.93,45.81 235.06,48.68 215.41,48.68 213.23,50.87 205.99,50.87 201.19,55.66 201.19,55.79 199.94,57.04 189.76,57.04 179.95,66.85 179.95,75.3 178.3,76.95
  BOTTOM w0.076: UH1.M9 v2(173.53,83.72)
  BOTTOM w0.14: v2(242.23,37.39) 242.23,37.37 242.02,37.16 241.59,37.16 241.19,36.76 241.19,35.84 241.07,35.73 JDIMM2.240
DDR_B_MA0: length 99
  IN5 w0.076: 167.81,69.58 167.81,70.5 164.25,74.07 164.23,74.07 163.47,74.83 163.47,75.66 162.14,76.99 162.14,77.05 160.55,78.64 160.55,81.69 160.17,82.07 160.17,82.96 159.81,83.32 v2(159.81,83.72)
  IN5 w0.145: 167.81,69.58 167.81,66.05 171.03,62.83 173.52,62.83 174.06,62.29 174.3,62.29 174.79,62.78 175.03,62.78 175.2,62.61 175.2,62.37 174.71,61.88 174.71,61.64 174.88,61.47 175.12,61.47 175.61,61.96 175.85,61.96 176.02,61.79 176.02,61.55 175.53,61.06 175.53,60.82 175.7,60.65 175.94,60.65 176.43,61.14 176.67,61.14 176.84,60.97 176.84,60.73 176.35,60.24 176.35,60 176.52,59.83 176.76,59.83 177.25,60.32 177.49,60.32 177.66,60.15 177.66,59.92 177.17,59.42 177.17,59.18 182.36,53.99 184.71,53.99 184.73,53.97 209.65,53.97 217.57,46.06 217.57,39.18 217.41,39.02 v2(216.96,39.02)
  BOTTOM w0.076: UH1.AJ9 159.48,83.4 v2(159.81,83.72)
  BOTTOM w0.213: JDIMM2.144 215.08,35.38 215.71,36.02 215.71,37.77 v2(216.96,39.02)
DDR_B_MA1: length 95.1
  IN5 w0.076: v2(159.17,81.08) 158.76,80.68 158.76,80.21 158.48,79.93 158.48,77.58 158.94,77.12 160.37,77.12 162.32,75.17 162.32,74.3 164.19,72.42 164.19,70.64
  IN5 w0.145: v2(212.86,37.62) 212.89,37.65 212.92,37.65 213.63,38.36 213.63,39.25 213.15,39.73 213.15,45.52 207.99,50.67 178,50.67 174.95,53.72 174.95,53.96 175.28,54.29 175.28,54.53 175.11,54.7 174.87,54.7 174.54,54.37 174.3,54.37 174.13,54.54 174.13,54.78 174.46,55.11 174.46,55.35 174.29,55.52 174.05,55.52 173.72,55.19 173.48,55.19 173.31,55.36 173.31,55.6 173.64,55.93 173.64,56.17 170.41,59.4 169.6,59.4 164.21,64.79 164.21,67.69 164.19,67.71 164.19,70.64
  BOTTOM w0.089: v2(159.17,81.08) 158.87,81.44 UH1.AK6
  BOTTOM w0.213: v2(212.86,37.62) 212.86,37.62 213.53,38.29 213.53,39.39 212.32,40.6 JDIMM2.133
DDR_B_MA2: length 94.8
  IN5 w0.076: v2(159.12,80.45) 159.12,80.34 158.65,79.86 158.65,77.64 158.96,77.33 160.4,77.33 162.48,75.24 162.48,74.36 164.66,72.18 164.66,70.17
  IN5 w0.145: v2(214.67,38.45) 214.14,38.98 214.14,40.53 213.97,40.7 213.76,40.7 213.59,40.87 213.59,41.11 213.76,41.28 213.97,41.28 214.14,41.45 214.14,41.69 213.97,41.86 213.76,41.86 213.59,42.03 213.59,42.27 213.76,42.44 213.97,42.44 214.14,42.61 214.14,42.93 214.72,43.51 214.72,44.6 208.18,51.14 179.43,51.14 178.39,52.18 178.15,52.18 177.79,51.82 177.55,51.82 177.38,51.99 177.38,52.23 177.74,52.59 177.74,52.83 177.57,53 177.33,53 176.97,52.64 176.73,52.64 176.56,52.81 176.56,53.05 176.92,53.41 176.92,53.65 176.75,53.82 176.51,53.82 176.15,53.46 175.91,53.46 175.74,53.63 175.74,53.87 176.06,54.19 176.06,54.39 170.6,59.85 169.79,59.85 164.66,64.98 164.66,70.17
  BOTTOM w0.089: v2(159.12,80.45) 159.07,80.45 UH1.AK5
  BOTTOM w0.213: JDIMM2.132 212.08,35.93 213.81,37.66 213.81,37.77 214.48,38.45 v2(214.67,38.45)
DDR_B_MA3: length 94.2
  IN5 w0.076: 163.74,71.09 163.74,71.71 163.62,71.83 163.62,72.76 159.43,76.94 158.88,76.94 158.32,77.51 158.32,80 158.38,80.07 v2(158.38,80.46)
  IN5 w0.145: 163.74,71.09 163.74,67.34 163.76,67.32 163.76,64.27 169.39,58.65 169.63,58.65 169.93,58.95 170.17,58.95 170.34,58.78 170.34,58.54 170.04,58.24 170.04,58 170.21,57.83 170.45,57.83 170.75,58.13 170.99,58.13 171.16,57.96 171.16,57.72 170.86,57.42 170.86,57.18 171.03,57.01 171.27,57.01 171.57,57.31 171.81,57.31 171.98,57.14 171.98,56.9 171.68,56.6 171.68,56.36 171.85,56.19 172.09,56.19 172.39,56.49 172.63,56.49 172.79,56.32 172.79,56.08 172.5,55.78 172.5,55.54 177.83,50.2 179.09,50.2 179.26,50.03 179.26,49.73 179.43,49.56 179.67,49.56 179.84,49.73 179.84,50.03 180.01,50.2 180.25,50.2 180.42,50.03 180.42,49.73 180.59,49.56 180.83,49.56 181,49.73 181,50.03 181.17,50.2 181.41,50.2 181.58,50.03 181.58,49.73 181.75,49.56 181.99,49.56 182.16,49.73 182.16,50.03 182.33,50.2 207.79,50.2 212.7,45.3 212.7,39.54 212.85,39.39 v2(212.85,38.89)
  BOTTOM w0.089: UH1.AL5 158.06,80.79 v2(158.38,80.46)
  BOTTOM w0.213: v2(212.85,38.89) 211.83,39.92 JDIMM2.131
DDR_B_MA4: length 95.6
  IN5 w0.076: v2(158.38,81.17) 158.01,80.68 158.01,80.33 158.15,80.19 158.15,77.44 158.81,76.77 159.37,76.77 163.12,73.02 163.12,71.94 163.3,71.76 163.3,71.54
  IN5 w0.145: 163.3,71.54 163.3,67.15 163.31,67.13 163.31,64.09 178.29,49.11 182.9,49.11 183.11,49.32 183.11,49.57 183.28,49.74 183.52,49.74 183.69,49.57 183.69,49.32 183.86,49.15 184.1,49.15 184.27,49.32 184.27,49.57 184.44,49.74 184.68,49.74 184.85,49.57 184.85,49.19 185.02,49.02 185.26,49.02 185.43,49.19 185.43,49.57 185.6,49.74 185.84,49.74 186.01,49.57 186.01,49.19 186.18,49.02 186.42,49.02 186.59,49.19 186.59,49.57 186.76,49.74 187,49.74 187.16,49.57 187.16,49.19 187.33,49.02 187.57,49.02 187.74,49.19 187.74,49.57 187.91,49.74 188.15,49.74 188.32,49.57 188.32,49.19 188.49,49.02 188.73,49.02 188.9,49.19 188.9,49.57 189.07,49.74 189.31,49.74 189.48,49.57 189.48,49.19 189.65,49.02 189.89,49.02 190.06,49.19 190.06,49.57 190.23,49.74 190.47,49.74 190.64,49.57 190.64,49.19 190.81,49.02 191.05,49.02 191.22,49.19 191.22,49.57 191.39,49.74 207.6,49.74 212.25,45.09 212.25,37.07 v2(211.4,36.22)
  BOTTOM w0.089: UH1.AL6 158.12,81.44 v2(158.38,81.17)
  BOTTOM w0.213: JDIMM2.128 211.08,35.9 v2(211.4,36.22)
DDR_B_MA5: length 95.4
  IN5 w0.076: v2(157.57,81.12) 157.85,80.85 157.85,80.26 157.99,80.12 157.99,77.37 158.75,76.61 159.3,76.61 162.85,73.06 162.85,71.98
  IN5 w0.145: v2(211.38,37.53) 211.8,37.95 211.8,44.88 207.56,49.11 200.06,49.11 199.9,48.94 199.9,48.62 199.73,48.45 199.48,48.45 199.32,48.62 199.32,48.94 199.15,49.11 198.91,49.11 198.74,48.94 198.74,48.62 198.57,48.45 198.32,48.45 198.16,48.62 198.16,48.94 197.99,49.11 197.75,49.11 197.58,48.94 197.58,48.62 197.41,48.45 197.16,48.45 197,48.62 197,48.94 196.83,49.11 196.59,49.11 196.42,48.94 196.42,48.62 196.26,48.45 196.01,48.45 195.84,48.62 195.84,48.94 195.67,49.11 195.43,49.11 195.26,48.94 195.26,48.62 195.1,48.45 194.85,48.45 194.68,48.62 194.68,48.94 194.51,49.11 194.27,49.11 194.1,48.94 194.1,48.62 193.94,48.45 193.69,48.45 193.52,48.62 193.52,48.94 193.36,49.11 193.12,49.11 192.95,48.94 192.95,48.62 192.78,48.45 192.53,48.45 192.37,48.62 192.37,48.94 192.2,49.11 191.96,49.11 191.79,48.94 191.79,48.62 191.62,48.45 184.04,48.45 183.83,48.66 178.11,48.66 162.85,63.92 162.85,71.97 162.85,71.98
  BOTTOM w0.089: v2(157.57,81.12) 157.26,81.44 UH1.AM6
  BOTTOM w0.213: v2(211.38,37.53) 210.9,37.53 210.57,37.21 JDIMM2.126
DDR_B_MA6: length 97.5
  IN5 w0.076: v2(157.06,82.42) 157.06,79.35 157.82,78.59 157.82,77.3 158.68,76.44 159.23,76.44 161.82,73.86 161.82,73.02
  IN5 w0.145: 161.82,73.02 161.82,72.62 161.99,72.45 162.23,72.45 162.4,72.28 162.4,72.04 162.23,71.87 161.99,71.87 161.82,71.7 161.82,71.46 161.99,71.29 162.23,71.29 162.4,71.12 162.4,70.88 162.23,70.71 161.99,70.71 161.82,70.54 161.82,70.3 161.99,70.13 162.23,70.13 162.4,69.96 162.4,69.72 162.23,69.55 161.99,69.55 161.82,69.38 161.82,69.14 161.99,68.97 162.23,68.97 162.4,68.8 162.4,68.56 162.23,68.39 161.99,68.39 161.82,68.22 161.82,67.98 161.99,67.81 162.23,67.81 162.4,67.65 162.4,67.41 162.23,67.24 161.99,67.24 161.82,67.07 161.82,66.83 161.99,66.66 162.23,66.66 162.4,66.49 162.4,66.25 162.23,66.08 161.99,66.08 161.82,65.91 161.82,65.67 161.99,65.5 162.23,65.5 162.4,65.33 162.4,65.09 162.23,64.92 161.99,64.92 161.82,64.75 161.82,64.31 177.92,48.21 183.64,48.21 183.85,48 199.69,48 199.94,47.75 200.16,47.75 200.32,47.91 200.32,48.27 200.47,48.42 200.76,48.42 200.9,48.27 200.9,47.91 201.07,47.74 201.41,47.74 201.58,47.91 201.58,48.25 201.75,48.42 201.99,48.42 202.16,48.25 202.16,47.91 202.33,47.74 202.57,47.74 202.74,47.91 202.74,48.38 203,48.63 207.41,48.63 211.31,44.73 211.31,39.36 v2(210.76,38.81)
  BOTTOM w0.089: v2(157.06,82.42) 156.88,82.3 UH1.AN7
  BOTTOM w0.213: JDIMM2.127 210.83,41.75 211.37,41.21 211.37,39.42 v2(210.76,38.81)
DDR_B_MA7: length 97.3
  IN5 w0.076: v2(157.06,84.37) 156.68,83.99 156.68,82.78 156.54,82.64 156.54,82.21 156.69,82.05 156.69,77.44 157.35,76.79 157.87,76.79 158.54,76.11 158.78,76.11 160.92,73.97 160.92,73.17
  IN5 w0.145: v2(209.57,36) 210.5,36.93 210.5,38.15 210.1,38.56 210.1,43.35 210.26,43.51 210.26,44.43 208.18,46.51 205.4,46.51 205.19,46.72 199.7,46.72 199.32,47.1 183.48,47.1 183.27,47.31 176.32,47.31 170.79,52.84 170.79,53.08 171.14,53.42 171.14,53.66 170.97,53.83 170.73,53.83 170.38,53.49 170.15,53.49 169.98,53.65 169.98,53.89 170.32,54.24 170.32,54.48 170.15,54.65 169.91,54.65 169.57,54.3 169.33,54.3 169.16,54.47 169.16,54.71 169.5,55.06 169.5,55.3 169.33,55.47 169.09,55.47 168.75,55.12 168.51,55.12 168.34,55.29 168.34,55.53 168.68,55.88 168.68,56.12 166.3,58.49 166.06,58.49 165.7,58.13 165.46,58.13 165.29,58.3 165.29,58.54 165.65,58.9 165.65,59.14 160.92,63.88 160.92,73.17
  BOTTOM w0.089: UH1.AN10 156.88,84.25 v2(157.06,84.37)
  BOTTOM w0.213: v2(209.57,36) JDIMM2.122
DDR_B_MA8: length 96.1
  IN5 w0.076: 161.37,73.17 161.37,74.02 159.1,76.28 158.61,76.28 157.66,77.23 157.66,77.81 156.86,78.6 156.86,82.12 156.71,82.27 156.71,82.57 157.06,82.93 v2(157.06,83.07)
  IN5 w0.145: 161.37,73.17 161.37,64.06 166.1,59.33 166.1,59.32 166.49,58.94 169.13,56.3 169.13,56.3 169.51,55.92 170.33,55.1 170.33,55.1 170.77,54.66 171.59,53.84 171.59,53.84 172.06,53.37 172.06,53.13 171.72,52.79 171.72,52.55 171.89,52.38 172.13,52.38 172.47,52.72 172.71,52.72 172.88,52.55 172.88,52.31 172.54,51.97 172.54,51.73 172.71,51.56 172.95,51.56 173.29,51.9 173.53,51.9 173.7,51.73 173.7,51.49 173.36,51.15 173.36,50.91 173.53,50.74 173.77,50.74 174.11,51.08 174.35,51.08 174.52,50.91 174.52,50.67 174.18,50.33 174.18,50.09 174.42,49.85 174.66,49.85 174.98,50.18 175.19,50.18 175.39,49.97 175.39,49.77 175.07,49.44 175.07,49.2 175.24,49.03 175.48,49.03 175.83,49.39 176.04,49.39 176.24,49.18 176.24,48.98 175.89,48.62 175.89,48.38 176.51,47.76 183.46,47.76 183.66,47.55 199.5,47.55 199.89,47.17 203.9,47.17 204.09,47.36 204.09,47.99 204.26,48.16 204.5,48.16 204.67,47.99 204.67,47.72 204.84,47.55 205.08,47.55 205.25,47.72 205.25,47.99 205.42,48.16 205.66,48.16 205.83,47.99 205.83,47.72 206,47.55 207.81,47.55 210.71,44.64 210.71,40.16 v2(210.7,40.15)
  BOTTOM w0.089: v2(157.06,83.07) 156.88,82.95 UH1.AN8
  BOTTOM w0.213: v2(210.7,40.15) 210.7,40.93 210.32,41.3 JDIMM2.125
DDR_B_MA9: length 96.9
  IN5 w0.076: v2(155.23,85.02) 155.78,84.48 155.78,82.81 155.92,82.67 155.92,82.36 156.36,81.92 156.36,77.3 157.23,76.44 157.46,76.44 157.46,76.44 157.75,76.44 158.15,76.04 158.15,73.95 158.92,73.17
  IN5 w0.145: 158.92,73.17 159.23,72.86 159.23,72.15 159.06,71.98 158.65,71.98 158.48,71.81 158.48,71.57 158.65,71.4 159.06,71.4 159.23,71.23 159.23,70.8 159.24,70.79 159.24,70.7 159.25,70.69 159.25,70.39 159.42,70.22 159.83,70.22 160,70.05 160,69.81 159.83,69.64 159.42,69.64 159.25,69.47 159.25,69.23 159.42,69.06 159.83,69.06 160,68.89 160,68.65 159.83,68.48 159.42,68.48 159.25,68.31 159.25,67.85 159.42,67.68 159.83,67.68 160,67.51 160,67.27 159.83,67.1 159.42,67.1 159.25,66.93 159.25,66.69 159.42,66.52 159.83,66.52 160,66.35 160,66.11 159.83,65.94 159.42,65.94 159.25,65.77 159.25,65.44 159.39,65.3 159.79,65.3 159.96,65.13 159.96,64.89 159.79,64.72 159.38,64.72 159.25,64.58 159.25,64.27 159.38,64.14 159.79,64.14 159.96,63.97 159.96,63.73 159.79,63.56 159.38,63.56 159.24,63.42 159.24,62.87 175.71,46.41 182.9,46.41 183.1,46.2 198.94,46.2 199.33,45.82 204.82,45.82 205.14,45.5 207.3,45.5 208.91,43.88 v2(208.91,39.97)
  BOTTOM w0.089: UH1.AR11 v2(155.23,85.02)
  BOTTOM w0.213: v2(208.91,39.97) 209.32,40.39 JDIMM2.121
DDR_B_MA10: length 97.2
  IN5 w0.076: v2(160.72,82.42) 160.72,82.41 160.96,82.17 160.96,78.81 161.21,78.55 162.97,78.55 163.8,77.72 163.8,74.98 168.71,70.07 168.71,69.58
  IN5 w0.145: 168.71,69.58 168.71,66.42 171.35,63.79 175.3,63.79 175.4,63.68 175.4,63.68 176.1,62.99 176.1,62.98 176.22,62.86 177.04,62.04 177.04,62.04 177.74,61.35 177.86,61.22 177.86,61.22 178.56,60.53 178.56,60.53 180.14,58.94 180.14,58.7 179.65,58.21 179.65,57.97 179.82,57.8 180.06,57.8 180.55,58.29 180.79,58.29 180.96,58.12 180.96,57.88 180.47,57.39 180.47,57.15 180.64,56.98 180.88,56.98 181.37,57.47 181.61,57.47 181.78,57.3 181.78,57.06 181.29,56.57 181.29,56.33 182.73,54.89 210.06,54.89 219.02,45.93 219.02,37.91 217.53,36.41 217.02,36.41 v2(216.96,36.48)
  BOTTOM w0.076: UH1.AH7 v2(160.72,82.42)
  BOTTOM w0.213: v2(216.96,36.48) 217.16,36.48 217.58,36.06 JDIMM2.146
DDR_B_MA11: length 99.9
  IN5 w0.076: 156.56,84.52 156.52,84.48 156.52,82.85 156.38,82.71 156.38,82.14 156.53,81.99 156.53,77.37 157.3,76.6 157.82,76.6 158.47,75.95 158.66,75.95 160.45,74.16 160.45,73.17
  IN5 w0.145: 160.45,73.17 160.45,63.58 160.74,63.29 160.74,63.05 160.34,62.65 160.34,62.41 160.51,62.24 160.75,62.24 161.15,62.64 161.39,62.64 161.56,62.47 161.56,62.23 161.16,61.84 161.16,61.6 161.33,61.43 161.57,61.43 161.97,61.82 162.21,61.82 162.38,61.65 162.38,61.41 161.98,61.02 161.98,60.78 162.15,60.61 162.39,60.61 162.79,61 163.03,61 163.2,60.84 163.2,60.6 162.8,60.2 162.8,59.96 162.97,59.79 163.21,59.79 163.61,60.19 163.85,60.19 164.02,60.02 164.02,59.78 163.62,59.38 163.62,59.14 163.79,58.97 164.03,58.97 164.43,59.37 164.67,59.37 164.84,59.2 164.84,58.96 164.44,58.56 164.44,58.32 165.83,56.92 166.97,56.92 167.29,56.6 167.29,55.7 176.13,46.86 183.08,46.86 183.29,46.65 199.13,46.65 199.51,46.27 205.01,46.27 205.33,45.95 207.48,45.95 209.65,43.79 209.65,37.57 v2(209.51,37.44) ; 156.56,84.52 v2(157.06,85.02)
  BOTTOM w0.076: UH1.AN11 156.88,84.9 v2(157.06,85.02)
  BOTTOM w0.213: v2(209.51,37.44) 208.85,36.78 208.85,35.74 209.08,35.52 JDIMM2.120
DDR_B_MA12: length 95.4
  IN5 w0.076: 157.8,73.17 157.8,76.03 157.56,76.27 157.39,76.27 157.11,76.27 156.2,77.18 156.2,81.85 155.75,82.29 155.75,82.6 155.62,82.74 155.62,83.99 v2(155.23,84.37)
  IN5 w0.145: v2(208.89,38.49) 208.89,38.65 208.29,39.25 208.29,43.87 207.11,45.05 204.96,45.05 204.63,45.37 199.14,45.37 198.76,45.75 182.92,45.75 182.71,45.96 175.52,45.96 158.79,62.69 158.79,64.18 158.8,64.19 158.8,66.33 158.79,66.34 158.79,67.13 158.62,67.3 158.2,67.3 158.03,67.47 158.03,67.71 158.2,67.88 158.62,67.88 158.79,68.05 158.79,68.29 158.62,68.46 158.2,68.46 158.03,68.63 158.03,68.87 158.2,69.04 158.62,69.04 158.79,69.21 158.79,69.45 158.62,69.62 158.2,69.62 158.03,69.79 158.03,70.03 158.2,70.2 158.62,70.2 158.79,70.37 158.79,70.61 158.62,70.78 158.2,70.78 158.03,70.95 158.03,72.79 157.83,72.99 157.83,73.14 157.8,73.17
  BOTTOM w0.076: UH1.AR10 v2(155.23,84.37)
  BOTTOM w0.213: JDIMM2.119 208.83,41.36 208.24,40.78 208.24,39.14 v2(208.89,38.49)
