# Allegro board Dell_Inspiron_15_7577_Compal_CKA50_CKF50_LA_E992P_Rev_1_0_BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCH_SPI_SI_R: length 24
  BOTTOM w0.14: RE128.2 304.69,37.57 v2(305.17,38.05) 305.17,39.24 304.81,39.6 304.11,39.6 303.97,39.74 303.97,40.02 304.11,40.16 304.48,40.16 304.62,40.3 304.62,40.67 304.48,40.81 302.98,40.81 302.83,40.97 302.83,41.28 302.97,41.42 304.46,41.42 304.6,41.56 304.6,41.89 304.59,41.89 304.45,42.03 304.45,43.32 304.31,43.46 304.03,43.46 303.89,43.32 303.89,42.03 303.76,41.89 302.98,41.89 302.81,42.07 302.81,42.94 302.67,43.08 302.36,43.08 302.22,42.94 302.22,42.03 302.08,41.89 301.5,41.89 301.36,41.75 301.36,41.47 301.5,41.33 302.08,41.33 302.22,41.2 302.22,40.37 304.01,38.57 UH8.5
PCH_SPI_SO: length 54.3
  TOP w0.14: RE127.1 301,41.33 v2(301,41.24) 301,40.94 v1(301.27,40.67)
  IN2 w0.097: v2(297.89,20.55) 297.89,21.1 299.21,22.41 299.21,24.12 299.64,24.55 299.64,29.77 300.53,30.66 300.53,36.62 300.96,37.05 300.96,41.2 v2(301,41.24)
  IN4 w0.137: v2(297.89,20.55) 297.44,20.09 293.87,20.09 v2(293.47,20.49)
  IN5 w0.097: v2(293.47,20.49) 292.49,21.47 288.42,21.47 288.38,21.43 283.76,21.43 283.02,22.17 283.02,22.6 282.92,22.7 282.33,22.7 282.23,22.8 282.23,22.99 282.33,23.09 282.92,23.09 283.02,23.18 283.02,24.16 282.88,24.3 282.46,24.3 282.36,24.4 282.36,24.59 282.46,24.69 282.88,24.69 282.97,24.79 282.97,25.01 282.88,25.11 282.46,25.11 282.36,25.2 282.36,25.4 282.46,25.49 282.88,25.49 282.97,25.59 282.97,25.78 282.88,25.88 282.46,25.88 282.36,25.98 282.36,26.17 282.46,26.27 282.88,26.27 282.97,26.36 282.97,26.55 282.88,26.65 282.46,26.65 282.36,26.75 282.36,26.94 282.46,27.04 282.94,27.04 283.04,27.13 283.04,28.85 282.32,29.57 v2(282.31,29.57)
  BOTTOM w0.076: v2(282.31,29.57) 282.49,29.75 282.49,30.11 282.67,30.29 UH2.BE30
  BOTTOM w0.14: RTPM2.1 v2(293.47,20.49)
PCH_SPI_SO_R: length 22.5
  TOP w0.14: RE127.2 301.08,42.78 300.94,42.92 v4(300.94,47.53) 300.94,48.21 301.08,48.35 302.03,48.35 302.17,48.21 302.17,47.93 302.03,47.79 301.61,47.79 301.47,47.65 301.47,47.37 301.61,47.23 302.86,47.23 303,47.09 303,46.81 302.86,46.67 301.61,46.67 301.47,46.53 301.47,46.25 301.61,46.11 303.81,46.11 303.95,45.97 303.95,45.69 303.81,45.55 301.61,45.55 301.47,45.41 301.47,45.13 301.61,44.99 302.03,44.99 302.17,44.85 302.17,44.57 302.03,44.43 301.61,44.43 301.47,44.29 v2(301.47,43.53)
  BOTTOM w0.14: UH8.2 v2(301.47,43.53)
PCH_SPI_WP#: length 199.9
  TOP w0.14: v2(301.79,40.86) 301.79,41.16 RE129.1 303.57,41.86 v1(303.72,41.71) ; v2(198.36,65.66) 197.7,65.66 RH519.2
  IN1 w0.097: v2(226.43,62.45) 232.58,62.45 234.04,60.99 237,60.99 238.21,62.2 263.09,62.2 265.48,59.81 268.2,59.81 273.22,54.8 273.22,47.9 275.57,45.55 275.57,42.07 275.9,41.73 275.9,38.94 276.9,37.94 276.9,34.8 277.3,34.4 277.58,34.4 280.72,31.25 281.68,31.25 282.74,30.19 282.74,29.05 282.42,28.73 v2(282.42,28.54)
  IN2 w0.097: v2(301.79,40.86) 301.79,37.57 300.76,36.53 300.76,30.57 299.89,29.7 299.89,27.14 301.03,26 302.3,26 302.93,25.36 302.93,24.41 303.11,24.23 303.11,21.45 301.51,19.85 301.51,18.74 v2(301.28,18.51) ; v2(282.42,28.54) 282.14,28.26 282.14,27.13 279.6,24.58 279.6,22.91 280.13,22.37 280.13,22.11 280.23,22.02 280.38,22.02 280.47,21.92 280.47,21.73 280.38,21.63 280.2,21.63 280.11,21.53 280.11,21.34 280.2,21.24 280.38,21.24 280.47,21.15 280.47,20.95 280.38,20.86 280.2,20.86 280.11,20.76 280.11,20.57 280.2,20.47 280.38,20.47 280.47,20.38 280.47,20.18 280.38,20.09 280.2,20.09 280.11,19.99 280.11,19.8 280.2,19.7 280.38,19.7 280.47,19.6 280.47,19.41 280.38,19.31 279.7,19.31 279.6,19.22 279.6,19.02 279.7,18.93 280.38,18.93 280.47,18.83 280.47,18.64 280.38,18.54 279.7,18.54 279.6,18.44 279.6,18.25 279.7,18.16 280.38,18.16 280.47,18.06 280.47,17.8 280.39,17.72 279.67,17.72 279.59,17.64 279.59,17.4 279.67,17.33 280.37,17.33 280.47,17.22 280.47,15.5 280.34,15.37 280.06,15.37 279.95,15.48 v2(279.95,16.92)
  IN3 w0.124: v2(279.95,16.92) 281.8,15.06 287.88,15.06 288.95,16.13 295.16,16.13 295.49,15.8 298.25,15.8 300.51,18.06 300.84,18.06 v2(301.28,18.51)
  IN4 w0.137: v2(198.36,65.66) 197.72,65.02 197.72,62.55 199.95,60.32 199.95,59.16 201.22,57.89 202.82,57.89 203.67,57.03 206.97,57.03 207.98,56.03 217.24,56.03 220.36,59.15 220.36,60.29 221.77,61.7 223.46,61.7 224.01,62.25 226.03,62.25 226.23,62.45 v2(226.43,62.45)
  BOTTOM w0.076: v2(282.42,28.54) 282.87,28.99 282.87,30.01 283.08,30.22 283.08,30.94 283.23,31.09 UH2.BC29
PCH_SPI_WP#_R: length 4.4
  TOP w0.14: RE129.2 303.59,42.78 303.73,42.92 v1(303.73,43.13) 303.73,43.39 303.59,43.53 v2(302.74,43.53)
  BOTTOM w0.14: UH8.3 v2(302.74,43.53)
PCH_SRTCRST#: length 6.7
  TOP w0.14: v2(292.72,31.9) 292.49,31.67 CH52.1 292.88,30.36 293.82,30.36 294.18,29.99 v4(294.18,29.03) 295.16,28.05 RH83.2
  BOTTOM w0.076: UH2.BB10 292.38,31.81 292.48,31.91 292.71,31.91 v2(292.72,31.9)
PCH_SYS_PWROK_XDP: length 8.2
  TOP w0.14: v1(196.85,58.89) 196.38,58.42 RH524.2 ; RH524.2 RH521.2 ; RH524.2 RH525.2 198.18,58.8 v2(198.18,59.26)
  BOTTOM w0.14: v2(198.18,59.26) 198.18,59.65 198.67,60.14 199.07,60.14 199.37,60.43 JXDP1.47
PCH_TRIGGER: length 171.6
  TOP w0.14: v1(299.81,37.42) 299.08,36.69 v2(298.93,36.69) ; v2(184.84,96.98) 184.19,96.98 RH167.1
  IN1 w0.097: v2(184.84,96.98) 185.42,96.98 188.46,93.94 188.46,79.58 189.84,78.2 189.84,76.3 192.06,74.07 192.06,69.8 192.66,69.21 192.66,68.51 192.17,68.03 192.17,65.71 195.28,62.6 196.73,62.6 197.46,61.86 210.99,61.86 211.19,62.06 213.81,62.06 214.21,62.46 217.67,62.46 219.55,64.33 224.42,64.33 225.21,65.12 229.34,65.12 229.47,64.99 264.83,64.99 267.31,62.51 276.64,62.51 278.57,60.58 278.57,58.68 282.25,55 282.25,51.74 283.26,50.73 283.26,46.19 284.63,44.82 287.39,44.82 287.97,44.24 287.97,42.97 288.25,42.69 289.12,42.69 290.44,41.37 290.44,39.8 290.09,39.45 290.09,37.42 291.73,35.78 292.34,35.78 292.62,36.06 295.8,36.06 295.96,35.89 298.13,35.89 v2(298.93,36.69)
  BOTTOM w0.076: v2(298.93,36.69) 298.55,36.69 298.03,37.21 296.57,37.21 296.49,37.29 UH2.AL2
PCH_TRIGGER_R: length 9
  TOP w0.102: 178.22,96.16 178.08,96.16 177.59,95.68 177.3,95.68 176.57,94.95 v1(176.57,94.66) 176.57,94.39 176.1,93.92 v2(176.07,93.92)
  TOP w0.14: 178.22,96.16 182.27,96.16 182.85,96.74 RH167.2
  BOTTOM w0.076: UH1.H23 175.7,94.29 v2(176.07,93.92)
PCH_XDP_CLK_N: length 116.9
  IN1 w0.104: v2(200.83,66.18) 200.85,66.21 200.85,66.86 201.24,67.24 211.53,67.24 213.01,65.76 215.93,65.76 217.85,67.69 265.76,67.69 268.37,65.07 278.36,65.07 280.74,62.69 282.49,62.69 286.85,58.34 286.85,57.24 287.99,56.1 287.99,54.45 287.68,54.15 287.68,51.79 289.02,50.45 290.68,50.45 292.87,48.27 295.88,48.27 298.06,46.09 298.06,45.35 v2(298.08,45.33)
  BOTTOM w0.076: v2(298.08,45.33) 297.87,45.54 297.87,46.08 297.41,46.54 296.88,46.54 296.8,46.61 296.8,47 UH2.L1
  BOTTOM w0.14: JXDP1.42 200.87,66.23 v2(200.83,66.18)
PCH_XDP_CLK_P: length 116.9
  IN1 w0.104: v2(297.49,45.33) 297.49,45.54 297.59,45.63 297.79,45.63 297.86,45.71 297.86,46.01 295.8,48.07 292.79,48.07 290.6,50.26 288.94,50.26 287.49,51.71 287.49,54.23 287.79,54.53 287.79,56.02 286.65,57.16 286.65,58.26 282.41,62.5 280.66,62.5 278.28,64.88 268.29,64.88 265.68,67.49 217.93,67.49 216.01,65.57 212.93,65.57 211.45,67.05 201.32,67.05 201.11,66.85 201.11,66.47 201.4,66.18 v2(201.41,66.18)
  BOTTOM w0.076: v2(297.49,45.33) 297.7,45.54 297.7,46.01 297.34,46.37 296.81,46.37 296.64,46.54 296.64,46.65 296.29,46.99 UH2.L2
  BOTTOM w0.14: v2(201.41,66.18) 201.19,66.4 201.19,66.62 201.37,66.8 JXDP1.40
PCIE_PRX_LANTX_N5: length 283.1
  IN5 w0.104: v2(287.21,48.14) 287.21,47.98 286.83,47.59 285.28,47.59 284.17,46.48 283.42,46.48 282.49,45.56 281.71,45.56 281.45,45.3 280.54,45.3 279.4,46.44 277.41,46.44 276.28,45.31 265.86,45.31 264.56,44.01 264.56,38.86 260.73,35.02 258.07,35.02 257.15,34.1 254.23,34.1 251.69,31.56 246.5,31.56 245.11,30.17 230.4,30.17 230,29.77 221.84,29.77 220.5,28.43 179.99,28.43 179.5,28.92 163.08,28.92 161.97,27.81 140.61,27.81 139.21,29.21 108.4,29.21 107.8,29.81 104.02,29.81 102.65,28.45 65.07,28.45 61.86,31.65 38.06,31.65 37.42,32.29 34.36,32.29 32.75,33.9 32.75,37.42 32.1,38.07 32.1,40.38 31.59,40.89 31.59,41.84 v2(31.78,42.03)
  BOTTOM w0.076: UH2.K19 287.5,48.14 v2(287.21,48.14)
  BOTTOM w0.14: CL31.1 30.02,40.67 31.06,40.67 31.65,41.26 31.65,41.9 v2(31.78,42.03)
PCIE_PRX_LANTX_N5_C: length 3.7
  BOTTOM w0.14: CL31.2 28.94,40.71 28.35,40.71 28.02,41.05 28.02,41.51 27.33,42.19 UL1.18
PCIE_PRX_LANTX_P5: length 283.1
  IN5 w0.104: v2(287.21,47.4) 285.36,47.4 284.25,46.29 283.5,46.29 282.57,45.36 281.79,45.36 281.53,45.11 280.46,45.11 279.32,46.25 277.49,46.25 276.36,45.11 265.94,45.11 264.76,43.93 264.76,38.78 260.81,34.82 258.15,34.82 257.23,33.9 254.31,33.9 251.77,31.36 246.58,31.36 245.19,29.97 230.48,29.97 230.08,29.57 221.92,29.57 220.58,28.24 179.91,28.24 179.42,28.72 163.16,28.72 162.05,27.61 140.53,27.61 139.13,29.02 108.32,29.02 107.72,29.62 104.1,29.62 102.73,28.25 64.99,28.25 61.78,31.46 37.98,31.46 37.34,32.1 34.28,32.1 32.56,33.82 32.56,37.34 31.91,37.99 31.91,40.3 31.4,40.81 31.4,41.82 v2(31.19,42.03)
  BOTTOM w0.076: UH2.L19 287.48,47.4 v2(287.21,47.4)
  BOTTOM w0.14: CL30.1 29.96,41.43 30.34,41.05 30.34,41.05 30.47,40.92 30.95,40.92 31.4,41.37 31.4,41.82 v2(31.19,42.03)
PCIE_PRX_LANTX_P5_C: length 3.7
  BOTTOM w0.14: CL30.2 28.93,41.56 28.79,41.42 28.79,41.18 28.61,40.99 28.43,40.99 28.27,41.15 28.27,41.62 v3(28,41.89) 27.58,42.31 27.58,42.72 27.73,42.87 UL1.17
PCIE_PRX_SSDTX_N10: length 51
  IN2 w0.104: v2(282.58,49.09) 282.57,49.18 282.69,49.33 282.84,49.33 282.99,49.18 282.99,46.06 282.24,45.31 281.64,45.31 280.57,44.24 279.64,44.24 279.49,44.38 276.63,44.38 276.34,44.67 272.87,44.67 270.42,42.22 270.42,33.13 270.66,32.89 270.66,29.11 270.48,28.94 270.48,28.03 270.68,27.84 270.9,27.84 v2(271.11,27.64)
  BOTTOM w0.076: UH2.G29 283.03,49.25 282.83,49.05 282.62,49.05 v2(282.58,49.09)
  BOTTOM w0.14: JNGFF2.29 274.55,18.78 274.79,18.53 275.16,18.53 275.51,18.89 275.51,25.19 276.17,25.84 276.17,27.55 275.97,27.75 272.37,27.75 272.23,27.61 272.23,27.33 272.09,27.19 271.83,27.19 271.69,27.33 271.69,27.59 271.53,27.75 271.22,27.75 v2(271.11,27.64)
PCIE_PRX_SSDTX_N11: length 42
  IN2 w0.104: v2(281.39,46.84) 281.52,46.84 281.68,46.69 281.68,46.54 281.47,46.34 281.32,46.34 281.11,46.55 280.93,46.55 279.61,45.23 272.04,45.23 270.01,43.2 270.01,32.96 270.25,32.72 270.25,29.28 270.07,29.11 270.07,23.67 268.74,22.33 268.74,21.9 268.92,21.71 269.02,21.71 269.41,22.09 v2(269.41,22.1)
  BOTTOM w0.076: UH2.L31 281.85,47.05 281.85,46.92 281.78,46.84 v2(281.39,46.84)
  BOTTOM w0.14: v2(269.41,22.1) 269.57,21.94 271.84,21.94 272.1,21.68 272.96,21.68 273.06,21.78 JNGFF2.17
PCIE_PRX_SSDTX_N12: length 42.8
  IN2 w0.104: v2(267.68,23.91) 267.81,24.04 267.81,24.51 268.22,24.93 268.22,29.49 268.84,30.11 268.84,32.11 268.61,32.35 268.61,36.38 267.97,37.02 267.97,38.68 267.98,38.68 267.98,44.11 271.46,47.59 278.62,47.59 280.01,48.97 v2(280.39,48.97)
  BOTTOM w0.089: UH2.G33 280.57,49.22 280.39,49.04 v2(280.39,48.97)
  BOTTOM w0.14: v2(267.68,23.91) 267.82,24.05 267.82,24.36 268.04,24.59 268.23,24.78 JNGFF2.5
PCIE_PRX_SSDTX_P10: length 51
  IN2 w0.104: v2(282.51,49.74) 282.51,49.66 282.62,49.56 282.89,49.56 283.19,49.26 283.19,45.98 282.32,45.11 281.72,45.11 280.65,44.04 279.56,44.04 279.41,44.19 276.55,44.19 276.26,44.48 272.95,44.48 270.61,42.14 270.61,33.21 270.85,32.97 270.85,29.03 270.68,28.86 270.68,28.11 270.76,28.03 270.92,28.03 v2(271.11,28.22)
  BOTTOM w0.076: UH2.E29 282.61,49.74 v2(282.51,49.74)
  BOTTOM w0.14: v2(271.11,28.22) 271.33,28 276.08,28 276.42,27.66 276.42,25.74 275.77,25.08 275.77,18.78 275.26,18.28 JNGFF2.31
PCIE_PRX_SSDTX_P11: length 41.9
  IN2 w0.104: v2(281.41,47.46) 281.41,47.44 280.98,47.01 280.98,46.87 279.53,45.42 271.96,45.42 269.82,43.28 269.82,32.88 270.06,32.64 270.06,29.36 269.88,29.19 269.88,23.75 268.54,22.41 268.54,21.82 268.84,21.52 v2(269.41,21.52)
  BOTTOM w0.076: v2(281.41,47.46) 281.8,47.85 UH2.K31
  BOTTOM w0.14: v2(269.41,21.52) 269.57,21.68 271.74,21.68 271.99,21.43 272.9,21.43 273.05,21.28 JNGFF2.19
PCIE_PRX_SSDTX_P12: length 42.8
  IN2 w0.104: v2(268.26,23.91) 268.26,23.91 268,24.17 268,24.43 268.42,24.85 268.42,29.41 269.04,30.03 269.04,32.19 268.81,32.43 268.81,36.46 268.17,37.1 268.17,38.6 268.17,38.6 268.17,44.03 271.54,47.4 278.7,47.4 279.95,48.65 280.15,48.65 280.36,48.43 v2(280.36,48.2)
  BOTTOM w0.089: v2(280.36,48.2) 280.62,48.46 UH2.H33
  BOTTOM w0.14: v2(268.26,23.91) 268.24,23.91 268.08,24.08 268.08,24.26 268.22,24.41 268.42,24.41 268.66,24.17 269.01,24.17 269.36,24.52 269.78,24.52 269.95,24.35 270.38,24.35 270.55,24.52 272.79,24.52 273.04,24.28 JNGFF2.7
PCIE_PRX_TBTTX_N1: length 70.8
  IN4 w0.147: v2(346.56,49.69) 346.71,49.83 347.02,49.83 347.17,49.68 347.17,49.36 347.17,48.08 346.78,47.69 346.06,47.69 345.79,47.96 340.81,47.96 336.46,52.31 334.21,52.31 333.98,52.31 333.51,51.83 330.89,51.83 330.55,51.83 330.22,51.5 328.64,51.5 319.2,51.5 319.09,51.61 311.55,51.61 311.54,51.62 310.74,51.62 310.51,51.85 309.79,51.85 309.21,52.42 306.5,52.42 305.18,53.74 303.27,53.74 302.59,54.42 302.33,54.42 302.33,54.43 299.15,54.43 299.14,54.44 296.78,54.44 296.77,54.45 296.41,54.45 295.33,55.52 292.33,55.52 291.15,54.35 291.15,52.22 289.82,50.88 289.82,49.33 290.01,49.14 290.31,49.14 v2(290.57,48.88)
  BOTTOM w0.076: UH2.H15 290.23,48.54 v2(290.57,48.88)
  BOTTOM w0.14: v2(346.56,49.69) 346.69,49.81 347.09,49.81 CT16.1
PCIE_PRX_TBTTX_N1_C: length 3.5
  BOTTOM w0.094: UT1.V22 349.99,51.21 349.92,51.21 349.92,51.21 349.58,51.21 348.84,51.21 348.34,50.7 348.34,50.13 348.15,49.94 348.04,49.94 347.96,49.85
  BOTTOM w0.14: 347.96,49.85 347.8,49.7 CT16.2
PCIE_PRX_TBTTX_N2: length 77.9
  IN4 w0.147: v2(289.3,48.99) 289.09,48.79 289.09,48.6 289.27,48.42 289.6,48.42 289.81,48.63 290.02,48.63 290.3,48.35 291.12,48.35 291.36,48.59 291.36,48.8 291.02,49.14 291.02,49.43 291.17,49.58 291.42,49.58 291.78,49.22 291.99,49.22 292.19,49.42 292.19,50.63 292.2,50.64 292.2,51.24 292.2,51.46 293.16,52.42 295.3,52.42 296.58,53.7 302.23,53.7 302.91,53.02 304.88,53.02 306.2,51.7 308.8,51.7 309.92,50.57 318.49,50.57 319.44,49.62 323.37,49.62 324.53,50.78 330.64,50.78 330.89,51.02 336.72,51.02 340.51,47.23 345.21,47.23 345.78,46.66 347.59,46.66 348.44,47.51 348.44,48.87 348.32,49 348.32,52.18 348.06,52.43 346.77,52.43 v2(346.56,52.23)
  BOTTOM w0.076: v2(289.3,48.99) 289.3,49.71 UH2.E17
  BOTTOM w0.14: CT2.1 347.09,52.35 346.68,52.35 v2(346.56,52.23)
PCIE_PRX_TBTTX_N2_C: length 2.9
  BOTTOM w0.076: 347.96,52.38 348.04,52.38 348.11,52.45 348.21,52.45 348.87,53.11 349.54,53.11 349.59,53.06 350,53.06 UT1.P22
  BOTTOM w0.14: CT2.2 347.96,52.38
PCIE_PRX_TBTTX_N3: length 90
  IN4 w0.147: v2(288.39,47.34) 288.42,47.31 288.75,47.29 288.93,47.11 291.42,47.11 291.73,46.79 292.35,46.17 302.51,46.17 302.96,45.71 306.7,45.71 306.92,45.93 307.35,45.93 307.58,45.93 308.12,45.93 309.44,47.24 313.37,47.24 314.4,46.22 318.07,46.22 319.67,44.62 320.55,44.62 320.56,44.61 323.45,44.61 323.87,45.03 329.57,45.03 329.68,45.03 329.68,45.03 329.74,45.03 330.56,44.22 330.56,44.15 330.56,43.46 331.66,42.35 332.05,42.35 332.06,42.34 336.49,42.34 336.5,42.35 336.73,42.35 337.07,42.35 338.32,43.6 341.03,43.6 341.37,43.6 341.59,43.82 342.29,43.82 342.61,44.14 343.71,44.14 344.03,43.82 347,43.82 347.44,43.39 350.38,43.39 352.15,45.15 352.15,47.23 352.08,47.3 352.08,47.3 351.45,47.94 351.45,48.05 351.45,48.06 351.45,48.64 351.45,48.65 351.45,48.73 352.56,49.84 353.64,49.84 353.8,50 353.8,50.04 353.91,50.15 353.91,50.38 353.91,51.68 353.6,51.99 352.36,51.99 352.08,52.26 352.08,53.27 351.38,53.97 349.29,53.97 347.91,55.35 v2(346.11,55.35)
  BOTTOM w0.076: v2(288.39,47.34) 288.71,47.02 UH2.L17
  BOTTOM w0.14: v2(346.11,55.35) 346.25,55.21 347.03,55.21 CT108.1
PCIE_PRX_TBTTX_N3_C: length 2.7
  BOTTOM w0.094: 348.04,55.19 349.44,55.19 349.59,55.35 349.96,55.35 350.01,55.3 UT1.K22
  BOTTOM w0.14: 348.04,55.19 347.83,55.4 CT108.2
PCIE_PRX_TBTTX_N4: length 75.2
  IN4 w0.147: v2(288.25,50.37) 288.25,50.33 288.1,50.19 287.93,50.2 287.93,50.2 287.79,50.33 287.79,50.54 287.94,50.69 287.94,50.93 288.08,51.08 288.32,51.08 288.47,51.23 288.47,51.44 288.32,51.59 288.1,51.59 287.95,51.74 287.95,52.23 287.57,52.61 287.57,53.43 286.67,54.33 286.67,58.06 288.39,59.78 299.39,59.78 301.37,57.8 304.31,57.8 304.31,57.79 304.32,57.79 304.97,57.15 306.61,57.15 307.35,56.41 310.05,56.41 310.98,55.49 318.59,55.49 318.7,55.48 320.06,55.48 320.12,55.49 324.55,55.49 324.89,55.82 329.34,55.82 330.98,57.47 333.5,57.47 334.63,58.59 344.19,58.59 344.21,58.58 344.21,58.58 345.17,57.62 345.78,57.62 346.09,57.31 v2(346.11,57.31)
  BOTTOM w0.076: UH2.E20 287.74,50.11 288,50.37 v2(288.25,50.37)
  BOTTOM w0.14: CT110.1 347.09,57.43 346.24,57.43 v2(346.11,57.31)
PCIE_PRX_TBTTX_N4_C: length 2.7
  BOTTOM w0.094: 347.96,57.24 348.07,57.12 348.78,57.12 349.17,56.73 349.99,56.73 UT1.F22
  BOTTOM w0.14: CT110.2 347.89,57.31 347.96,57.24
PCIE_PRX_TBTTX_P1: length 70.7
  IN4 w0.147: v2(290.56,49.55) 290.44,49.43 290.13,49.43 290.11,49.45 290.11,50.76 291.44,52.1 291.44,54.23 292.45,55.24 295.21,55.24 296.3,54.15 302.42,54.15 303.1,53.47 305.07,53.47 306.39,52.15 309.1,52.15 309.68,51.57 310.4,51.57 310.63,51.34 311.43,51.34 311.43,51.34 318.98,51.34 319.08,51.23 328.53,51.23 330.33,51.23 330.67,51.56 330.78,51.56 333.62,51.56 334.09,52.03 336.35,52.03 340.7,47.69 345.67,47.69 345.95,47.41 346.89,47.41 347.45,47.97 347.45,49.47 347.45,49.47 347.45,49.79 347.13,50.11 346.72,50.11 v2(346.56,50.27)
  BOTTOM w0.076: UH2.G15 290.32,49.3 v2(290.56,49.55)
  BOTTOM w0.14: v2(346.56,50.27) 346.71,50.12 347.02,50.12 CT14.1
PCIE_PRX_TBTTX_P1_C: length 3.5
  BOTTOM w0.094: 347.96,50.17 348,50.12 348.07,50.12 348.15,50.21 348.15,50.78 348.77,51.39 349.39,51.39 349.43,51.43 349.43,51.61 349.48,51.67 349.81,51.67 349.85,51.62 349.85,51.53 UT1.V23
  BOTTOM w0.14: CT14.2 347.96,50.17
PCIE_PRX_TBTTX_P2: length 77.9
  IN4 w0.147: v2(288.52,49.08) 288.81,48.8 288.81,48.48 289.13,48.15 289.15,48.15 289.22,48.08 291.24,48.08 292.47,49.31 292.47,50.51 292.48,50.52 292.48,51.35 293.27,52.14 295.41,52.14 296.69,53.42 302.12,53.42 302.8,52.74 304.77,52.74 306.09,51.42 308.68,51.42 309.81,50.3 318.37,50.3 319.33,49.34 323.49,49.34 324.64,50.5 330.76,50.5 330.99,50.74 336.62,50.74 340.4,46.96 345.09,46.96 345.67,46.38 347.71,46.38 348.72,47.39 348.72,48.99 348.59,49.11 348.59,52.29 348.07,52.81 v2(346.56,52.81)
  BOTTOM w0.076: v2(288.52,49.08) 288.38,49.22 288.38,49.36 288.63,49.61 288.78,49.61 288.94,49.46 UH2.G17
  BOTTOM w0.14: CT12.1 347.03,52.67 346.7,52.67 v2(346.56,52.81)
PCIE_PRX_TBTTX_P2_C: length 2.9
  BOTTOM w0.076: 347.96,52.71 347.96,52.69 348.03,52.61 348.14,52.61 348.88,53.35 348.88,53.55 348.95,53.62 349.11,53.62 349.18,53.55 349.18,53.35 349.26,53.27 UT1.P23
  BOTTOM w0.14: CT12.2 347.96,52.71
PCIE_PRX_TBTTX_P3: length 89.9
  IN4 w0.147: v2(288.43,47.97) 288.43,47.94 288.76,47.57 288.86,47.57 289.05,47.38 289.45,47.38 289.7,47.63 290.01,47.63 290.25,47.38 290.62,47.38 290.86,47.63 291.29,47.63 291.85,47.06 292.47,46.44 302.62,46.44 303.08,45.99 306.59,45.99 306.81,46.2 307.46,46.2 307.47,46.2 308.01,46.2 309.32,47.52 313.48,47.52 314.51,46.49 318.19,46.49 319.79,44.89 320.66,44.89 320.67,44.88 323.34,44.88 323.76,45.3 329.45,45.3 329.86,45.3 330.83,44.33 330.83,44.04 330.83,44.04 330.83,43.57 331.77,42.63 336.85,42.63 336.96,42.63 338.21,43.88 341.14,43.88 341.26,43.88 341.48,44.1 342.18,44.1 342.49,44.41 343.83,44.41 344.15,44.1 347.11,44.1 347.55,43.66 350.27,43.66 351.87,45.27 351.87,47.12 351.81,47.18 351.81,47.19 351.17,47.83 351.17,48.17 351.18,48.17 351.18,48.53 351.17,48.53 351.17,48.9 352.4,50.13 353.5,50.13 353.64,50.27 353.64,51.34 353.64,51.56 353.49,51.71 352.56,51.71 352.22,51.71 351.76,52.17 351.76,53.2 351.26,53.7 349.17,53.7 347.8,55.08 347.38,55.08 347.14,54.83 346.93,54.83 346.69,55.08 346.45,55.08 346.14,54.77 v2(346.11,54.77)
  BOTTOM w0.076: v2(288.43,47.97) 288.73,47.67 288.84,47.67 UH2.K17
  BOTTOM w0.14: CT109.1 347.08,54.9 346.25,54.9 v2(346.11,54.77)
PCIE_PRX_TBTTX_P3_C: length 2.7
  BOTTOM w0.089: UT1.K23 349.91,55.11 349.95,55.07
  BOTTOM w0.094: 349.95,55.07 349.95,54.94 349.89,54.88 349.59,54.88 349.47,55.01 348.13,55.01 348.02,54.89 347.96,54.89
  BOTTOM w0.14: 347.96,54.89 347.93,54.89 CT109.2
PCIE_PRX_TBTTX_P4: length 75.3
  IN4 w0.147: v2(346.11,57.89) 345.3,57.89 344.33,58.86 334.4,58.86 333.28,57.74 330.87,57.74 329.22,56.1 324.78,56.1 324.44,55.76 320.1,55.76 320.04,55.75 318.71,55.75 318.6,55.76 311.09,55.76 310.16,56.69 307.46,56.69 306.72,57.42 305.08,57.42 304.44,58.07 304.43,58.07 304.42,58.08 304.39,58.08 304.38,58.08 301.48,58.08 299.51,60.05 288.28,60.05 288,59.78 287.99,59.78 286.39,58.18 286.39,54.21 287.28,53.31 287.28,52.5 287.66,52.12 287.66,50.82 287.5,50.66 287.5,50.24 287.8,49.93 288.04,49.92 v2(288.23,49.71)
  BOTTOM w0.076: UH2.G19 288.05,49.4 288.23,49.58 v2(288.23,49.71)
  BOTTOM w0.14: v2(346.11,57.89) 346.19,57.81 347.09,57.81 CT111.1
PCIE_PRX_TBTTX_P4_C: length 2.7
  BOTTOM w0.094: 347.96,57.8 347.96,57.71 348.36,57.31 348.86,57.31 349.23,56.94 349.36,56.94 349.41,56.99 349.41,57.07 349.51,57.16 349.67,57.16 349.75,57.08 UT1.F23
  BOTTOM w0.14: CT111.2 347.82,57.94 347.96,57.8
PCIE_PRX_WLANTX_N6: length 68.5
  IN4 w0.147: v2(287.02,49.04) 287.08,49.1 287.08,49.31 286.94,49.46 286.73,49.46 286.57,49.3 286.57,48.78 286.77,48.58 286.77,46.99 287.13,46.64 288.47,46.64 288.66,46.45 290.97,46.45 291.38,46.04 291.38,44.83 291.82,44.4 294.59,44.4 295.09,44.9 298.26,44.9 298.81,45.46 302.27,45.46 302.67,45.06 308.18,45.06 309.71,46.59 313.1,46.59 314.13,45.56 317.8,45.56 320.19,43.17 325.57,43.17 325.89,43.49 329.26,43.49 331.31,41.45 341.15,41.45 341.52,41.81 341.52,42.11 342.39,42.98 342.85,42.98 343.16,43.29 v2(343.18,43.29)
  BOTTOM w0.102: UH2.G22 v2(287.02,49.04)
  BOTTOM w0.14: v2(343.18,43.29) 343.58,43.29 344.08,43.8 JNGFF1.35
PCIE_PRX_WLANTX_P6: length 68.4
  IN4 w0.147: v2(343.18,42.71) 342.5,42.71 341.79,42 341.79,41.7 341.26,41.17 331.2,41.17 329.15,43.22 326,43.22 325.68,42.9 320.07,42.9 317.69,45.29 314.01,45.29 312.98,46.31 309.82,46.31 308.29,44.78 302.56,44.78 302.16,45.18 298.93,45.18 298.37,44.63 295.21,44.63 294.7,44.12 291.7,44.12 291.11,44.72 291.11,45.93 290.86,46.18 288.55,46.18 288.36,46.36 287.02,46.36 286.5,46.88 286.5,48.47 286.3,48.67 286.3,49.79 v2(286.3,49.79)
  BOTTOM w0.102: v2(286.3,49.79) 286.3,49.84 286.62,50.17 UH2.E22
  BOTTOM w0.14: JNGFF1.33 343.94,43.3 343.57,42.93 343.4,42.93 v2(343.18,42.71)
PCIE_PTX_LANRX_N5: length 291
  IN5 w0.104: v2(32.36,44.94) 32.22,44.8 32.03,44.8 31.94,44.88 31.76,44.88 31.59,44.71 31.59,43.52 32.87,42.23 32.87,38.95 34.29,37.53 34.29,36.22 35.38,35.13 35.38,33.96 36.46,32.89 37.73,32.89 38.35,32.28 62.09,32.28 63.2,31.17 68.04,31.17 69.76,29.45 82.49,29.45 84.38,31.35 108.09,31.35 109.63,29.81 139.46,29.81 140.03,29.24 155.6,29.24 155.88,29.52 179.78,29.52 180.27,29.03 220.25,29.03 221.59,30.37 229.75,30.37 230.15,30.77 244.86,30.77 246.25,32.16 251.44,32.16 253.98,34.7 256.9,34.7 263.96,41.76 263.96,44.27 267.92,48.23 269.45,48.23 271.18,49.96 271.18,51.08 277.85,57.75 283.4,57.75 v2(283.76,58.12)
  BOTTOM w0.076: 285.6,55.15 285.6,55.08 286.17,54.51 286.17,53.71 286.79,53.08 286.79,51.26 286.72,51.18 286.72,51.05 286.5,50.83 UH2.D22
  BOTTOM w0.14: CL48.1 31.73,44.45 32.22,44.94 v2(32.36,44.94) ; v2(283.76,58.12) 285.01,58.12 285.6,57.53 285.6,55.15
PCIE_PTX_LANRX_N5_C: length 1.7
  BOTTOM w0.14: UL1.14 28.87,44.74 28.93,44.8 29.59,44.8 CL48.2
PCIE_PTX_LANRX_P5: length 290.9
  IN5 w0.104: v2(31.92,45.31) 31.39,44.79 31.39,43.44 32.68,42.15 32.68,38.87 34.1,37.45 34.1,36.14 35.19,35.05 35.19,33.88 36.38,32.7 37.65,32.7 38.27,32.08 62.01,32.08 63.12,30.98 67.96,30.98 69.68,29.26 82.57,29.26 84.46,31.15 108.01,31.15 109.55,29.62 139.38,29.62 139.95,29.05 155.68,29.05 155.96,29.33 179.7,29.33 180.19,28.84 220.33,28.84 221.67,30.18 229.83,30.18 230.23,30.58 244.94,30.58 246.33,31.97 251.52,31.97 254.06,34.51 256.98,34.51 264.15,41.68 264.15,44.19 268,48.03 269.53,48.03 271.37,49.88 271.37,51 277.93,57.56 283.74,57.56 v2(283.76,57.53)
  BOTTOM w0.076: UH2.C22 286.4,51.23 286.4,51.33 286.63,51.56 286.63,53.02 286.51,53.13 286.4,53.13 286.28,53.01 286.18,53.01 286.07,53.12 286.07,53.23 286.19,53.35 286.19,53.46 286.01,53.64 286.01,53.8 285.93,53.88 285.83,53.88 285.76,53.96 285.76,54.1 285.84,54.19 285.93,54.19 286.01,54.26 286.01,54.44 285.43,55.02 285.43,55.04 285.34,55.13 285.34,55.15
  BOTTOM w0.14: CL47.1 31.45,44.73 31.65,44.73 31.92,45 v2(31.92,45.31) ; v2(283.76,57.53) 283.98,57.75 285.01,57.75 285.34,57.42 285.34,55.15
PCIE_PTX_LANRX_P5_C: length 1.7
  BOTTOM w0.14: CL47.2 29.65,45.05 28.93,45.05 28.85,45.14 UL1.13
PCIE_PTX_SSDRX_N10: length 55.1
  IN2 w0.104: v2(280.93,53.16) 280.93,53.19 280.74,53.39 280.56,53.39 280.48,53.31 280.48,52.97 280.67,52.78 280.67,52.63 280.48,52.44 280.48,52.29 280.97,51.79 280.97,50.83 280.56,50.42 280.28,50.42 278.53,48.68 276.9,48.68 276.6,48.37 270.83,48.37 269.98,47.52 268.85,47.52 265.88,44.56 265.88,34.47 267.06,33.3 267.06,32.5 267.77,31.78 267.86,31.78 268.38,31.26 268.38,30.42 267.76,29.8 267.76,25.05 267.21,24.49 267.21,21.72 268.62,20.31 268.62,19.47 269,19.09 v2(269.01,19.09)
  BOTTOM w0.076: UH2.C32 281.12,51.18 281.12,51.79 281.05,51.85 281.05,52.23 281.28,52.46 281.28,53 281.21,53.08 281.01,53.08 v2(280.93,53.16)
  BOTTOM w0.14: CD45.1 269.65,17.24 269.29,16.89 268.99,16.89 268.85,17.03 268.85,17.77 268.99,17.91 269.01,17.91 269.15,18.05 269.15,18.33 269.01,18.47 268.99,18.47 268.85,18.61 268.85,18.92 v2(269.01,19.09)
PCIE_PTX_SSDRX_N10_C: length 3.5
  BOTTOM w0.14: JNGFF2.35 273.03,17.28 272.92,17.17 272.09,17.17 271.92,17 270.88,17 CD45.2
PCIE_PTX_SSDRX_N11: length 50.9
  IN2 w0.104: v2(266.99,21.08) 266.99,20.83 266.85,20.69 266.65,20.69 266.46,20.89 266.46,24.66 267.16,25.36 267.16,31.55 266.46,32.25 266.46,33.05 265.28,34.23 265.28,44.84 268.57,48.13 269.63,48.13 271.08,49.58 275.63,49.58 275.77,49.72 278.66,49.72 279.5,50.56 279.5,51.6 279.61,51.7 279.85,51.7 279.96,51.81 279.96,51.95 279.85,52.06 279.61,52.06 279.5,52.16 279.5,52.5 279.66,52.66 279.79,52.66 v2(279.87,52.58)
  BOTTOM w0.076: UH2.C33 280.83,51.19 280.44,51.58 280.44,52.49 280.23,52.7 280,52.7 v2(279.87,52.58)
  BOTTOM w0.14: CD43.1 269.39,20.48 268.61,20.48 268,21.08 v2(266.99,21.08)
PCIE_PTX_SSDRX_N11_C: length 3.6
  BOTTOM w0.14: CD43.2 270.88,20.41 271.4,20.41 v3(271.57,20.25) 271.76,20.06 272.49,20.06 272.59,20.15 272.97,20.15 273.09,20.28 JNGFF2.23
PCIE_PTX_SSDRX_N12: length 54.1
  IN2 w0.104: v2(278.91,52.65) 278.6,52.96 278.41,52.96 278.29,52.84 278.29,52.18 278.08,51.96 277.21,51.96 276.75,52.43 276.75,52.58 276.26,53.08 274.4,53.08 273.06,51.74 269.68,51.74 264.08,46.14 264.08,33.73 265.25,32.55 265.25,31.75 265.96,31.05 265.96,28.54 263.54,26.12 263.54,25.97 263.67,25.84 263.67,25.69 263.55,25.57 263.35,25.57 263.24,25.67 263.09,25.67 262.88,25.46 262.88,24.95 263.17,24.65 263.62,24.65 v2(263.84,24.87)
  BOTTOM w0.076: v2(278.91,52.65) 279.12,52.86 279.26,52.86 279.35,52.77 279.35,52.26 279.89,51.72 280.03,51.72 UH2.B35
  BOTTOM w0.14: CD37.1 269.33,23.54 269.01,23.54 268.41,22.93 267.86,22.93 267.85,22.93 267.08,22.93 266.82,23.19 266.82,24.44 266.54,24.71 264,24.71 v2(263.84,24.87)
PCIE_PTX_SSDRX_N12_C: length 3.6
  BOTTOM w0.14: CD37.2 270.89,23.52 271.36,23.52 v3(271.56,23.33) 271.73,23.15 272.91,23.15 273.03,23.28 JNGFF2.11
PCIE_PTX_SSDRX_P10: length 55
  IN2 w0.104: v2(268.43,19.09) 268.43,20.23 267.02,21.64 267.02,24.57 267.57,25.13 267.57,29.88 268.19,30.5 268.19,31.18 267.78,31.59 267.69,31.59 266.87,32.42 266.87,33.22 265.69,34.39 265.69,44.64 268.77,47.72 269.9,47.72 270.75,48.57 276.52,48.57 276.82,48.87 278.45,48.87 280.2,50.61 280.48,50.61 280.78,50.91 280.78,51.71 280.28,52.21 280.28,53.42 280.6,53.75 v2(280.94,53.75)
  BOTTOM w0.076: v2(280.94,53.75) 280.94,53.66 281.45,53.14 281.45,52.39 281.22,52.16 281.22,51.92 281.28,51.86 281.28,51.53 UH2.B32
  BOTTOM w0.14: CD46.1 269.53,16.54 268.98,16.54 268.57,16.94 268.57,18.94 v2(268.43,19.09)
PCIE_PTX_SSDRX_P10_C: length 3.5
  BOTTOM w0.14: CD46.2 270.88,16.74 272.02,16.74 272.2,16.92 272.82,16.92 272.96,16.78 JNGFF2.37
PCIE_PTX_SSDRX_P11: length 50.9
  IN2 w0.104: v2(267.23,20.49) 267.13,20.49 267.12,20.5 266.57,20.5 266.26,20.81 266.26,24.74 266.97,25.44 266.97,31.47 266.27,32.17 266.27,32.97 265.09,34.15 265.09,44.92 268.49,48.32 269.55,48.32 271,49.77 275.55,49.77 275.69,49.92 278.58,49.92 279.31,50.64 279.31,52.58 279.44,52.71 279.44,52.72 279.87,53.15 v2(279.87,53.16)
  BOTTOM w0.076: UH2.B33 280.76,51.55 280.71,51.55 280.61,51.65 280.61,52.55 280.3,52.87 280.08,52.87 279.87,53.07 v2(279.87,53.16)
  BOTTOM w0.14: v2(267.23,20.49) 267.23,20.61 267.45,20.83 267.89,20.83 268.5,20.22 269.27,20.22 CD44.1
PCIE_PTX_SSDRX_P11_C: length 3.6
  BOTTOM w0.14: CD44.2 270.88,20.16 271.29,20.16 271.64,19.8 272.6,19.8 272.7,19.9 272.97,19.9 273.09,19.78 JNGFF2.25
PCIE_PTX_SSDRX_P12: length 54.1
  IN2 w0.104: v2(278.91,53.23) 278.42,53.23 278.1,52.92 278.1,52.26 278,52.15 277.29,52.15 276.94,52.51 276.94,52.66 276.34,53.27 274.32,53.27 272.98,51.94 269.6,51.94 263.89,46.22 263.89,33.65 265.06,32.47 265.06,31.67 265.76,30.97 265.76,28.62 262.69,25.54 262.69,24.87 263.09,24.46 263.66,24.46 v2(263.84,24.29)
  BOTTOM w0.076: UH2.A35 280.22,51.98 280.14,51.9 279.94,51.9 279.52,52.33 279.52,52.84 279.33,53.03 279.12,53.03 v2(278.91,53.23)
  BOTTOM w0.14: CD42.1 269.33,23.28 269.12,23.28 268.5,22.67 v3(268.17,22.67) 266.98,22.67 266.56,23.09 266.56,24.33 266.44,24.46 264.01,24.46 v2(263.84,24.29)
PCIE_PTX_SSDRX_P12_C: length 3.6
  BOTTOM w0.14: JNGFF2.13 273.05,22.78 272.93,22.9 271.62,22.9 271.25,23.27 270.87,23.27 CD42.2
PCIE_PTX_TBTRX_N1: length 69.8
  IN4 w0.147: v2(289.42,52.63) 289.57,52.77 289.94,52.77 290.17,53.01 290.17,53.56 289.79,53.94 289.79,54.87 290.89,55.97 295.88,55.97 296.97,54.89 299.33,54.89 299.34,54.88 302.52,54.88 302.52,54.88 302.78,54.88 303.45,54.2 305.37,54.2 306.69,52.88 309.4,52.88 309.98,52.3 310.7,52.3 310.93,52.07 311.73,52.07 311.73,52.06 319.28,52.06 319.38,51.96 328.72,51.96 330.03,51.96 330.36,52.29 331.08,52.29 333.18,52.29 334.4,53.51 336.85,53.51 337.06,53.71 337.07,53.72 337.08,53.72 337.63,54.27 341,54.27 344.18,51.09 344.18,48.86 344.48,48.55 345.82,48.55 v2(345.96,48.4)
  BOTTOM w0.076: v2(289.42,52.63) 289.42,52.73 289.59,52.9 289.74,52.9 289.95,52.69 289.95,52.39 289.87,52.31 289.77,52.31 289.73,52.35 289.66,52.35 289.55,52.24 289.55,52.13 289.64,52.03 289.64,51.93 289.58,51.86 289.5,51.79 289.4,51.79 289.31,51.87 UH2.A16
  BOTTOM w0.14: v2(345.96,48.4) 346.1,48.54 347.09,48.54 CT15.1
PCIE_PTX_TBTRX_N1_C: length 4
  BOTTOM w0.094: 347.96,48.54 348.55,48.54 348.78,48.77 348.78,49.93 349.05,50.2 349.32,50.2 349.39,50.28 349.98,50.28 UT1.Y22
  BOTTOM w0.14: 347.96,48.54 347.93,48.54 CT15.2
PCIE_PTX_TBTRX_N2: length 69.8
  IN4 w0.147: v2(288.22,53.14) 288.35,53.31 288.62,53.34 288.9,53.67 288.9,55.01 290.59,56.7 290.66,56.7 290.66,56.71 298.17,56.71 298.54,56.71 299.63,55.61 303.04,55.61 303.05,55.6 303.08,55.6 303.76,54.92 305.67,54.92 306.36,54.23 309.15,54.23 310.35,53.03 311,53.03 311.23,52.79 312.03,52.79 312.04,52.79 319.58,52.79 319.69,52.68 329.13,52.68 329.47,52.68 329.82,53.03 330.66,53.03 331.21,53.58 331.21,54.62 331.76,55.16 333.45,55.16 333.45,55.16 334.39,55.16 334.4,55.17 335.31,55.17 335.6,55.46 338.55,55.46 338.72,55.29 341.01,55.29 345.18,51.12 345.2,51.12 345.21,51.1 346.41,51.1 v2(346.56,50.96)
  BOTTOM w0.076: UH2.B19 288.13,51.43 288.13,51.29 288.21,51.21 288.26,51.21 288.33,51.14 288.47,51.14 288.52,51.18 288.52,51.28 288.54,51.3 288.54,51.41 288.42,51.54 288.42,51.71 288.34,51.79 288.17,51.79 288.04,51.92 288.04,52.02 288.01,52.05 288.01,53.07 288.09,53.15 288.22,53.15 v2(288.22,53.14)
  BOTTOM w0.14: CT13.1 347.09,51.08 346.69,51.08 v2(346.56,50.96)
PCIE_PTX_TBTRX_N2_C: length 3.5
  BOTTOM w0.089: 350.21,52.33 UT1.T22
  BOTTOM w0.094: 350.21,52.33 350.01,52.13 349.43,52.13 349.42,52.12 349.28,52.12 349.27,52.13 349.26,52.13 349.21,52.18 348.51,52.18 348.42,52.08 348.42,51.3 348.14,51.03 348.01,51.03 347.96,50.97
  BOTTOM w0.14: CT13.2 347.94,50.96 347.96,50.97
PCIE_PTX_TBTRX_N3: length 69.8
  IN4 w0.147: v2(287.19,55.27) 287.34,55.12 287.56,55.12 290.17,57.72 299.03,57.72 300.12,56.63 300.94,56.63 300.95,56.62 303.46,56.62 303.47,56.6 303.49,56.6 304.12,55.97 306.12,55.97 306.86,55.23 309.56,55.23 310.49,54.31 311.13,54.31 311.13,54.3 318.58,54.3 318.65,54.3 320.14,54.3 320.2,54.31 325.04,54.31 325.38,54.65 329.83,54.65 331.34,56.16 333.86,56.16 333.98,56.16 333.99,56.17 334.89,56.17 336.09,57.37 342.25,57.37 345.71,53.91 346.45,53.91 v2(346.62,54.08)
  BOTTOM w0.076: 287.31,55.15 287.31,55.06 287.49,54.89 287.81,54.89 287.88,54.82 287.88,54.23 287.59,53.94 287.59,51.78 287.57,51.76 287.57,51.71 UH2.B20
  BOTTOM w0.14: v2(346.62,54.08) 346.77,53.93 347.02,53.93 CT18.1 ; 287.31,55.15 v2(287.19,55.27)
PCIE_PTX_TBTRX_N3_C: length 2.6
  BOTTOM w0.094: 348.16,54.13 349.29,54.13 349.58,54.42 349.99,54.42 UT1.M22
  BOTTOM w0.14: CT18.2 348.16,54.13
PCIE_PTX_TBTRX_N4: length 72.7
  IN4 w0.147: v2(346.69,56.62) 346.63,56.67 345.47,56.67 344.82,57.32 344.01,58.13 343.67,58.13 334.82,58.13 334.82,58.13 334.81,58.13 333.69,57.01 331.17,57.01 329.52,55.37 325.08,55.37 324.74,55.03 320.15,55.03 320.09,55.03 318.68,55.03 318.61,55.03 311.43,55.03 311.43,55.03 310.79,55.03 309.86,55.96 307.16,55.96 306.42,56.7 304.42,56.7 303.79,57.33 303.77,57.33 303.76,57.34 301.19,57.34 299.2,59.33 288.81,59.33 287.41,57.92 287.41,57.22 287.71,56.92 288.03,56.92 v2(288.17,56.77)
  BOTTOM w0.076: UH2.B21 287.04,51.69 287.26,51.92 287.26,52.3 287.12,52.44 287.12,53.22 286.84,53.5 286.84,54.31 286.48,54.68 286.48,55.08 286.55,55.15
  BOTTOM w0.14: v2(288.17,56.77) 288.14,56.8 287.38,56.8 286.55,55.97 286.55,55.15 ; CT21.1 347.03,56.48 346.83,56.48 v2(346.69,56.62)
PCIE_PTX_TBTRX_N4_C: length 2.7
  BOTTOM w0.094: UT1.H22 349.98,56.26 348.57,56.26 348.29,56.54 347.96,56.54
  BOTTOM w0.14: 347.96,56.54 347.93,56.54 CT21.2
PCIE_PTX_TBTRX_P1: length 69.9
  IN4 w0.147: v2(289.42,53.21) 289.57,53.06 289.82,53.06 289.88,53.12 289.88,53.44 289.5,53.82 289.5,54.97 290.78,56.25 290.84,56.25 290.85,56.26 295.16,56.26 295.16,56.25 296,56.25 297.08,55.17 299.44,55.17 299.44,55.16 299.82,55.16 302.85,55.16 302.87,55.15 302.89,55.15 303.57,54.47 305.48,54.47 306.8,53.15 309.51,53.15 310.09,52.57 310.81,52.57 311.04,52.34 311.84,52.34 311.85,52.34 319.39,52.34 319.5,52.23 328.83,52.23 329.92,52.23 330.25,52.56 331.19,52.56 333.07,52.56 334.29,53.78 336.74,53.78 336.87,53.91 336.96,53.99 337.52,54.55 341.11,54.55 344.45,51.21 344.45,48.97 344.59,48.83 345.81,48.83 345.96,48.98 v2(345.96,48.99)
  BOTTOM w0.076: UH2.B16 289.49,51.53 290.11,52.16 290.11,52.76 289.66,53.21 v2(289.42,53.21)
  BOTTOM w0.14: CT3.1 347.02,48.85 346.1,48.85 v2(345.96,48.99)
PCIE_PTX_TBTRX_P1_C: length 3.9
  BOTTOM w0.089: 349.79,50.55 UT1.Y23
  BOTTOM w0.094: 349.79,50.55 349.79,50.68 349.74,50.73 349.52,50.73 349.38,50.6 349.38,50.52 349.24,50.38 348.97,50.38 348.6,50.01 348.6,48.85 348.48,48.73 348.13,48.73 347.96,48.9
  BOTTOM w0.14: CT3.2 347.96,48.9
PCIE_PTX_TBTRX_P2: length 69.9
  IN4 w0.147: v2(288.15,53.72) 288.32,53.59 288.32,53.59 288.47,53.61 288.61,53.78 288.61,55.11 290.49,56.99 290.66,56.99 290.66,56.98 298.05,56.98 298.65,56.98 299.75,55.89 303.16,55.89 303.17,55.88 303.19,55.88 303.86,55.21 305.6,55.21 305.61,55.2 305.79,55.2 306.48,54.51 309.26,54.51 310.47,53.3 311.11,53.3 311.35,53.07 312.14,53.07 312.15,53.06 319.69,53.06 319.8,52.96 329.36,52.96 329.71,53.3 330.49,53.3 330.52,53.33 330.53,53.33 330.94,53.74 330.94,54.73 331.64,55.44 333.56,55.44 333.56,55.44 334.28,55.44 334.29,55.45 335.19,55.45 335.48,55.74 338.66,55.74 338.83,55.57 341.12,55.57 345.3,51.39 345.31,51.39 345.32,51.38 346.4,51.38 v2(346.56,51.54)
  BOTTOM w0.076: v2(288.15,53.72) 287.85,53.42 287.85,51.88 287.88,51.85 287.88,51.03 287.96,50.95 UH2.C19
  BOTTOM w0.14: v2(346.56,51.54) 346.71,51.39 347.02,51.39 CT1.1
PCIE_PTX_TBTRX_P2_C: length 3.4
  BOTTOM w0.094: UT1.T23 349.75,52.37 349.66,52.46 349.51,52.46 349.4,52.36 349,52.36 348.91,52.46 348.91,52.54 348.8,52.66 348.66,52.66 348.53,52.52 348.53,52.41 348.47,52.36 348.36,52.36 348.24,52.23 348.24,51.43 348.14,51.34 348.04,51.34 347.96,51.42
  BOTTOM w0.14: CT1.2 347.8,51.57 347.96,51.42
PCIE_PTX_TBTRX_P3: length 69.8
  IN4 w0.147: v2(346.62,53.5) 346.49,53.62 346.35,53.62 345.61,53.62 342.13,57.09 336.2,57.09 335,55.9 334.1,55.9 334.09,55.89 333.75,55.89 331.46,55.89 329.94,54.37 325.49,54.37 325.16,54.03 320.21,54.03 320.15,54.02 318.64,54.02 318.6,54.03 318.6,54.02 318.37,54.02 318.36,54.03 311.02,54.03 311.01,54.03 310.37,54.03 309.45,54.96 306.66,54.96 305.96,55.66 304.04,55.66 303.38,56.33 303.36,56.33 303.34,56.34 299.94,56.34 298.84,57.44 298.47,57.44 290.36,57.44 290.36,57.43 290.27,57.43 287.68,54.84 287.68,54.83 287.68,54.83 287.33,54.83 287.19,54.69 v2(287.19,54.69)
  BOTTOM w0.076: v2(287.19,54.69) 287.64,54.69 287.72,54.61 287.72,54.3 287.43,54.01 287.43,51.85 287.4,51.83 287.4,51.5 287.65,51.25 UH2.C20
  BOTTOM w0.14: CT4.1 347.09,53.62 346.75,53.62 v2(346.62,53.5)
PCIE_PTX_TBTRX_P3_C: length 2.6
  BOTTOM w0.094: 348,53.45 348.13,53.45 348.27,53.59 348.27,53.85 348.37,53.95 348.58,53.95 348.73,53.8 349.01,53.8 349.16,53.95 349.61,53.95 349.75,54.09 UT1.M23
  BOTTOM w0.14: 348,53.45 347.85,53.45 CT4.2
PCIE_PTX_TBTRX_P4: length 72.7
  IN4 w0.147: v2(288.17,57.35) 288.03,57.2 287.83,57.2 287.69,57.34 287.69,57.8 287.97,58.08 288.18,58.08 288.39,57.87 288.62,57.87 288.76,58.02 288.76,58.33 288.6,58.49 288.6,58.7 288.95,59.05 299.09,59.05 301.08,57.07 303.64,57.07 303.66,57.05 303.68,57.05 304.31,56.42 306.31,56.42 307.04,55.69 309.75,55.69 310.68,54.76 311.32,54.76 311.32,54.76 318.6,54.76 318.67,54.75 320.11,54.75 320.17,54.76 324.85,54.76 325.19,55.1 329.64,55.1 331.28,56.74 333.81,56.74 334.92,57.85 343.78,57.85 343.79,57.85 343.9,57.85 345.36,56.4 346.3,56.4 346.66,56.04 v2(346.69,56.04)
  BOTTOM w0.076: UH2.A21 287.09,52.1 287.09,52.24 286.96,52.37 286.96,53.15 286.68,53.43 286.68,54.24 286.32,54.61 286.32,55.06 286.25,55.13 286.25,55.15
  BOTTOM w0.14: v2(288.17,57.35) 287.95,57.13 287.28,57.13 286.25,56.1 286.25,55.15 ; v2(346.69,56.04) 346.82,56.17 347.08,56.17 CT5.1
PCIE_PTX_TBTRX_P4_C: length 2.6
  BOTTOM w0.094: 347.96,56.19 348.13,56.36 348.22,56.36 348.5,56.08 349.33,56.08 349.42,55.99 349.42,55.87 349.49,55.8 349.69,55.8 349.75,55.87 UT1.H23
  BOTTOM w0.14: CT5.2 347.96,56.19
PCIE_PTX_WLANRX_N6: length 74.6
  TOP w0.14: v2(343.7,42.32) 343.85,42.17 344.33,42.17 CN20.1
  IN4 w0.147: v2(285.47,53.24) 285.65,53.06 286.1,53.06 286.49,52.67 286.49,50.7 285.75,49.96 285.75,48.69 285.6,48.54 285.6,48.05 285.95,47.69 285.95,46.68 287.87,44.77 288.86,44.77 289.96,43.67 294.89,43.67 295.4,44.18 296.74,44.18 297.24,43.68 298.71,43.68 299.59,44.57 301.98,44.57 302.26,44.29 308.43,44.29 310.01,45.86 312.8,45.86 313.83,44.83 317.5,44.83 319.88,42.45 323.94,42.45 325.15,41.24 329.67,41.24 330.19,40.72 341.67,40.72 342.36,41.41 342.36,41.79 342.79,42.22 343.6,42.22 v2(343.7,42.32)
  BOTTOM w0.076: UH2.B22 286.42,51.7 286.42,52.52 285.7,53.24 285.47,53.24 v2(285.47,53.24)
PCIE_PTX_WLANRX_P6: length 74.6
  TOP w0.14: v2(343.7,41.74) 343.86,41.89 344.33,41.89 CN21.1
  IN4 w0.147: v2(285.46,52.65) 285.59,52.78 285.99,52.78 286.21,52.56 286.21,50.82 285.47,50.07 285.47,48.8 285.32,48.66 285.32,47.93 285.68,47.58 285.68,46.57 287.75,44.49 288.75,44.49 289.85,43.4 295,43.4 295.51,43.9 296.63,43.9 297.12,43.41 298.82,43.41 299.71,44.29 301.87,44.29 302.15,44.01 308.55,44.01 310.12,45.59 312.68,45.59 313.71,44.56 317.39,44.56 319.77,42.17 323.82,42.17 325.03,40.97 329.55,40.97 330.07,40.44 341.78,40.44 342.63,41.3 342.63,41.67 342.91,41.94 343.49,41.94 v2(343.7,41.74)
  BOTTOM w0.076: UH2.A23 285.98,52.03 285.98,51.91 286.06,51.84 286.16,51.84 286.24,51.92 286.24,52.47 285.81,52.9 285.6,52.9 285.46,52.76 v2(285.46,52.65)
PCIE_PTX_WLANRX_RE_N6: length 2.1
  TOP w0.14: v2(346.18,42.27) 345.82,42.27 CN20.2
  BOTTOM w0.14: v2(346.18,42.27) 346.05,42.14 345.76,42.14 345.6,42.3 JNGFF1.29
PCIE_PTX_WLANRX_RE_P6: length 2.2
  TOP w0.14: CN21.2 345.8,41.77 346.09,41.77 v2(346.18,41.68)
  BOTTOM w0.14: v2(346.18,41.68) 345.97,41.89 345.73,41.89 345.64,41.8 JNGFF1.27
PCIE_RBIAS: length 2
  TOP w0.14: v1(353.29,54) 353.06,53.77 RT3.1 352.61,53.13 v2(352.53,53.21)
  BOTTOM w0.076: v2(352.53,53.21) UT1.N16
PCIE_RCOMPN: length 4
  BOTTOM w0.102: 288.75,53.78 288.75,51.76 UH2.B18
  BOTTOM w0.127: v1(288.08,55.32) 288.51,54.89 RH108.1
  BOTTOM w0.305: 288.75,53.78 288.75,54.08 RH108.1
PCIE_RCOMPP: length 4.6
  BOTTOM w0.102: UH2.C17 288.96,51.38 288.96,53.47 289.41,53.92
  BOTTOM w0.127: RH108.2 289.42,55.17 v1(289.65,55.4)
  BOTTOM w0.305: 289.41,53.92 289.41,54.31 RH108.2
PCIE_WAKE#: length 395.4
  TOP w0.14: v2(296.95,20.53) 297.39,20.09 v1(297.41,20.09) 298.2,20.09 298.29,20.19 UE1.4
  IN1 w0.097: v2(296.95,20.53) 297.45,20.03 298.17,20.03 298.63,19.57 301.69,19.57 302.32,18.94 302.32,18.75 302.42,18.65 307.97,18.65 308.33,19.02 310.86,19.02 312.11,20.27 313.81,20.27 314.47,20.92 314.47,22.48 318.61,26.62 324.19,26.62 327.87,30.3 334.23,30.3 v2(334.38,30.15) ; v2(347.56,47.28) 349.2,47.28 349.6,47.68 349.6,47.96 350.52,48.88 358.39,48.88 360,50.49 360.67,50.49 360.94,50.76 361.23,50.76 362.22,51.76 v2(364.78,51.76)
  IN2 w0.097: v2(341.76,48.64) 341.76,48.61 342.45,47.92 342.45,42.2 340.9,40.65 340.9,36.74 341.31,36.33 341.31,31.99 339.62,30.3 334.52,30.3 v2(334.38,30.15)
  IN3 w0.124: v2(296.95,20.53) 294.11,20.53 293.48,19.9 288.57,19.9 288.16,19.49 286.07,19.49 285.52,20.05 283.42,20.05 282.93,20.53 281.2,20.53 280.72,20.05 277.5,20.05 276.82,20.73 271.62,20.73 270.92,20.03 261.16,20.03 255.44,25.75 251.52,25.75 249.99,27.28 246.3,27.28 245.45,26.43 239.39,26.43 238.13,27.69 224.5,27.69 223.29,26.48 209.77,26.48 209.26,27 136.55,27 136.03,27.51 117.59,27.51 116.67,26.59 86.28,26.59 84.37,24.68 69.04,24.68 63.92,29.79 60.71,29.79 60.39,29.47 60.39,27.28 59.02,25.91 39,25.91 34.97,29.94 34.97,29.94 31.92,32.99 31.92,36.57 29.76,38.72 27.47,38.72 26.99,38.24 v2(26.35,38.24)
  BOTTOM w0.14: RL2.1 26.93,38.2 26.39,38.2 v2(26.35,38.24) ; v2(296.95,20.53) 296.37,20.53 295.41,21.5 RH114.2 ; v2(364.78,51.76) RT10.2 ; v2(347.56,47.28) 346.77,47.28 346.28,46.8 JNGFF1.47 342.65,46.8 341.8,47.65 341.8,48.61 v2(341.76,48.64)
PD_EE_CLK: length 3.3
  TOP w0.14: v2(359.98,68.89) 359.44,68.89 v1(359.25,68.7) 358.8,68.25 RT123.1
  BOTTOM w0.076: UT4.A3 360.19,68.03 360.19,68.68 v2(359.98,68.89)
PD_EE_CLK_R: length 39.4
  TOP w0.14: v2(359.45,66.91) 359.39,66.97 RT123.2
  IN4 w0.137: v2(359.45,66.91) 358.76,67.59 358.76,72.38 359.32,72.94 363.41,72.94 364.28,73.81 364.28,79.95 361.19,83.04 361.19,88.7 362.46,89.97 362.46,94.35 v2(362.92,94.81)
  BOTTOM w0.14: UT5.6 360.83,95.47 361.49,94.81 v2(362.92,94.81)
PD_EE_CS_N: length 36.7
  TOP w0.14: v2(359.98,67.16) 359.98,66.7 v1(359.35,66.07)
  IN4 w0.137: v2(362.9,90.01) 361.43,88.54 361.43,83.13 364.55,80.01 364.55,73.75 363.51,72.7 359.47,72.7 359,72.23 359,68.14 v2(359.98,67.16)
  BOTTOM w0.076: UT4.B3 359.94,68.27 359.69,68.03 359.69,67.45 v2(359.98,67.16)
  BOTTOM w0.14: UT5.1 363.37,89.78 362.84,89.25 RT126.1 362.36,89.46 v2(362.9,90.01)
PD_EE_DI: length 43.1
  TOP w0.14: v2(361.09,66.88) 361.48,66.49 v1(362.09,66.49)
  IN4 w0.137: v2(361.09,66.88) 361.09,67.09 359.48,68.7 359.48,71.94 359.76,72.22 363.7,72.22 365.03,73.55 365.03,80.28 361.91,83.41 361.91,88.08 363.61,89.78 363.61,93.44 v2(362.93,94.12)
  BOTTOM w0.076: v2(361.09,66.88) 360.69,67.27 360.69,68.03 UT4.B4
  BOTTOM w0.14: v2(362.93,94.12) 360.77,94.12 359.56,95.33 UT5.5
PD_EE_DO: length 38.5
  TOP w0.14: v2(360.49,66.87) 360.49,66.08 v1(360.9,65.67)
  IN4 w0.137: v2(360.49,66.87) 360.49,67.25 359.24,68.5 359.24,72.08 359.62,72.46 363.6,72.46 364.79,73.65 364.79,80.15 361.67,83.27 361.67,88.18 363.37,89.88 363.37,90.35 363.11,90.62 v2(362.89,90.62)
  BOTTOM w0.076: v2(360.49,66.87) 360.45,66.91 360.45,67.77 UT4.A4
  BOTTOM w0.14: v2(362.89,90.62) 361.95,89.68 361.95,89.4 361.8,89.25 RT125.1 361.44,90.11 362.1,90.77 UT5.2
PD_EE_HOLD#: length 3.1
  BOTTOM w0.14: UT5.7 362.1,98 361.93,98.17 RT128.1 v1(360.86,98.82)
PD_EE_WP#: length 3.8
  BOTTOM w0.14: v1(359.41,89.25) RT127.1 360.58,90.36 360.83,90.62 UT5.3
PD_I2C_INT#: length 3.6
  BOTTOM w0.076: UT4.B6 361.69,68.03 361.69,67.68 361.91,67.47 362.31,67.47 362.94,66.83 363.4,66.83 RT120.1
PD_I2C_SCL_R: length 3.8
  BOTTOM w0.076: RT60.2 RT57.2 362.41,66.36 362.32,66.27 RT118.2 361.67,66.46 361.67,66.9 361.66,66.91 361.66,67.09 361.19,67.56 361.19,68.03 UT4.B5
PD_I2C_SDA_R: length 3.6
  BOTTOM w0.076: RT58.2 RT59.2 360.24,66.27 RT119.2 361.15,66.27 361.5,66.61 361.5,67.03 360.94,67.58 UT4.A5
PD_UART: length 4.5
  BOTTOM w0.076: 358.5,70.13 358.74,70.13 358.84,70.03 359.19,70.03 UT4.E2 UT4.F2
  BOTTOM w0.14: 358.5,70.13 357.66,70.13 356.76,69.23 356.76,68.9 356.55,68.7 RT62.1
PECI: length 7.2
  BOTTOM w0.076: UH2.AL3 296,37.29 296.23,37.52 296.56,37.52 296.7,37.38 298.26,37.38 298.48,37.16 v1(298.74,37.16) 298.97,37.16 299.29,36.83 299.29,34.92 299.87,34.33 RH138.1
PECI_EC: length 321.1
  TOP w0.14: RE17.2 319.28,22 319.85,22.57 319.85,25.21 316.85,28.21 315.93,28.21 311.82,32.32 311.82,32.69 310.06,34.46 306.41,34.46 v1(305.39,33.44) 304.55,32.59 v2(304.55,31.61)
  IN2 w0.097: v2(304.55,31.61) 306.53,33.59 306.53,38.29 305.77,39.04 305.77,44.59 308.87,47.68 308.87,52.21 306.01,55.07 303.15,55.07 301.64,56.58 298.15,56.58 294.16,60.57 292.17,60.57 290.61,62.12 290.61,62.26 288.42,64.45 283.21,64.45 280.17,67.49 276.94,67.49 276.94,67.49 275.92,67.49 275.6,67.17 263.74,67.17 263.13,67.78 261.84,69.07 245.12,69.07 244.76,69.44 239.82,69.44 v2(239.37,68.99)
  IN4 w0.137: v2(131.42,105.12) 131.3,105.12 130.54,104.35 130.54,96.46 130.88,96.11 130.88,93.26 123.24,85.62 123.24,65.75 123.75,65.24 134.61,54.38 166.78,54.38 173.14,48.02 185.05,48.02 186.41,46.67 198.46,46.67 199.03,46.1 205.15,46.1 205.6,46.54 232.63,46.54 236.76,50.68 236.76,57.17 237.72,58.12 v2(237.72,58.85)
  BOTTOM w0.14: v2(304.55,31.61) 304.55,31.97 302.22,34.29 301.47,34.29 RH138.2 ; v2(237.72,58.85) 237.72,60.82 239.37,62.47 v2(239.37,68.99) ; RH190.1 135.47,103.36 134.06,104.77 131.78,104.77 v2(131.42,105.12)
PECI_EC_R: length 5.4
  BOTTOM w0.102: UH1.BT34 138.9,101.88
  BOTTOM w0.114: 138.9,101.88 137.73,103.05 137.31,103.05
  BOTTOM w0.14: 137.31,103.05 RH190.2 136.39,103.29 v1(135.43,104.24)
PEG_GTX_C_HRX_N0: length 24
  TOP w0.102: 179.74,83.51 178.2,83.51 v2(178.02,83.69)
  TOP w0.14: 179.74,83.51 v3(180.71,83.51) 186.79,83.51 196.13,92.84 196.13,93.11 196.27,93.25 196.59,93.25 196.72,93.12 CG516.1
  BOTTOM w0.076: UH1.E10 177.74,84.12 178.01,84.12 178.07,84.06 178.07,83.96 178.13,83.9 178.13,83.79 v2(178.02,83.69)
PEG_GTX_C_HRX_N1: length 25
  TOP w0.102: 181.38,84.03 181.37,84.03 181.25,84.14 181.25,84.2 181.03,84.42 180.67,84.42 180.32,84.08 177.73,84.08 v2(177.33,84.48)
  TOP w0.14: 181.38,84.03 v3(183.29,84.03) 186.68,84.03 195.62,92.96 195.62,93.65 195.82,93.85 196.64,93.85 CG513.1
  BOTTOM w0.076: v2(177.33,84.48) 177.7,84.84 UH1.E11
PEG_GTX_C_HRX_N2: length 24.8
  TOP w0.102: v2(178.02,85.26) 178.02,85.17 178.12,85.06 178.27,85.06 178.47,84.86 179.46,84.86 179.82,85.23 181.08,85.23 181.23,85.08 181.38,85.08
  TOP w0.14: 181.38,85.08 v3(181.94,85.08) 186.39,85.08 194.6,93.3 194.6,94.97 195.27,95.63 195.27,96.12 195.41,96.26 195.62,96.26 CG25.1
  BOTTOM w0.076: UH1.E12 177.74,85.69 178.03,85.69 178.07,85.65 178.07,85.54 178.13,85.48 178.13,85.37 v2(178.02,85.26)
PEG_GTX_C_HRX_N3: length 26.7
  TOP w0.102: 181.38,86.15 181.37,86.15 181.35,86.13 181.28,86.13 181.17,86.25 v3(180.26,86.25) 179.95,86.25 179.54,86.66 178.45,86.66 178.16,86.36 178.16,86.18 v2(178.02,86.05)
  TOP w0.14: 181.38,86.15 181.75,86.15 182.12,85.78 186.1,85.78 193.9,93.59 193.9,96.02 195,97.12 CG27.1
  BOTTOM w0.076: UH1.E13 177.7,86.37 v2(178.02,86.05)
PEG_GTX_C_HRX_N4: length 25.9
  TOP w0.102: v2(177.37,87.6) 177.45,87.6 177.83,87.22 179.73,87.22 180.15,86.8 181.08,86.8 181.14,86.86 181.34,86.86 181.36,86.88 181.38,86.88
  TOP w0.14: CG29.1 196.12,98.26 195.87,98.01 194.79,98.01 193.21,96.42 193.21,93.88 186.21,86.88 v3(183.47,86.88) 181.38,86.88
  BOTTOM w0.076: v2(177.37,87.6) 177.7,87.27 UH1.E14
PEG_GTX_C_HRX_N5: length 27.7
  TOP w0.102: 181.38,87.59 181.37,87.59 181.36,87.58 181.33,87.58 181.1,87.81 180,87.81 179.61,88.21 178.7,88.21 178.13,87.61 v2(178.03,87.6)
  TOP w0.14: 181.38,87.59 v3(181.81,87.59) 185.94,87.59 192.51,94.16 192.51,96.74 194.55,98.78 195.64,98.78 195.85,98.99 197.17,98.99 197.27,99.09 198.33,99.09 CG31.1
  BOTTOM w0.076: UH1.E15 177.7,87.93 v2(178.03,87.6)
PEG_GTX_C_HRX_N6: length 26.9
  TOP w0.102: 181.38,88.36 181.36,88.36 181.33,88.33 180.15,88.33 179.74,88.74 178.6,88.74 178.52,88.66 178.38,88.66 178.22,88.82 177.89,88.82 177.78,88.7 177.78,88.51 177.88,88.41 v2(178.02,88.41)
  TOP w0.14: 181.38,88.36 v3(183.57,88.36) 185.71,88.36 191.81,94.45 191.81,97.09 194.2,99.48 195.35,99.48 195.59,99.72 196.6,99.72 196.6,99.73 196.71,99.84 196.79,99.84 CG33.1
  BOTTOM w0.076: v2(178.02,88.41) 177.7,88.74 UH1.E16
PEG_GTX_C_HRX_N7: length 27.7
  TOP w0.102: 181.38,89.22 181.33,89.22 181.13,89.42 179.93,89.42 179.57,89.78 178.69,89.78 178.11,89.2 v2(178.02,89.2)
  TOP w0.14: 181.38,89.22 185.59,89.22 191.11,94.74 191.11,97.41 194.11,100.42 194.98,100.42 195.44,100.88 v3(196.03,100.88) 198.08,100.88 CG36.1
  BOTTOM w0.114: UH1.E17 177.7,89.52 v2(178.02,89.2)
PEG_GTX_C_HRX_N8: length 27
  TOP w0.102: 181.38,89.97 181.18,89.97 181.15,89.95 179.98,89.95 179.71,90.21 178.46,90.21 178.31,90.37 177.86,90.37 177.59,90.09 177.48,89.99 v2(177.37,89.99)
  TOP w0.14: 181.38,89.97 181.79,89.97 181.8,89.98 182.39,89.98 182.39,89.97 185.35,89.97 190.41,95.03 190.41,97.7 193.83,101.12 194.7,101.12 195.47,101.89 196.86,101.89 CG489.1
  BOTTOM w0.102: UH1.F18 177.05,90.31 v2(177.37,89.99)
PEG_GTX_C_HRX_N9: length 28.5
  TOP w0.102: v2(178.02,90.77) 177.97,90.83 177.97,90.91 178.03,90.97 178.27,90.97 178.45,91.15 178.83,91.15 179.1,90.88 v3(180.1,90.88) 181.04,90.88 181.32,90.61 181.32,90.54 181.38,90.47
  TOP w0.14: 181.38,90.47 181.4,90.45 185.2,90.45 189.97,95.22 189.97,97.89 193.65,101.56 194.52,101.56 195.44,102.49 195.82,102.49 195.82,102.48 196.37,102.48 196.38,102.49 197.24,102.49 197.39,102.64 197.73,102.64 197.82,102.56 197.82,102.4 197.92,102.3 198.29,102.3 CG490.1
  BOTTOM w0.127: v2(178.02,90.77) 177.95,90.84 177.95,91 178.12,91.17 UH1.D19
