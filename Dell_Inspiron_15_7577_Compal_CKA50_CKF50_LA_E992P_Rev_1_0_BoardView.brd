# Allegro board Dell_Inspiron_15_7577_Compal_CKA50_CKF50_LA_E992P_Rev_1_0_BoardView.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on BOTTOM (solid shape): 11.93,76.7 13.51,75.11 16.65,75.11 17.06,74.7 17.06,73.52 16.84,73.31 12.77,73.31 12.77,74.75 12.17,75.45 11.4,74.95 8.01,74.95 7.51,74.65 3.42,74.65 3.42,79.05 3.07,79.9 2.22,80.25 1,80.25 0.44,80.49 0.2,81.05 0.2,82.31 0.29,82.52 0.5,82.61 5,82.61 5.21,82.52 5.3,82.31 5.3,82.1 5.5,81.6 6,81.4 6.8,81.4 7.3,81.6 7.5,82.1 7.5,82.31 7.59,82.52 7.8,82.61 11.4,82.61 11.69,82.67 11.93,82.84
GND on BOTTOM (solid shape): 217.75,102.87 217.75,100.07 217.95,99.87 217.98,99.8 218.01,99.75 218.06,99.73 218.11,99.69 218.13,99.67 218.17,99.65 218.27,99.55 218.27,99.54 218.29,99.46 218.32,99.4 218.37,99.36 218.44,99.23 218.37,99.09 218.37,98.7 218.44,98.61 218.44,97.79 218.38,97.73 218.34,97.65 218.11,97.43 218.11,97.39 218.03,97.32 217.99,97.23 217.98,97.21 217.96,97.2 217.89,97.13 217.89,96.53 217.79,96.43 217.79,96.39 217.74,96.35 217.68,96.29 217.65,96.27 217.6,96.28 217.56,96.28 217.52,96.29 217.48,96.31 217.43,96.35 217.4,96.4 217.34,96.44 217.34,97.22 217.53,97.41 217.56,97.48 217.56,97.54 217.6,97.58 217.62,97.58 217.74,97.65 217.81,97.77 217.82,97.78 218.03,97.99 218.03,98.63 218.08,98.67 218.13,98.73 218.18,98.82 218.18,98.89 218.1,99.1 217.97,99.2 217.96,99.2 217.79,99.37 217.75,99.43 217.7,99.47 217.55,99.62 217.53,99.69 217.51,99.75 217.48,99.81 217.43,99.84 217.4,99.9 217.36,99.92 217.33,99.94 217.33,101.28 217.13,101.47 217.13,101.48 217.08,101.56 217,101.62 217,101.75 217.38,102.12 217.38,102.85 217.49,102.96 217.66,102.96
GND on BOTTOM (solid shape): 276.62,45.1 276.69,45.08 276.73,45.01 276.84,44.89 276.83,44.87 276.85,44.66 276.98,44.51 277.04,44.44 277.01,44.35 277,44.33 277.11,43.97 277.35,44.26 277.34,44.29 277.57,44.52 277.66,44.49 277.73,44.42 277.72,44.33 277.67,44.15 277.76,43.99 277.8,43.92 277.77,43.84 277.69,43.71 277.68,43.55 277.69,43.52 277.27,43.1 277.23,43.12 277.08,43.16 276.94,43.09 276.85,43.06 276.78,43.11 276.71,43.18 276.61,43.21 276.5,43.2 276.44,43.2 276.44,43.29 276.45,43.31 276.48,43.41 276.45,43.5 276.44,43.52 276.44,43.82 276.59,43.82 276.77,43.95 276.71,44.16 276.71,44.21 276.44,44.47 276.44,45 276.47,45.07 276.55,45.1
GND on BOTTOM (solid shape): 221.22,114.76 221.22,114.39 221.41,114.2 221.41,113.97 221.36,113.92 221.46,113.69 221.67,113.57 221.71,113.56 221.71,113.44 222.17,112.97 222.21,112.94 222.25,112.92 222.25,112.78 222.21,112.74 222.19,112.7 222.1,112.65 222.01,112.7 221.93,112.79 221.83,112.84 221.8,112.85 221.78,112.92 221.11,113.12 221.38,112.48 221.45,112.47 221.47,112.44 221.52,112.35 221.6,112.29 221.65,112.2 221.6,112.11 221.53,112.05 221.47,111.98 221.47,111.96 221.21,111.85 221.11,111.72 221.03,111.66 220.94,111.7 220.91,111.73 220.88,111.8 220.91,111.87 221.01,112.27 220.7,112.53 220.67,112.54 220.65,112.58 220.63,112.66 220.59,112.74 220.88,113.04 220.88,113.29 220.91,113.3 221.13,113.59 221.02,113.92 220.89,114.05 220.89,114.74 220.96,114.82 221.15,114.82
GND on BOTTOM (solid shape): outline of 87 points within 208.97,88.57 209.72,106.43
GND on BOTTOM (solid shape): outline of 176 points within 362.25,33.35 380.09,43.48
GND on BOTTOM (solid shape): 233.14,82.58 233.14,82.47 233.13,81.84 233.72,82.06 233.76,82.16 233.78,82.17 233.91,82.3 233.95,82.48 233.98,82.55 234.05,82.59 235.35,82.59 235.42,82.56 235.45,82.49 235.49,82.3 235.63,82.17 235.66,82.16 235.68,82.06 235.64,82.05 235.53,81.98 235.45,81.87 235.44,81.82 235.34,81.86 235.33,81.88 235.04,82.06 234.77,81.86 234.75,81.82 234.64,81.86 234.63,81.88 234.53,82 234.38,82.05 234.16,81.99 234.05,81.8 234.01,81.75 233.95,81.73 233.72,81.65 233.58,81.44 233.54,81.34 233.44,81.27 233.37,81.18 233.23,81.18 233.04,81.34 232.8,81.31 232.51,81.59 232.54,81.84 232.38,82.03 232.38,82.17 232.49,82.27 232.55,82.41 232.55,82.42 232.6,82.47 232.61,82.47 232.77,82.53 232.88,82.66 233.06,82.66
GND on BOTTOM (solid shape): 233.25,88.57 233.33,88.53 233.61,88.36 233.93,88.47 234,88.5 234.07,88.47 234.35,88.2 235.13,88.2 235.21,88.11 235.21,88 235.1,87.88 234.74,87.88 234.58,87.72 234.22,87.72 234.06,87.61 233.97,87.43 233.96,87.39 233.84,87.39 233.37,86.93 233.35,86.9 233.33,86.87 233.25,86.83 233.17,86.86 233.14,86.89 233.1,86.91 233.05,87 233.1,87.09 233.18,87.15 233.23,87.22 233.24,87.24 233.34,87.28 233.52,87.92 232.88,87.74 232.84,87.64 232.82,87.63 232.75,87.58 232.69,87.5 232.6,87.45 232.51,87.5 232.45,87.58 232.38,87.63 232.36,87.64 232.27,87.87 232.17,87.97 232.12,88.05 232.17,88.13 232.21,88.17 232.29,88.19 232.36,88.14 232.84,87.97 233.07,88.42 233.07,88.46 233.09,88.48 233.13,88.51 233.17,88.54
GND on BOTTOM (solid shape): 223.29,114.76 223.29,114.43 223.6,114.13 223.58,114.09 223.6,113.78 223.88,113.65 223.96,113.62 223.99,113.55 223.99,113.51 224.25,113.26 224.25,113.24 224.28,113.12 224.35,113.02 224.39,112.95 224.36,112.87 224.35,112.86 224.35,112.78 224.31,112.74 224.29,112.7 224.2,112.65 224.11,112.7 224.05,112.78 223.95,112.84 223.93,112.85 223.92,112.9 223.26,113.11 223.51,112.47 223.56,112.46 223.57,112.43 223.62,112.35 223.7,112.29 223.75,112.2 223.7,112.11 223.6,112.03 223.55,111.91 223.55,111.88 223.28,111.79 223.21,111.75 223.14,111.73 223.08,111.75 223.06,111.77 223.02,111.86 223.06,111.93 223.21,112.4 222.79,112.63 222.75,112.64 222.73,112.66 222.71,112.7 222.69,112.74 222.98,113.04 222.98,113.36 223.02,113.37 223.32,113.75 223,114.12 223,114.72 223.17,114.88
GND on BOTTOM (solid shape): 225.39,114.76 225.39,114.36 225.67,114.08 225.66,114.05 225.71,113.76 225.98,113.65 226.06,113.62 226.09,113.55 226.09,113.51 226.34,113.26 226.35,113.24 226.42,113.05 226.6,112.95 226.62,112.95 226.66,112.9 226.61,112.85 226.6,112.85 226.48,112.8 226.39,112.7 226.3,112.65 226.21,112.7 226.15,112.78 226.08,112.83 226.06,112.84 226.02,112.94 225.38,113.12 225.56,112.48 225.66,112.44 225.67,112.42 225.72,112.35 225.8,112.29 225.85,112.2 225.8,112.11 225.72,112.05 225.67,111.98 225.66,111.96 225.41,111.85 225.31,111.72 225.23,111.66 225.14,111.7 225.11,111.73 225.08,111.8 225.11,111.87 225.21,112.27 224.9,112.53 224.87,112.55 224.85,112.58 224.84,112.64 224.81,112.7 224.79,112.74 225.1,113.05 225.1,113.3 225.32,113.76 224.89,114.03 224.86,114.03 224.83,114.06 224.8,114.12 225.11,114.42 225.11,114.71 225.28,114.88
GND on BOTTOM (solid shape): 217.9,111.05 217.99,111 218.22,110.85 218.48,110.95 218.84,110.95 218.87,110.8 219,110.56 219.25,110.47 219.32,110.45 219.46,110.21 219.66,110.15 219.78,110.15 219.9,110.03 219.9,109.58 219.74,109.43 219.49,109.43 219.04,108.98 218.86,108.98 218.46,109.38 218.35,109.38 218.35,109.46 218.38,109.47 218.47,109.54 218.53,109.63 218.54,109.66 218.6,109.67 218.82,110.32 218.17,110.1 218.16,110.04 218.13,110.03 217.95,109.82 218.03,109.55 218.04,109.44 217.95,109.38 217.31,109.38 216.89,108.95 216.81,108.95 216.75,109.02 216.72,109.09 216.75,109.16 216.88,109.46 216.74,109.75 216.71,109.82 216.73,109.89 216.77,109.94 216.85,109.98 216.93,109.94 217.34,109.78 217.63,110.1 217.64,110.16 217.67,110.17 217.85,110.45 217.66,110.73 217.63,110.76 217.64,110.86 217.67,110.87 217.75,110.92 217.81,111
GND on BOTTOM (solid shape): outline of 126 points within 211.77,88.57 212.52,106.43
GND on BOTTOM (solid shape): 214.75,113.39 214.78,113.38 214.85,113.35 214.98,113.31 214.96,113.24 214.94,113.23 214.73,112.83 215.03,112.51 215.15,112.48 215.16,112.45 215.42,112.25 215.71,112.4 215.8,112.45 215.89,112.4 215.95,112.32 216.04,112.27 216.08,112.25 216.04,112.14 216.02,112.13 215.85,111.84 216.04,111.57 216.08,111.55 216.04,111.44 216.02,111.43 215.95,111.38 215.89,111.3 215.8,111.25 215.71,111.3 215.41,111.45 215.16,111.24 214.8,111 214.89,110.57 214.92,110.5 214.89,110.43 214.86,110.4 214.83,110.37 214.75,110.32 214.67,110.37 214.57,110.47 214.34,110.56 214.33,110.58 214.28,110.65 214.2,110.71 214.15,110.8 214.2,110.89 214.26,110.94 214.31,111 214.33,111.02 214.39,111.02 214.81,111.27 214.65,111.73 214.6,111.8 214.63,111.88 214.71,112.28 214.4,112.53 214.37,112.55 214.35,112.58 214.34,112.64 214.32,112.69 214.3,112.73 214.61,113.04 214.61,113.3 214.67,113.34 214.72,113.38
GND on BOTTOM (solid shape): 360.84,71.89 360.82,71.59 361.04,71.4 361.05,71.39 361.19,71.26 361.19,71.24 361.36,71.04 361.61,71.09 361.69,71.12 361.77,71.09 362.06,71.06 362.19,71.32 362.16,71.35 362.15,71.38 362.15,71.44 362.09,71.5 362.09,71.88 362.21,72.01 362.45,72.01 362.58,71.88 362.58,71.46 362.71,71.32 363,71.32 363.16,71.17 363.16,69.58 363.16,69.17 363.12,69.09 363.03,69.08 362.65,68.9 362.74,68.5 362.75,68.49 362.77,68.45 362.75,68.41 362.72,68.25 362.8,68.1 362.8,67.97 362.72,67.84 362.73,67.69 362.75,67.65 362.69,67.59 361.95,67.59 361.82,67.73 361.82,68.08 361.8,68.1 361.8,68.96 361.9,69.06 362.16,69.36 361.77,69.43 361.69,69.4 361.44,69.51 361.19,69.4 361.11,69.43 361.02,69.5 360.92,69.51 360.89,69.51 360.69,69.71 360.69,69.74 360.69,69.85 360.63,69.95 360.6,70.03 360.7,70.28 360.6,70.53 360.63,70.62 360.64,70.95 360.28,70.98 360.04,70.98 359.96,70.99 359.83,70.98 359.72,71.09 359.72,71.87 359.87,72.02 360.7,72.02
GND on BOTTOM (solid shape): outline of 141 points within 226.05,88.53 226.87,106.47
GND on BOTTOM (solid shape): outline of 234 points within 229.35,104.25 232.9,106.05
GND on BOTTOM (solid shape): 232.44,103.57 232.44,103.47 232.45,102.83 233.03,103.1 233.04,103.16 233.11,103.19 233.17,103.24 233.25,103.27 233.33,103.23 233.61,103.06 233.93,103.17 233.99,103.24 234.06,103.27 234.13,103.24 234.23,103.17 234.35,103.15 234.37,103.15 234.62,102.9 235.12,102.9 235.36,102.65 235.07,102.35 235.04,102.35 234.82,102.25 234.75,102.02 234.72,101.94 234.65,101.9 234.29,101.9 234.19,101.97 234.22,102.08 234.24,102.6 233.71,102.65 233.63,102.63 233.56,102.67 233.16,102.82 232.87,102.5 232.83,102.33 232.77,102.29 232.43,102.29 232.37,102.33 232.31,102.35 232.28,102.35 232.22,102.54 231.93,102.82 231.55,102.68 231.54,102.67 231.5,102.65 231.47,102.67 231.21,102.73 230.97,102.61 230.9,102.58 230.55,102.73 230.2,102.58 229.85,102.73 229.5,102.58 229.43,102.61 229.39,102.65 229.35,102.67 229.35,102.83 229.43,102.89 229.49,102.97 229.8,103.28 229.9,103.28 230.15,103.15 230.4,103.28 230.6,103.28 230.8,103.15 231.04,103.21 231.42,103.21 231.44,103.21 231.64,103.2 231.79,103.34 231.8,103.35 232.09,103.64 232.37,103.64
GND on BOTTOM (solid shape): outline of 101 points within 207.58,109.23 211.15,114.78
GND on BOTTOM (solid shape): outline of 179 points within 224.7,88.53 225.53,106.47
GND on BOTTOM (solid shape): outline of 188 points within 213.17,88.57 213.88,106.44
GND on BOTTOM (solid shape): outline of 230 points within 223.16,88.53 224.08,106.47
GND on BOTTOM (solid shape): outline of 484 points within 105.64,56.48 132.56,75.62
GND on BOTTOM (solid shape): outline of 214 points within 210.37,88.57 211.08,106.43
GND on BOTTOM (solid shape): outline of 200 points within 219.1,88.53 219.93,106.47
GND on BOTTOM (solid shape): outline of 201 points within 221.9,88.53 222.82,106.47
GND on BOTTOM (solid shape): outline of 266 points within 215.97,88.56 216.7,106.41
GND on BOTTOM (solid shape): outline of 293 points within 220.48,88.56 221.24,106.44
GND on BOTTOM (solid shape): outline of 311 points within 214.58,88.57 215.28,106.41
GND on BOTTOM (solid shape): outline of 237 points within 227.2,106.85 233.08,114.79
GND on BOTTOM (solid shape): outline of 239 points within 0.2,0.2 365.77,62.59
GND on BOTTOM (solid shape): outline of 1498 points within 357.14,54.26 383.1,143.1
GND on BOTTOM (solid shape): outline of 224 points within 0.21,55.94 369.02,146.7
GND on BOTTOM (solid shape): outline of 1605 points within 350.04,50.11 358.37,58.38
GND on BOTTOM (solid shape): outline of 3621 points within 221.46,32.92 245.53,45.3
GND on BOTTOM (solid shape): outline of 3843 points within 178.35,32.92 206.29,44.67
GND on BOTTOM (solid shape): outline of 7404 points within 100.56,32.59 181.65,56.04
GND on BOTTOM (solid shape): outline of 11943 points within 200.55,77.59 236.25,109.43
GND on BOTTOM (solid shape): outline of 11883 points within 274.14,30.44 298.8,52.29
GND on GND1 (solid shape): 128.37,20.73 123.67,20.73 123.67,23.52 128.37,23.52
GND on GND1 (solid shape): 237.4,20.67 232.7,20.67 232.7,23.46 237.4,23.46
GND on GND1 (solid shape): 19.69,99.29 19.87,99.05 19.94,98.76 20,97.92 20.08,97.09 21.9,88.3 25.47,80.06 25.91,79.61 26.52,79.45 31.38,79.45 31.75,79.36 32.03,79.11 33.42,77.27 34.92,75.51 34.64,75.23 34.55,75.23 33.05,77 31.66,78.85 31.54,78.95 31.38,78.99 26.52,78.99 25.68,79.22 25.07,79.84 21.45,88.18 19.62,97.09 19.55,97.91 19.49,98.74 19.46,98.86 19.38,98.96 18.18,100.1 18.5,100.42
GND on IN1 (solid shape): 372.75,67.53 372.75,64.67 372.53,64.46 371.82,64.46 371.51,64.76 371.51,67.5 371.64,67.63 372.64,67.63
GND on IN1 (solid shape): 372.61,75.15 372.61,73.51 372.97,73.14 372.97,73.12 372.99,72.93 373.1,72.78 373.1,72.66 372.89,72.44 372.58,72.44 372.07,72.95 372.07,75.2 372.16,75.29 372.47,75.29
GND on IN1 (solid shape): 369.23,21 369.83,20.3 370.6,20.8 373.99,20.8 374.49,21.1 380.1,21.1 380.1,18.37 379.64,18.37 379.64,18.38 370.12,18.38 368.6,19.9 365.48,19.9 364.78,20.6 364.78,22.32 365.17,22.71 369.23,22.71
GND on IN1 (solid shape): 11.96,76.67 13.53,75.1 16.65,75.1 17.01,74.74 17.01,73.59 16.74,73.32 12.77,73.32 12.77,74.75 12.17,75.45 11.4,74.95 8.01,74.95 7.51,74.65 3.42,74.65 3.42,77 3.42,79.05 3.07,79.9 2.22,80.25 1,80.25 0.44,80.49 0.2,81.05 0.2,82.31 0.29,82.52 0.5,82.61 4.65,82.61 4.65,82.61 5,82.61 5.21,82.52 5.3,82.31 5.3,82.1 5.5,81.6 6,81.4 6.8,81.4 7.3,81.6 7.5,82.1 7.5,82.31 7.59,82.52 7.8,82.61 8.17,82.61 8.17,82.61 11.4,82.61 11.71,82.68 11.96,82.89
GND on IN1 (solid shape): outline of 171 points within 365.23,33.35 380.09,43.49
GND on IN1 (solid shape): outline of 264 points within 0.2,0.2 365.77,62.51
GND on IN1 (solid shape): outline of 1449 points within 357.14,54.24 383.1,143.1
GND on IN1 (solid shape): outline of 216 points within 0.2,58.04 369.7,146.7
GND on GND2 (solid shape): 237.4,20.67 232.7,20.67 232.7,23.46 237.4,23.46
GND on GND2 (solid shape): 128.4,20.2 123.5,20.2 123.5,23.89 128.4,23.89
GND on GND2 (solid shape): 19.69,99.29 19.87,99.05 19.94,98.76 20,97.92 20.08,97.09 21.9,88.3 25.47,80.06 25.91,79.61 26.52,79.45 31.38,79.45 31.75,79.36 32.03,79.11 33.42,77.27 34.92,75.51 34.64,75.23 34.55,75.23 33.05,77 31.66,78.85 31.54,78.95 31.38,78.99 26.52,78.99 25.68,79.22 25.07,79.84 21.45,88.18 19.62,97.09 19.55,97.91 19.49,98.74 19.46,98.86 19.38,98.96 18.18,100.1 18.5,100.42
GND on IN2 (solid shape): 369.23,21 369.83,20.3 370.6,20.8 373.99,20.8 374.49,21.1 380.1,21.1 380.1,18.37 379.64,18.37 379.64,18.38 370.13,18.38 368.6,19.9 365.48,19.9 364.78,20.6 364.78,22.32 365.17,22.71 369.23,22.71
GND on IN2 (solid shape): 11.96,76.67 13.52,75.11 16.6,75.11 16.98,74.73 16.98,73.5 16.8,73.32 12.77,73.32 12.77,74.75 12.17,75.45 11.4,74.95 8.01,74.95 7.51,74.65 3.42,74.65 3.42,77 3.42,79.05 3.07,79.9 2.22,80.25 1,80.25 0.44,80.49 0.2,81.05 0.2,82.31 0.29,82.52 0.5,82.61 5,82.61 5.21,82.52 5.3,82.31 5.3,82.1 5.5,81.6 6,81.4 6.8,81.4 7.3,81.6 7.5,82.1 7.5,82.31 7.59,82.52 7.8,82.61 11.4,82.61 11.71,82.68 11.96,82.89
GND on IN2 (solid shape): outline of 170 points within 365.17,33.35 380.09,43.47
GND on IN2 (solid shape): outline of 252 points within 0.2,0.2 365.77,62.59
GND on IN2 (solid shape): outline of 1382 points within 357.14,54.24 383.1,143.1
GND on IN2 (solid shape): outline of 215 points within 0.2,58.04 369.65,146.7
GND on VCC (solid shape): 19.69,99.29 19.87,99.05 19.94,98.76 20,97.92 20.08,97.09 21.9,88.3 25.47,80.06 25.91,79.61 26.52,79.45 31.38,79.45 31.75,79.36 32.03,79.11 33.42,77.27 34.92,75.51 34.64,75.23 34.55,75.23 33.05,77 31.66,78.85 31.54,78.95 31.38,78.99 26.52,78.99 25.68,79.22 25.07,79.84 21.45,88.18 19.62,97.09 19.55,97.91 19.49,98.74 19.46,98.86 19.38,98.96 18.18,100.1 18.5,100.42
GND on IN3 (solid shape): 369.23,21 369.83,20.3 370.6,20.8 373.99,20.8 374.49,21.1 380.1,21.1 380.1,18.37 379.64,18.37 379.64,18.38 370.13,18.38 368.6,19.9 365.48,19.9 364.78,20.6 364.78,22.32 365.17,22.71 369.23,22.71
GND on IN3 (solid shape): 11.96,76.67 13.52,75.11 16.59,75.11 16.98,74.72 16.98,73.5 16.79,73.31 12.77,73.31 12.77,74.75 12.17,75.45 11.4,74.95 8.01,74.95 7.51,74.65 3.42,74.65 3.42,77 3.42,79.05 3.07,79.9 2.22,80.25 1,80.25 0.44,80.49 0.2,81.05 0.2,82.31 0.29,82.52 0.5,82.61 5,82.61 5.21,82.52 5.3,82.31 5.3,82.1 5.5,81.6 6,81.4 6.8,81.4 7.3,81.6 7.5,82.1 7.5,82.31 7.59,82.52 7.8,82.61 11.4,82.61 11.71,82.68 11.96,82.89
GND on IN3 (solid shape): outline of 170 points within 365.23,33.35 380.09,43.49
GND on IN3 (solid shape): outline of 250 points within 0.2,0.2 365.77,62.59
GND on IN3 (solid shape): outline of 1446 points within 357.14,54.24 383.1,143.1
GND on IN3 (solid shape): outline of 217 points within 0.2,58.04 369.72,146.7
GND on IN4 (solid shape): 369.23,21 369.83,20.3 370.6,20.8 373.99,20.8 374.49,21.1 380.1,21.1 380.1,18.37 379.64,18.37 379.64,18.38 370.13,18.38 368.6,19.9 365.48,19.9 364.78,20.6 364.78,22.32 365.17,22.71 369.23,22.71
GND on IN4 (solid shape): 11.96,76.67 13.52,75.11 16.61,75.11 17.04,74.68 17.04,73.52 16.84,73.32 12.77,73.32 12.77,74.75 12.17,75.45 11.4,74.95 8.01,74.95 7.51,74.65 3.42,74.65 3.42,77 3.42,79.05 3.07,79.9 2.22,80.25 1,80.25 0.44,80.49 0.2,81.05 0.2,82.31 0.29,82.52 0.5,82.61 5,82.61 5.21,82.52 5.3,82.31 5.3,82.1 5.5,81.6 6,81.4 6.8,81.4 7.3,81.6 7.5,82.1 7.5,82.31 7.59,82.52 7.8,82.61 11.4,82.61 11.71,82.68 11.96,82.89
GND on IN4 (solid shape): outline of 170 points within 365.23,33.35 380.09,43.5
GND on IN4 (solid shape): outline of 250 points within 0.2,0.2 365.77,62.59
GND on IN4 (solid shape): outline of 1458 points within 357.14,54.24 383.1,143.1
GND on IN4 (solid shape): outline of 215 points within 0.2,58.04 369.65,146.7
GND on IN4 (solid shape): outline of 29988 points within 217.54,71.97 266.99,143.2
GND on GND3 (solid shape): 237.4,20.67 232.7,20.67 232.7,23.46 237.4,23.46
GND on GND3 (solid shape): 128.37,20.21 123.1,20.21 123.1,23.52 128.37,23.52
GND on GND3 (solid shape): 19.69,99.29 19.87,99.05 19.94,98.76 20,97.92 20.08,97.09 21.9,88.3 25.47,80.06 25.91,79.61 26.52,79.45 31.38,79.45 31.75,79.36 32.03,79.11 33.42,77.27 34.92,75.51 34.64,75.23 34.55,75.23 33.05,77 31.66,78.85 31.54,78.95 31.38,78.99 26.52,78.99 25.68,79.22 25.07,79.84 21.45,88.18 19.62,97.09 19.55,97.91 19.49,98.74 19.46,98.86 19.38,98.96 18.18,100.1 18.5,100.42
GND on IN5 (solid shape): 365.48,124.75 365.48,114.54 359.64,108.7 357.44,108.7 357.14,109 357.14,120.66 357.17,120.88 357.26,121.09 359.59,124.82 359.88,125.1 360.27,125.2 365.04,125.2
GND on IN5 (solid shape): 352.41,64.15 352.48,64.15 352.55,64.15 352.58,64.16 354.29,62.45 354.29,62.42 354.38,62.11 354.7,62.01 354.72,62.01 354.77,61.97 354.77,61.82 353.84,60.89 353.57,60.89 351.65,62.81 351.65,63.43 352.39,64.16
GND on IN5 (solid shape): 369.23,21 369.83,20.3 370.6,20.8 373.99,20.8 374.49,21.1 380.1,21.1 380.1,18.37 379.64,18.37 379.64,18.38 370.13,18.38 368.6,19.9 365.48,19.9 364.78,20.6 364.78,22.32 365.17,22.71 369.23,22.71
GND on IN5 (solid shape): 372.57,69.46 372.79,69.38 373.01,69.47 373.13,69.47 373.21,69.43 373.23,69.34 373.38,68.96 373.79,69.02 373.86,69.05 373.94,69.02 374.02,68.95 374.13,68.92 374.17,68.91 374.17,64.23 373.66,63.72 373.23,63.72 372.9,64.05 372.9,66.26 372.28,66.88 372.28,69.27 372.48,69.47 372.56,69.47
GND on IN5 (solid shape): 11.96,76.67 13.52,75.11 16.6,75.11 17.04,74.67 17.04,73.51 16.84,73.31 12.77,73.31 12.77,74.75 12.17,75.45 11.4,74.95 8.01,74.95 7.51,74.65 3.42,74.65 3.42,77 3.42,79.05 3.07,79.9 2.22,80.25 1,80.25 0.44,80.49 0.2,81.05 0.2,82.31 0.29,82.52 0.5,82.61 5,82.61 5.21,82.52 5.3,82.31 5.3,82.1 5.5,81.6 6,81.4 6.8,81.4 7.3,81.6 7.5,82.1 7.5,82.31 7.59,82.52 7.8,82.61 11.4,82.61 11.71,82.68 11.96,82.89
GND on IN5 (solid shape): outline of 170 points within 365.23,33.35 380.09,43.51
GND on IN5 (solid shape): outline of 399 points within 365.42,54.24 383.1,115.85
GND on IN5 (solid shape): outline of 252 points within 0.2,0.2 365.77,62.59
GND on IN5 (solid shape): outline of 265 points within 0.2,58.04 382.4,146.7
GND on GND4 (solid shape): 237.4,20.67 232.7,20.67 232.7,23.46 237.4,23.46
GND on GND4 (solid shape): 128.37,20.21 123.28,20.21 123.28,23.52 128.37,23.52
GND on GND4 (solid shape): 19.69,99.29 19.87,99.05 19.94,98.76 20,97.92 20.08,97.09 21.9,88.3 25.47,80.06 25.91,79.61 26.52,79.45 31.38,79.45 31.75,79.36 32.03,79.11 33.42,77.27 34.92,75.51 34.64,75.23 34.55,75.23 33.05,77 31.66,78.85 31.54,78.95 31.38,78.99 26.52,78.99 25.68,79.22 25.07,79.84 21.45,88.18 19.62,97.09 19.55,97.91 19.49,98.74 19.46,98.86 19.38,98.96 18.18,100.1 18.5,100.42
GND on TOP: 177.12,127.8 178.4,127.8 178.96,127.24 182.98,127.24 183.88,126.34 183.88,122.88 182.14,121.14 181.15,121.14 180.65,120.63 180.65,120.16 180.38,119.89 179.15,119.89 178.82,119.56 178.82,118.27 178.77,118.21 176.9,118.21 176.76,118.35 176.76,121.96 176.12,122.6 176.12,125.78 176.35,126.01 176.9,126.01 177.01,126.13 177.01,127.7
GND on TOP: 141.09,127.08 142.86,127.08 143.37,126.57 143.37,126.18 143.73,125.82 147.7,125.82 147.8,125.92 149.55,125.92 149.65,126.02 149.65,127.05 149.76,127.16 151.18,127.16 152.33,126.01 156.43,126.01 156.62,126.21 157.92,126.21 158.28,126.57 158.28,127.03 158.41,127.17 159.89,127.17 160.98,126.08 162.03,126.08 162.63,125.48 166.08,125.48 166.24,125.32 167.4,125.32 168.1,126.02 168.1,126.59 168.29,126.78 169.67,126.78 169.8,126.65 169.8,124.98 170.23,124.55 170.23,120.01 170.07,119.85 168.55,119.85 167.17,121.22 165.91,121.22 165.86,121.17 165.86,120.04 165.67,119.85 165.32,119.85 164.97,119.49 163.49,119.49 163.08,119.91 163.08,123.67 162.76,123.99 158.7,123.99 158.54,123.83 158.54,121.16 157.63,120.25 154.13,120.25 154,120.38 154,121.1 154.25,121.35 154.25,121.91 154.3,121.96 155.08,121.96 155.32,122.21 155.32,123.5 155.16,123.67 154.45,123.67 154.22,123.91 149.95,123.91 149.69,123.65 149.69,120.77 148.95,120.02 145.64,120.02 145.03,120.63 145.03,123.68 144.92,123.78 141.44,123.78 140.89,124.34 140.89,126.88
GND on TOP: 173.98,145.74 188.47,145.74 189.32,144.88 189.32,142.33 191.25,140.4 191.25,138.29 190.86,137.9 181.64,137.9 180.9,137.16 180.9,132.24 180.68,132.02 179.17,132.02 178.93,132.26 178.93,133.57 178.78,133.72 177.51,133.72 177.39,133.61 177.39,130.84 177.53,130.7 177.93,130.7 178.07,130.56 178.07,129.91 178.04,129.89 174.27,129.89 174.07,130.09 174.07,131.36 175.24,132.53 175.24,134.76 174.61,135.38 174.61,137.14 174.79,137.32 176.91,137.32 176.96,137.37 176.96,138.6 176.85,138.71 175.93,138.71 175.81,138.84 175.81,139.41 175.62,139.6 174.92,139.6 174.78,139.74 174.78,143.56 173.8,144.54 173.8,145.56
GND on BOTTOM: 52.43,36.32 47.62,36.32 47.58,36.27 47.58,34.85 47.72,34.71 52.23,34.71 52.52,35 52.52,36.22
GND on BOTTOM: 39.5,34.47 39.62,34.35 41.86,34.35 42.48,33.73 42.48,31.05 43.5,30.04 43.5,29.31 42.72,28.54 36.77,28.54 34.67,30.63 34.67,33.96 35.18,34.47
GND on GND1: outline of 383 points within 0.2,0.2 383.1,146.7
GND on GND1: 11.58,97.35 11.49,97.37 11.4,97.37 7.8,97.37 7.59,97.46 7.5,97.67 7.5,97.9 7.3,98.4 6.8,98.6 6,98.6 5.5,98.4 5.3,97.9 5.3,97.67 5.21,97.46 5,97.37 0.5,97.37 0.29,97.46 0.2,97.67 0.2,99.85 0.44,100.41 1,100.65 2.6,100.65 3.45,101 3.8,101.85 3.8,105.55 4.04,106.11 4.6,106.35 11.94,106.35 12.02,106.34 12.1,106.33 12.3,106.26 12.48,106.13 19.04,99.91 12.1,99.91 11.99,99.91 11.86,99.79 11.86,97.63
GND on GND2: outline of 386 points within 0.2,0.2 383.1,146.7
GND on GND2: 11.56,97.35 11.48,97.37 11.4,97.37 7.8,97.37 7.59,97.46 7.5,97.67 7.5,97.9 7.3,98.4 6.8,98.6 6,98.6 5.5,98.4 5.3,97.9 5.3,97.67 5.21,97.46 5,97.37 0.5,97.37 0.29,97.46 0.2,97.67 0.2,99.85 0.2,99.89 0.45,100.43 1,100.65 2.6,100.65 3.45,101 3.8,101.85 3.8,105.55 4.04,106.11 4.6,106.35 11.94,106.35 12.23,106.29 12.48,106.13 19.02,99.94 12.04,99.94 11.88,99.77 11.88,97.67
GND on VCC: outline of 205 points within 298.49,0.2 383.1,143.1
GND on VCC: 231.94,35.46 103.71,35.52 100.66,38.57 78.19,38.57 77.45,39.31 77.45,51.53 95.33,51.53 117.9,74.09 117.9,77.39 120.88,80.38 120.88,85.27 125.77,90.16 125.77,109.08 126.19,109.5 127.57,109.5 133.9,103.17 133.9,90.16 133.9,87.01 133.9,87 133.9,86.79 133.9,86.78 134.58,86.1 138.88,86.1 139.51,85.47 174.67,85.47 179.64,85.44 179.93,85.14 179.93,82.66 180.78,81.82 184.32,81.82 184.32,77.65 187.07,74.89 189.61,74.89 190.98,73.52 190.98,63.8 194.82,59.97 200.66,59.97 204.66,55.97 205.64,55.97 205.92,55.61 206.19,55.97 226.18,55.97 231.14,51.02 236.03,51.02 239.07,47.97 242.69,47.97 245.91,44.75 245.91,37.03 244.35,35.46
GND on VCC: 11.56,97.35 11.48,97.37 11.4,97.37 7.8,97.37 7.59,97.46 7.5,97.67 7.5,97.9 7.3,98.4 6.8,98.6 6,98.6 5.5,98.4 5.3,97.9 5.3,97.67 5.21,97.46 5,97.37 0.5,97.37 0.29,97.46 0.2,97.67 0.2,99.85 0.2,99.89 0.45,100.43 1,100.65 2.6,100.65 3.45,101 3.8,101.85 3.8,105.55 4.04,106.11 4.6,106.35 11.94,106.35 12.23,106.29 12.48,106.13 19.04,99.91 12,99.91 11.88,99.79 11.88,97.67
GND on VCC: 41.36,33.56 34.31,40.6 0.2,40.6 0.2,56.33 0.28,56.71 0.56,57.17 1.06,57.35 2.22,57.35 3.07,57.7 3.42,58.55 3.42,60.65 7.51,60.65 8.01,60.35 11.4,60.35 12.17,59.85 12.77,60.55 12.77,74.75 12.17,75.45 11.4,74.95 8.01,74.95 7.51,74.65 3.42,74.65 3.42,79.05 3.31,79.57 2.98,79.99 2.98,79.99 2.62,80.19 2.22,80.25 1,80.25 0.44,80.49 0.2,81.05 0.2,82.31 0.29,82.52 0.5,82.61 5,82.61 5.21,82.52 5.3,82.31 5.3,82.1 5.5,81.6 6,81.4 6.8,81.4 7.3,81.6 7.5,82.1 7.5,82.31 7.59,82.52 7.8,82.61 11.4,82.61 11.73,82.69 11.98,82.91 11.98,76.65 13.51,75.12 16.64,75.12 17.07,74.69 17.07,71.56 19.13,69.5 32.89,69.5 33.88,70.5 33.88,76.7 43.45,68.46 55.16,63.73 55.16,41.83 57.85,39.14 69.15,39.14 69.57,38.72 69.57,33.98 69.15,33.56
GND on VCC: 244.24,52.03 232.87,63.4 202.96,63.4 198.41,67.95 198.41,74.94 195.72,77.63 195.72,78.23 195.85,78.36 226.74,78.36 227.88,79.5 227.88,105.61 226.08,107.41 212.36,107.41 196.76,123.01 196.76,135.45 193.44,138.78 182.69,138.78 180.19,136.28 180.19,132.89 180.57,132.51 180.57,116.3 143.08,116.3 142.66,116.72 142.66,126.52 168.61,126.52 169.77,127.69 169.77,135.39 168.42,136.74 120.84,136.74 117.35,133.25 112.9,133.25 112.9,136.96 113.12,138.03 113.72,138.93 114.97,140.18 115.87,140.78 116.94,141 126,141 126.85,141.35 127.2,142.2 127.2,145.9 127.44,146.46 128,146.7 246.82,146.7 247.03,146.61 247.12,146.4 247.12,146.15 247.33,145.65 247.82,145.45 254.54,145.45 254.75,145.36 254.84,145.15 254.84,142.2 255.19,141.35 256.04,141 265.1,141 266.17,140.78 267.07,140.18 268.32,138.93 268.92,138.03 269.14,136.96 269.14,90.13 270.08,87.86 272.35,86.93 273.1,86.93 274.38,86.41 274.91,85.13 274.91,82.92 276.55,78.95 280.51,77.31 283.28,77.31 284.18,77.07 284.84,76.41 285.43,75.41 286.05,74.43 283.82,72.21 283.82,62.49 283.4,62.07 272.86,62.07 262.82,52.03
GND on GND3: 11.58,97.35 11.49,97.37 11.4,97.37 7.8,97.37 7.59,97.46 7.5,97.67 7.5,97.9 7.3,98.4 6.8,98.6 6,98.6 5.5,98.4 5.3,97.9 5.3,97.67 5.21,97.46 5,97.37 0.5,97.37 0.29,97.46 0.2,97.67 0.2,99.85 0.21,99.9 0.46,100.43 1,100.65 2.6,100.65 3.45,101 3.8,101.85 3.8,105.55 4.04,106.11 4.6,106.35 11.94,106.35 12.23,106.29 12.48,106.13 19.05,99.9 11.98,99.9 11.88,99.8 11.88,97.64
GND on GND3: outline of 390 points within 0.2,0.2 383.1,146.7 ; 1 cut-out
GND on GND4: 11.56,97.35 11.48,97.37 11.4,97.37 7.8,97.37 7.59,97.46 7.5,97.67 7.5,97.9 7.3,98.4 6.8,98.6 6,98.6 5.5,98.4 5.3,97.9 5.3,97.67 5.21,97.46 5,97.37 0.5,97.37 0.29,97.46 0.2,97.67 0.2,99.85 0.21,99.91 0.46,100.44 1,100.65 2.6,100.65 3.45,101 3.8,101.85 3.8,105.55 4.04,106.11 4.6,106.35 11.94,106.35 12.23,106.29 12.48,106.13 19.04,99.91 11.99,99.91 11.88,99.8 11.88,97.67
GND on GND4: outline of 388 points within 0.2,0.2 383.1,146.7
VCC_1.8V on TOP (solid shape): 269.22,81.69 269.22,81.63 269.34,81.5 269.34,81.37 269.72,80.99 269.85,80.99 270.04,80.8 270.04,80.29 269.91,80.17 269.53,80.17 269.03,80.67 268.9,80.67 268.77,80.8 268.77,81.63 268.9,81.75 269.15,81.75
VCC_1.8V on BOTTOM (solid shape): 269.28,81.63 269.28,81.31 269.41,81.18 270.06,81.18 270.17,81.07 270.17,80.32 270.07,80.23 269.47,80.23 269.03,80.67 268.9,80.67 268.77,80.81 268.77,80.98 268.77,81.63 268.9,81.75 269.15,81.75
VCC_CHG on BOTTOM (solid shape): 41.7,43.63 41.7,42.26 41.48,42.04 38.49,42.04 38.27,42.26 38.27,43.49 38.69,43.91 41.41,43.91
VCC_CHG_1 on TOP (solid shape): 39.52,41.24 39.52,40.63 39.21,40.32 37.6,40.32 37.57,40.29 37.42,40.29 37.09,39.96 37.09,39.61 37,39.52 36.23,39.52 36.12,39.63 36.12,40.56 36.73,41.16 37.17,41.16 37.59,41.58 39.18,41.58
VCC_CHG_1 on BOTTOM (solid shape): 40.36,41 40.36,39.06 40.24,38.94 38.54,38.94 38.46,39.02 38.46,40.95 38.64,41.13 40.23,41.13
VCC_CORE_PH1 on TOP (solid shape): 151.72,123.56 151.72,121.61 151.42,121.31 150.22,121.31 150.04,121.49 150.04,123.55 150.15,123.66 151.61,123.66
VCC_CORE_PH1 on BOTTOM (solid shape): 149.36,125.03 149.36,123.88 149.55,123.69 153.23,123.69 153.3,123.63 153.3,119.28 153.11,119.09 149.71,119.09 149.58,119.22 149.58,121.31 148.41,122.49 148.41,125.03 148.53,125.15 149.23,125.15
VCC_CORE_PH2 on TOP (solid shape): 142.59,123.58 142.59,121.44 142.46,121.3 141.38,121.3 140.88,121.8 140.88,123.55 140.98,123.65 142.52,123.65
VCC_CORE_PH2 on BOTTOM (solid shape): 140.79,124.84 140.79,123.69 140.98,123.5 144.66,123.5 144.91,123.25 144.91,119.22 144.76,119.06 141.42,119.06 141.26,119.22 141.26,121.25 139.83,122.68 139.83,124.84 139.96,124.96 140.66,124.96
VCC_CORE_PH3 on TOP (solid shape): 160.31,123.6 160.31,121.63 160.06,121.38 159.3,121.38 158.85,121.82 158.85,123.66 158.98,123.79 160.12,123.79
VCC_CORE_PH3 on BOTTOM (solid shape): 158.03,125.04 158.03,123.85 158.22,123.66 161.9,123.66 161.96,123.6 161.96,122.9 161.65,122.58 161.65,119.22 158.09,119.22 158.09,121.38 157.07,122.39 157.07,125 157.22,125.14 157.92,125.14
VCC_GT_PH1 on BOTTOM (solid shape): 126.79,125.46 126.79,121.6 125.36,120.17 125.36,119.57 124.69,118.9 124.69,117.25 124.37,116.93 121.07,116.93 120.88,117.12 120.88,117.82 120.94,117.88 122.15,117.88 122.34,118.07 122.34,121.82 122.87,122.36 123.78,122.36 123.78,122.3 123.78,122.25 123.8,122.2 123.82,122.16 123.85,122.11 123.89,122.08 123.93,122.05 123.98,122.02 124.03,122.01 124.08,122 124.13,122 124.18,122.01 124.23,122.02 124.28,122.05 124.32,122.08 124.36,122.11 124.39,122.16 124.41,122.2 124.43,122.25 124.44,122.3 124.44,122.36 124.43,122.41 124.41,122.46 124.39,122.5 124.36,122.54 124.32,122.58 124.28,122.61 124.23,122.64 124.18,122.65 124.13,122.66 124.08,122.66 124.03,122.65 123.98,122.64 123.93,122.61 123.89,122.58 123.85,122.54 123.82,122.5 123.8,122.46 123.78,122.41 123.78,122.36 122.87,122.36 124.12,123.6 124.12,125.38 124.44,125.69 126.55,125.69
VCC_GT_PH2 on TOP (solid shape): 126.59,134.01 126.59,132.43 126.34,132.17 124.61,132.17 124.49,132.3 124.49,133.81 124.78,134.11 126.5,134.11
VCC_GT_PH2 on BOTTOM (solid shape): 126.84,133.19 126.84,128.8 123.74,125.69 121.13,125.69 121.03,125.79 121.03,126.53 121.14,126.63 122.26,126.63 122.47,126.84 122.47,130.46 122.59,130.58 123.55,130.58 123.93,130.97 123.93,133.95 124.12,134.14 125.9,134.14
VCC_VCCIO on BOTTOM (solid shape): 125.64,101.63 125.64,99.66 125.45,99.47 125.01,99.47 124.94,99.53 124.94,100.74 124.88,100.8 124.88,101.63 124.94,101.69 125.58,101.69
VIN on TOP (solid shape): 54.57,58.93 54.57,58.3 54.16,57.9 54.16,56.34 54.08,56.26 53.59,56.26 53.06,55.73 53.06,54.83 53.57,54.32 53.57,49.88 53.19,49.49 48.93,49.49 48.81,49.62 48.81,58.75 49.28,59.22 54.28,59.22
VIN on BOTTOM (solid shape): 54.46,59.07 54.46,58.15 54.15,57.84 54.15,55.66 53.38,54.89 53.38,50.82 53.15,50.59 52.63,50.59 52.23,50.19 52.23,49.2 52.11,49.08 48.74,49.08 48.36,49.46 48.36,58.2 49.39,59.23 54.3,59.23
VIN on IN4 (solid shape): 54.08,58.07 54.08,53.75 53.57,53.24 48.74,53.24 47.66,54.32 47.66,57.69 48.87,58.89 53.25,58.89
VIN_2.5V on BOTTOM (solid shape): 175.43,30.44 175.43,27.33 175.69,27.07 175.69,26.72 175.14,26.72 175.14,26.22 175.69,26.22 175.69,25.92 175.14,25.92 175.14,25.52 175.14,25.42 175.25,25.42 175.69,25.42 175.69,25 175.61,24.93 174.61,24.93 173.89,25.65 173.89,26.54 173.01,27.41 171.79,27.41 171.59,27.61 171.59,27.97 171.8,28.18 173.41,28.18 174.16,28.92 174.16,30.37 174.35,30.57 175.31,30.57
+CHGRTC on BOTTOM (solid shape): 267.12,19.52 267.12,17.94 267.69,17.94 267.69,17.81 267.12,17.81 267.12,17.36 266.99,17.24 266.14,17.24 265.34,18.04 265.34,19.52 265.6,19.78 266.87,19.78
+CRT_5V_OUT on BOTTOM (solid shape): 370.88,121.06 370.88,119.41 371.07,119.22 372.53,119.22 372.97,118.77 372.97,117.63 372.66,117.31 372.08,117.31 372.07,117.32 371.92,117.35 371.78,117.32 371.77,117.31 371.07,117.31 370.82,117.06 370.82,116.49 370.69,116.36 369.8,116.36 369.55,116.61 369.55,120.61 370.12,121.19 370.75,121.19
+EDPVDD on TOP (solid shape): outline of 96 points within 89.17,50.12 97.03,53.48
+EDPVDD on BOTTOM (solid shape): 96.01,51.81 96.01,50.66 95.94,50.59 93.37,50.59 93.16,50.8 93.16,51.79 93.28,51.92 95.9,51.92
+EDPVDD_OUT on TOP (solid shape): 88.62,54.23 88.62,51.7 88.52,51.6 87.1,51.6 87.01,51.65 87.01,51.75 86.87,52.2 86.43,52.07 86.35,52.01 86.26,52.04 86.15,52.16 85.32,52.16 85.13,52.35 85.13,54.13 85.33,54.33 88.51,54.33
+FBX_PLLAVDD on BOTTOM (solid shape): 224.44,87.53 224.44,87.22 224.11,86.89 224.11,86.7 223.96,86.55 223.77,86.55 223.4,86.92 223.4,87.15 223.81,87.55 224.06,87.55 224.23,87.72 224.25,87.72
+FBX_PLLAVDD on BOTTOM (solid shape): 228.89,90.93 228.89,90.78 228.67,90.56 228.62,90.56 228.33,90.27 228.33,89.92 228.27,89.85 227.83,89.85 227.82,89.86 227.82,90.5 228.34,91.02 228.8,91.02
+FBX_PLLAVDD on BOTTOM (solid shape): 215.09,79.9 215.09,78.87 215.53,78.42 215.53,76.74 215.24,76.45 213.75,76.45 213.31,76 212.26,76 212.24,76.02 212.24,76.78 212.65,77.2 212.74,77.23 212.81,77.18 213.33,77.16 213.23,77.67 213.19,77.68 213.2,77.75 213.4,77.94 214.19,77.94 214.49,78.25 214.49,79.88 214.66,80.04 214.95,80.04
+FBX_PLLAVDD on IN1 (solid shape): outline of 852 points within 214.55,78.36 224.26,87.57
+INV_PWR_SRC on BOTTOM (solid shape): 95.99,42.32 95.99,40.92 95.92,40.86 94.08,40.86 93.7,41.24 92.88,41.24 91.35,39.72 91.35,37.49 91.67,37.18 93.77,37.18 94.15,36.79 94.15,33.43 93.89,33.18 90.21,33.18 89.7,33.68 89.7,37.37 88.69,38.38 85.32,38.38 84.94,38.76 84.94,40.1 85.38,40.54 87.61,40.54 88.43,41.37 91.23,41.37 92.3,42.45 95.86,42.45
+LAN_IO on BOTTOM (solid shape): 25.44,43.69 25.44,42.23 25.23,42.02 24.43,42.02 24.3,42.14 24.3,42.39 24.47,42.56 24.89,42.56 25.21,42.88 25.21,43.68 25.27,43.74 25.39,43.74
+LAN_IO on BOTTOM (solid shape): 30.6,46.2 30.6,45.94 30.51,45.85 29.48,45.85 29.43,45.91 29.13,45.91 29.01,45.79 28.84,45.79 28.81,45.82 27.98,45.82 27.92,45.88 27.92,45.97 28,46.05 28.78,46.05 28.85,46.13 29.12,46.13 29.3,46.31 29.38,46.31 29.54,46.47 30.33,46.47
+LAN_IO on TOP: 23.15,49.11 23.47,49.43 25.95,49.43 26.2,49.18 26.2,47.39 25.88,47.07 25.36,47.07 25.36,47.54 24.65,47.54 24.65,47.05 24.63,47.03 24.63,44.06 25.9,42.8 25.9,38.85 25.67,38.62 23.81,38.62 23.23,39.21 23.23,39.47 23.45,39.7 24.23,39.7 24.37,39.84 24.37,40.87 24.03,41.21 23.67,41.21 23.15,41.74
+LAN_IO on TOP: 29.58,45.32 31.17,45.32 31.3,45.45 31.3,46.43 31.12,46.61 29.69,46.61 29.47,46.4 29.47,45.43
+LAN_IO on BOTTOM: 23.89,46.63 23.83,46.69 23.83,47.61 23.19,48.25 23.19,48.63 23.07,48.75 22.93,48.75 22.72,48.95 22.72,50.51 24.07,51.86 24.07,52.38 24.34,52.65 25.02,52.65 25.2,52.47 25.2,51.53 24.48,50.81 24.48,49.16 24.14,48.82 24.14,48.07 24.38,47.83 24.38,47.23 24.73,46.88 24.73,46.69 24.67,46.63
+LAN_IO on IN3: 23.79,51.34 31.47,51.34 32.23,50.59 32.23,40.89 31.04,39.71 25.32,39.71 24.45,38.84 23.54,38.84 23.06,39.32 23.06,50.61
+LAN_VDD on BOTTOM (solid shape): 23.3,47.46 23.3,46.43 23.7,46.04 24.67,46.04 24.73,45.98 24.73,45.89 24.67,45.83 23.7,45.83 23.64,45.77 23.02,45.77 22.39,46.39 22.39,47.71 22.48,47.79 22.98,47.79
+LAN_VDD on BOTTOM (solid shape): 25.04,43.68 25.04,42.9 24.97,42.83 24.3,42.83 24.11,42.64 24.11,41.94 24.23,41.81 26,41.81 26.01,41.8 26.01,41.39 25.93,41.3 23.28,41.3 23.03,41.56 23.03,41.79 22.93,41.88 22.93,42.92 23.48,43.46 24.62,43.46 24.89,43.73 24.98,43.73
+LAN_VDD on BOTTOM (solid shape): 26.82,51.28 27.92,51.28 28.05,51.14 28.05,49.05 28.3,48.81 28.3,47.83 28.05,47.59 28.05,47.04 27.94,46.93 27.68,46.93 27.62,46.99 27.62,48.05 27.98,48.4 27.98,48.67 27.36,49.28 27.36,50.02 27.36,50.02 27.36,50.21 27.23,50.33 26.22,50.33 26.01,50.13 26.01,49.09 25.86,48.94 25.86,47.85 25.84,47.84 25.84,46.99 25.78,46.92 25.69,46.92 25.62,46.99 25.62,47.92 25.5,48.04 25.5,48.56 25.39,48.67 25.39,51.13 25.4,51.13 25.4,51.31 25.59,51.5 26.6,51.5
+LAN_VDD on IN4: 25.26,41.87 23,41.87 22.39,42.48 22.39,50.01 24.04,51.67 28.48,51.67 28.8,51.35 28.8,45.41
+NVVDD1 on TOP (solid shape): outline of 202 points within 209.84,88.01 212.38,96.37
+NVVDD1 on TOP (solid shape): outline of 734 points within 216.88,88.84 225.92,106.16
+NVVDD1 on TOP (solid shape): outline of 1401 points within 180.71,88.06 217.01,137.81
+NVVDD1 on BOTTOM (solid shape): 222.88,103.06 223.37,103.06 223.37,102.79 223.22,102.64 223.22,102.6 223.22,102.59 223.17,102.4 223.22,102.22 223.22,102.2 223.22,102.14 223.35,102.01 223.35,101.41 223.15,101.21 223.15,100.84 223.37,100.61 223.37,99.96 223.13,99.72 223.02,99.72 222.73,99.44 222.63,99.54 222.63,99.7 222.7,99.78 222.74,99.87 222.75,99.88 222.8,99.94 222.8,103.04 222.87,103.07
+NVVDD1 on BOTTOM (solid shape): outline of 4967 points within 180.76,87.4 227.94,137.95
+NVVDD1 on IN1 (solid shape): outline of 1298 points within 188.38,104.73 209.82,132.31
+NVVDD1 on IN1 (solid shape): outline of 6446 points within 208.82,88.31 227.95,106.91
+NVVDD1 on IN2 (solid shape): outline of 9510 points within 180.82,88.65 228.09,137.76
+NVVDD1 on IN3 (solid shape): outline of 21203 points within 180.82,87.37 228.18,137.76
+NVVDD1 on IN4 (solid shape): outline of 20909 points within 180.82,87.79 228.01,143.64
+NVVDD1 on IN5 (solid shape): outline of 14743 points within 180.82,87.35 227.65,137.76
+NVVDD1 on VCC: 194.72,78.63 190.74,82.61 190.74,84.97 190.73,102.64 190.73,105.23 187.34,108.61 184.1,108.61 183.68,109.04 183.68,113.54 181.08,116.15 181.08,132.72 180.7,133.1 180.7,136.07 182.9,138.27 193.23,138.27 196.25,135.24 196.25,122.8 212.15,106.9 225.87,106.9 227.37,105.4 227.37,79.71 226.53,78.87 195.64,78.87 195.4,78.63 ; 4 cut-outs
+NVVDD1 on GND3: 199.48,87.35 197.42,89.41 197.42,90.1 196.64,90.88 193.51,90.88 192.85,91.55 192.85,101.35 191.02,103.18 191.02,104.67 191.5,105.16 191.5,105.98 190.44,107.04 188.51,107.04 184.14,111.41 184.14,124.31 180.81,127.64 180.81,135.03 183.56,137.77 199.43,137.77 201.87,135.33 201.87,118.97 203.95,116.89 205.04,116.89 209.51,112.42 209.51,109.6 212.02,107.09 226.35,107.09 227.67,105.76 227.67,87.92 227.11,87.35 ; 4 cut-outs
+PEX_VDD on TOP (solid shape): 182.41,72.23 182.41,67.91 182.28,67.78 180.44,67.78 180.13,68.1 180.13,72.55 180.32,72.74 181.9,72.74
+PEX_VDD on TOP (solid shape): outline of 87 points within 205.65,102.05 208.38,104.68
+PEX_VDD on TOP (solid shape): outline of 1212 points within 188.46,78.83 208.89,95.91
+PEX_VDD on BOTTOM (solid shape): 124.82,87.53 125.39,87.53 125.39,88.1 125.64,88.1 125.64,87.53 126.21,87.53 126.21,88.1 128.56,88.1 128.88,87.79 128.88,81.83 128.88,81.75 132.25,78.39 132.25,77.24 131.87,76.86 127.74,76.86 126.91,77.69 126.91,79.59 126.59,79.91 126.59,81.7 126.6,81.7 126.6,85.62 126.59,85.66 126.42,85.84 123.91,85.84 123.8,85.96 123.8,87.98 123.93,88.1 124.82,88.1
+PEX_VDD on BOTTOM (solid shape): 206.1,104.68 206.31,104.55 206.55,104.62 206.7,104.62 207.03,104.47 207.25,104.52 207.42,104.52 207.64,104.3 207.64,101.99 207.53,101.88 205.59,101.88 205.53,101.94 205.5,102.01 205.53,102.08 205.61,102.23 205.63,102.39 205.63,102.42 205.9,102.69 205.99,102.71 206.06,102.65 206.27,102.46 206.55,102.52 206.7,102.52 206.82,102.45 207.43,102.75 206.82,103.06 206.7,102.98 206.55,102.98 206.49,103.02 206.41,103.05 206.36,103.08 206.33,103.15 206.26,103.37 205.93,103.58 205.92,103.59 205.83,103.7 205.7,103.75 205.69,103.75 205.47,103.97 205.47,104.14 205.61,104.31 205.62,104.53 205.62,104.56 205.74,104.68
+PEX_VDD on BOTTOM (solid shape): 207.65,95.1 207.65,89.22 207.46,89.03 206.49,89.03 206.18,89.34 206.18,89.44 206.29,89.58 206.33,89.75 206.36,89.82 206.41,89.85 206.49,89.88 206.55,89.92 206.7,89.92 206.88,89.8 206.9,89.78 206.91,89.79 207.21,89.79 207.24,89.82 207.43,90.15 207.24,90.48 206.86,90.48 206.82,90.46 206.7,90.38 206.55,90.38 206.49,90.42 206.41,90.45 206.36,90.48 206.33,90.55 206.29,90.72 206.18,90.86 206.18,91.54 206.29,91.68 206.33,91.85 206.36,91.92 206.41,91.95 206.49,91.98 206.55,92.02 206.7,92.02 206.82,91.95 206.88,91.91 206.89,91.92 207.24,91.92 207.43,92.25 207.24,92.58 206.86,92.58 206.82,92.56 206.7,92.48 206.55,92.48 206.49,92.52 206.41,92.55 206.36,92.58 206.33,92.65 206.29,92.82 206.18,92.96 206.18,93.64 206.29,93.78 206.33,93.95 206.36,94.02 206.41,94.05 206.49,94.08 206.55,94.12 206.7,94.12 206.82,94.05 207.43,94.35 206.82,94.66 206.7,94.58 206.55,94.58 206.49,94.62 206.41,94.65 206.36,94.68 206.33,94.75 206.29,94.92 206.18,95.06 206.18,95.21 206.41,95.44 207.31,95.44
+PEX_VDD on IN2 (solid shape): outline of 1973 points within 203.18,89.5 208.57,104.68
+PEX_VDD on IN4 (solid shape): 131.74,79.28 131.74,77.69 131.29,77.24 129.64,77.24 129.26,77.63 129.26,79.47 129.39,79.59 131.42,79.59
+PEX_VDD on IN4 (solid shape): 180.9,69.87 180.9,67.99 180.7,67.78 180.48,67.78 180.11,67.41 178.3,67.41 177.9,67.81 177.9,69.66 178.08,69.84 178.09,69.84 178.39,70.13 180.63,70.13
+TBTA_VBUS on TOP (solid shape): 370.31,73.11 370.31,67.97 370.05,67.72 369.69,67.72 369.59,67.82 369.59,72.23 369.2,72.62 366.02,72.62 365.77,72.36 365.77,69.34 364.63,68.2 364.31,68.2 363.9,67.78 363.9,67.27 363.64,67.02 363.15,67.02 362.96,67.21 362.96,68.24 363.91,69.19 363.91,72.63 365.26,73.99 369.43,73.99
+TBTA_VBUS on TOP (solid shape): 374.49,69.37 376.31,69.37 376.43,69.24 376.54,69.14 377.76,69.14 377.86,69.04 377.86,68.86 377.72,68.72 377.2,68.72 377.11,68.7 377.04,68.66 376.59,68.66 376.16,69.09 376.01,69.09 376.01,69.1 375.85,69.1 375.2,69.1 374.79,69.1 374.25,68.56 373.39,68.56 373.32,68.63 373.32,69.37 373.44,69.5 374.36,69.5
+TBTA_VBUS on TOP (solid shape): 375.1,71.88 375.2,71.88 375.23,71.85 375.85,71.85 375.93,71.86 376.01,71.88 376.34,71.88 376.44,71.99 376.47,71.99 376.52,72.04 376.72,72.04 377.13,71.63 377.79,71.63 377.86,71.55 377.86,71.38 377.81,71.33 377.12,71.33 376.99,71.45 376.92,71.45 376.88,71.49 376.83,71.52 376.8,71.55 376.67,71.56 376.6,71.55 374.56,71.55 373.75,72.37 373.75,72.39 373.65,72.67 373.37,72.78 373.34,72.77 373.29,72.82 373.14,72.82 373.12,72.86 373.08,72.91 373.08,72.96 373.04,73 373.04,73.21 373.11,73.28 373.7,73.28
+TBTA_VBUS on BOTTOM (solid shape): 370.9,74.13 373.23,74.13 374.41,72.95 374.41,72.2 374.24,72.04 374.05,72.04 373.8,72.29 373.8,72.54 373.66,72.69 373.61,72.73 373.52,72.82 373.2,72.82 373.03,72.99 372.94,72.99 372.85,73 372.75,72.99 371.25,72.99 370.8,72.55 369.74,72.55 369.69,72.6 367.75,72.6 367.74,72.58 367.7,72.58 367.48,72.36 367.48,71.81 367.43,71.76 367.37,71.76 366.96,71.7 366.94,71.29 366.94,71.28 366.94,71.21 366.88,71.15 364.95,71.15 364.92,71.12 364.44,71.12 364.37,71.19 363.8,71.19 363.75,71.24 363.75,71.43 363.59,71.6 363.43,71.6 363.35,71.68 363.35,71.96 363.39,71.99 363.56,71.99 363.76,72.19 363.76,72.41 363.83,72.47 364.13,72.47 364.4,72.74 365.68,72.74 365.68,72.57 366.68,72.57 366.68,72.94 367,73.26 367,73.74 367.89,74.64 370.39,74.64
+TBTA_VBUS on IN1 (solid shape): outline of 518 points within 363.97,68.04 375.4,72.8
+TBTA_VBUS on IN2 (solid shape): outline of 568 points within 364.08,67.85 375.51,75.53
+TBTA_VBUS on VCC: 368.7,67.85 368,68.54 364.51,68.54 364.02,69.03 364.02,73.08 364.25,73.31 376.79,73.31 377.15,72.95 377.15,68 377,67.85
+V_DAC on TOP (solid shape): 31.34,66.07 31.34,64.93 31.28,64.86 21.69,64.86 21.57,64.99 21.57,65.91 21.57,65.92 21.6,66.02 21.6,66.13 21.59,66.16 21.82,66.39 31.03,66.39
+VDISPLAY_VCC on BOTTOM (solid shape): 366.78,92.14 366.78,90.15 367.49,89.43 369.2,89.43 369.56,89.07 370.07,89.07 370.17,89.04 370.26,89.04 370.33,89.01 370.36,88.93 370.36,87.45 370.18,87.27 366.55,87.27 366.17,86.89 366.17,85.31 366.04,85.18 365.48,85.18 365.26,85.4 365.26,92.07 365.49,92.3 366.62,92.3
ACDRV_CHG on TOP (solid shape): 35.57,43.35 35.57,42.82 34.65,41.89 34.65,40.14 34.57,40.06 34.5,40.06 34.42,40.14 34.42,41.05 33.8,41.68 33.8,42.33 34.46,42.99 34.46,43.21 34.66,43.42 35.51,43.42
ADPIN on TOP (solid shape): 50.63,62.88 54.28,62.88 54.76,62.41 54.76,59.74 54.49,59.47 47.08,59.47 46.42,60.14 46.42,62.89 46.65,63.13 50.38,63.13
ADPIN on BOTTOM: 43.41,59.17 43.41,61.5 45.06,63.15 50.33,63.15 50.58,62.89 54.33,62.89 54.84,62.39 54.84,59.74 54.56,59.46 49.26,59.46 47.76,57.96 47.76,55.23 36.04,43.51 35.89,43.51 32.3,47.11 32.3,47.25 35.71,50.66 35.71,51.47
ADPIN on IN1: 54.19,62.78 48.38,62.78 48.13,63.02 45.1,63.02 36.96,54.88 36.96,50.97 37.5,50.43 42.47,50.43 44.64,52.61 50.39,52.61 54.81,57.03 54.81,62.16
ADPIN on IN5: 54.19,62.78 48.38,62.78 48.13,63.02 45.1,63.02 36.96,54.88 36.96,50.98 37.5,50.43 42.47,50.43 44.64,52.61 50.38,52.61 54.81,57.04 54.81,62.16
AUD_AGND on GND1: 366.18,3.2 366.18,8.55 363.59,11.14 361.21,11.14 357.99,7.92 357.99,6.9 357.78,6.7 346.96,6.7 342.64,11.01 340.53,11.01 340.53,15.89 342.13,17.49 347,17.49 347,21.06 346.97,21.09 347.06,21.17 348.14,21.17 348.2,21.24 348.86,21.24 349.29,20.8 349.29,20.27 349.59,19.97 351.98,19.97 352.04,19.9 352.25,19.9 352.4,20.05 352.4,21.66 351.26,22.8 351.26,23.88 350.79,24.35 347.98,24.35 347.83,24.2 347.83,24.02 347.65,23.84 346.51,23.84 346.3,23.64 346.3,22.57 345.35,22.57 345.35,23.85 346.18,24.68 346.18,26.61 346.39,26.83 351.89,26.83 351.89,24.88 353.99,22.78 353.99,18.66 355.79,16.86 369.4,16.86 370.41,17.87 380.1,17.87 380.1,14.3 369.7,14.3 369,13.7 369.5,12.93 369.5,7.47 369,6.7 369.7,6.1 381.4,6.1 381.4,4 381.16,3.44 380.6,3.2
AUD_AGND on GND2, GND4: 366.18,3.2 366.18,8.55 363.59,11.14 361.21,11.14 357.99,7.92 357.99,6.9 357.78,6.7 346.96,6.7 342.64,11.01 340.53,11.01 340.53,15.89 342.13,17.49 347,17.49 347,21.06 346.97,21.09 347.06,21.17 348.14,21.17 348.2,21.24 348.86,21.24 349.29,20.8 349.29,20.27 349.59,19.97 351.98,19.97 352.04,19.9 352.25,19.9 352.4,20.05 352.4,21.66 351.26,22.8 351.26,23.88 350.79,24.35 347.98,24.35 347.83,24.2 347.83,24.02 347.65,23.84 346.51,23.84 346.3,23.64 346.3,22.57 345.35,22.57 345.35,23.85 346.18,24.68 346.18,26.61 346.39,26.83 351.89,26.83 351.89,24.88 353.99,22.78 353.99,18.66 355.79,16.86 369.4,16.86 370.41,17.87 380.1,17.87 380.1,14.3 369.7,14.3 369,13.7 369.5,12.93 369.5,7.47 369,6.7 369.7,6.1 381.4,6.1 381.4,4 381.16,3.44 380.6,3.2
AUD_AGND on VCC: 366.87,3.2 366.52,3.19 366.18,3.15 366.18,8.55 363.59,11.14 361.21,11.14 357.99,7.92 357.99,6.9 357.78,6.7 346.96,6.7 342.64,11.01 340.53,11.01 340.53,15.89 342.13,17.49 347,17.49 347,21.06 346.97,21.09 347.06,21.17 348.14,21.17 348.2,21.24 348.86,21.24 349.29,20.8 349.29,20.27 349.59,19.97 351.98,19.97 352.04,19.9 352.25,19.9 352.4,20.05 352.4,21.66 351.26,22.8 351.26,23.88 350.79,24.35 347.98,24.35 347.83,24.2 347.83,24.02 347.65,23.84 346.51,23.84 346.3,23.64 346.3,22.57 345.35,22.57 345.35,23.85 346.18,24.68 346.18,26.61 346.39,26.83 351.89,26.83 351.89,24.88 353.99,22.78 353.99,18.66 355.79,16.86 369.4,16.86 370.41,17.87 380.1,17.87 380.1,14.3 369.7,14.3 369.01,13.7 369.5,12.93 369.5,7.47 369.01,6.7 369.7,6.1 381.4,6.1 381.4,4 381.17,3.44 380.6,3.2
AUD_AGND on GND3: 366.18,3.2 366.18,8.55 363.59,11.14 361.21,11.14 357.99,7.92 357.99,6.9 357.78,6.7 346.96,6.7 342.64,11.01 340.53,11.01 340.53,15.89 342.13,17.49 347,17.49 347,21.06 346.97,21.09 347.06,21.17 348.14,21.17 348.2,21.24 348.86,21.24 349.29,20.8 349.29,20.27 349.59,19.97 351.98,19.97 352.04,19.9 352.25,19.9 352.4,20.05 352.4,21.66 351.26,22.8 351.26,23.88 350.79,24.35 347.98,24.35 347.83,24.2 347.83,24.02 347.65,23.84 346.51,23.84 346.3,23.64 346.3,22.57 345.35,22.57 345.35,23.85 346.18,24.68 346.18,26.61 346.39,26.83 351.89,26.83 351.89,24.88 353.99,22.78 353.99,18.66 355.79,16.86 369.4,16.86 370.41,17.87 380.1,17.87 380.1,14.3 369.7,14.3 369,13.7 369.5,12.93 369.5,7.47 369,6.7 369.7,6.1 381.4,6.1 381.4,4 381.16,3.44 380.6,3.2
AUD_SPK_L+ on TOP (solid shape): 328.97,17.53 330.97,17.53 331.08,17.42 331.08,16.93 330.91,16.77 329.99,16.77 329.78,16.97 328.93,16.97 328.88,17.03 328.88,17.51 328.93,17.56
AUD_SPK_L+ on TOP (solid shape): 345.15,25.64 345.28,25.51 345.28,24.75 344.76,24.23 344.76,22.72 344.69,22.65 344.62,22.65 344.55,22.72 344.55,24.43 344.8,24.69 344.8,25.51 344.94,25.65 345.15,25.65
AUD_SPK_L+ on IN1 (solid shape): 329.73,18.61 329.73,17.85 330.04,17.54 330.09,17.49 330.88,17.49 331.05,17.32 331.05,16.56 330.88,16.39 329.5,16.39 328.71,17.19 328.71,18.58 328.8,18.67 329.68,18.67
AUD_SPK_L+ on IN1 (solid shape): 345.92,27.13 345.92,26 345.29,25.36 345.29,24.67 345.16,24.54 344.97,24.54 344.81,24.7 344.81,25.56 344.91,25.65 344.91,27.21 344.96,27.26 345.8,27.26
AUD_SPK_L+_C on TOP (solid shape): 326.08,15.36 326.08,13.51 325.84,13.27 325.47,13.27 325.21,13.53 325.21,15.17 324.66,15.71 324.66,16.05 324.8,16.18 325.26,16.18
AUD_SPK_L+_C on TOP (solid shape): 326.56,16.72 328.83,16.72 329.68,16.72 329.82,16.57 329.82,16.08 329.65,15.9 327.28,15.9 327.28,15.9 325.97,15.9 325.49,16.38 323.32,16.38 323.01,16.08 322.67,16.08 322.55,16.2 322.55,17.05 322.72,17.22 323.05,17.22 323.27,16.99 324.24,16.99 324.73,17.47 325.81,17.47
AUD_SPK_L+_C on IN1 (solid shape): 323.8,17.21 323.8,16.39 323.66,16.26 323.27,16.26 323.11,16.1 322.69,16.1 322.54,16.24 322.54,17.05 322.82,17.32 323.68,17.32
AUD_SPK_L+_C on IN1 (solid shape): 325.38,16.88 325.38,16.06 325.71,15.72 325.71,15.33 325.48,15.1 324.9,15.1 324.61,15.39 324.61,15.61 324.27,15.95 324.27,16.24 324.27,16.24 324.27,17.03 324.53,17.29 324.98,17.29
AUD_SPK_L- on TOP (solid shape): 331.3,18.36 331.3,17.89 331.18,17.78 329.08,17.78 328.88,17.98 328.88,18.39 329.98,18.39 330.15,18.56 331.09,18.56
AUD_SPK_L- on TOP (solid shape): 344.62,25.54 344.62,24.68 344.37,24.43 344.37,23.91 344.37,23.55 344.35,23.54 344.35,22.74 344.29,22.67 344.2,22.67 344.14,22.74 344.14,23.53 344.13,23.54 344.13,25.53 344.23,25.62 344.54,25.62
