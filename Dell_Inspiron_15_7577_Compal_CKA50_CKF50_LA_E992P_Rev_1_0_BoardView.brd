# Allegro board Dell_Inspiron_15_7577_Compal_CKA50_CKF50_LA_E992P_Rev_1_0_BoardView.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
AUD_SPK_L- on IN1 (solid shape): 331.11,19.23 331.11,17.91 330.99,17.8 330.15,17.8 329.99,17.95 329.99,19.35 330.1,19.46 330.88,19.46
AUD_SPK_L- on IN1 (solid shape): 344.62,26.78 344.62,24.68 344.5,24.56 344.3,24.56 344.15,24.71 344.15,25.48 342.81,26.83 342.82,26.83 342.82,27.83 343.57,27.83
AUD_SPK_L-_C on TOP (solid shape): 327.95,15.09 327.95,13.52 327.72,13.29 326.68,13.29 326.49,13.48 326.49,14.89 326.49,14.89 326.49,15 326.73,15.23 327.8,15.23
AUD_SPK_L-_C on TOP (solid shape): 329.99,19.61 329.99,18.76 329.87,18.64 328.77,18.64 328.59,18.83 326.23,18.83 325.74,18.35 324.83,18.35 324.3,18.88 322.2,18.88 322.06,19.01 322.06,19.66 322.24,19.84 329.76,19.84
AUD_SPK_L-_C on IN1 (solid shape): 327.92,14.69 327.92,13.87 327.75,13.69 327.34,13.69 326.34,14.7 326.34,15.12 326.78,15.57 327.05,15.57
AUD_SPK_L-_C on IN1 (solid shape): 324.14,19.5 324.14,18.75 324.04,18.65 322.28,18.65 322.07,18.85 322.07,19.28 322.51,19.72 323.92,19.72
AUD_SPK_R+ on TOP (solid shape): 330.37,21.48 331.06,21.48 331.38,21.16 331.38,20.78 331.26,20.65 330.37,20.65 330.18,20.84 330.18,21.17 329.8,21.55 328.88,21.55 328.88,22.01 328.94,22.08 329.77,22.08
AUD_SPK_R+ on TOP (solid shape): 343.13,24.6 343.13,24.3 343.56,23.87 343.56,22.72 343.5,22.66 343.42,22.66 343.35,22.72 343.35,23.65 342.18,24.83 342.18,25.05 342.3,25.17 342.56,25.17
AUD_SPK_R+ on IN1 (solid shape): 332.25,21.1 332.25,20.19 332.15,20.08 330.75,20.08 330.33,20.5 330.33,21 330.49,21.17 332.19,21.17
AUD_SPK_R+ on IN1 (solid shape): 343.13,24.54 343.13,24.3 342.97,24.14 341.84,24.14 341.06,23.36 338.18,23.36 338.18,24.39 340.95,24.39 341.73,25.17 342.49,25.17
AUD_SPK_R+_C on TOP (solid shape): 323.56,14.95 323.56,13.54 323.31,13.29 321.89,13.29 321.58,13.6 321.58,14.71 322.11,15.23 323.28,15.23
AUD_SPK_R+_C on TOP (solid shape): 326.34,21.3 328.62,21.3 329.69,21.3 329.8,21.19 329.8,20.69 329.65,20.54 322.26,20.54 322.14,20.66 322.14,21.23 322.24,21.34 324.25,21.34 324.83,21.91 325.73,21.91
AUD_SPK_R+_C on IN1 (solid shape): 323.25,21.18 323.25,20.8 322.42,19.98 322.41,19.98 322.11,19.68 321.85,19.68 321.32,20.22 321.32,20.48 322.15,21.32 323.1,21.32
AUD_SPK_R+_C on IN1 (solid shape): 322.37,15.75 322.37,15.31 322.49,15.19 322.49,14.42 322.29,14.23 321.34,14.23 321.17,14.39 321.17,15.75 321.33,15.91 322.21,15.91
AUD_SPK_R- on TOP (solid shape): 331.31,22.42 331.31,21.9 331.17,21.77 330.45,21.77 329.89,22.33 329.87,22.33 328.94,22.33 328.86,22.41 328.86,22.88 328.88,22.9 330.83,22.9
AUD_SPK_R- on TOP (solid shape): 343.76,25.19 343.76,25.17 344.01,24.93 344.01,23.59 343.95,23.53 343.95,22.72 343.9,22.67 343.8,22.67 343.74,22.73 343.74,23.98 343.5,24.22 343.5,24.23 343.45,24.29 343.45,24.6 343.07,24.98 343.07,25.24 343.19,25.36 343.59,25.36
AUD_SPK_R- on IN1 (solid shape): 332.54,22.45 332.54,21.94 332.24,21.64 330.52,21.64 330.27,21.89 330.27,22.47 330.47,22.67 332.31,22.67
AUD_SPK_R- on IN1 (solid shape): 343.78,25.18 343.78,24.72 343.93,24.57 343.93,24.47 343.93,24.46 343.93,24.36 343.79,24.22 343.51,24.22 343.42,24.32 343.42,24.63 342.62,25.43 342.37,25.43 341.37,25.43 340.99,25.05 338.88,25.05 338.88,26.06 340.62,26.06 341.01,26.45 342.52,26.45
AUD_SPK_R-_C on TOP (solid shape): 324.81,15.18 324.81,13.49 324.59,13.26 324.24,13.26 323.99,13.51 323.99,14.88 323.2,15.67 323.2,15.9 323.42,16.13 323.87,16.13
AUD_SPK_R-_C on TOP (solid shape): 329.86,23.93 329.86,23.3 329.71,23.15 328.69,23.15 328.55,23.29 326.24,23.29 325.74,22.8 324.82,22.8 324.23,23.39 322.26,23.39 322.12,23.53 322.12,24.11 322.31,24.31 329.49,24.31
AUD_SPK_R-_C on IN1 (solid shape): 324.16,24.17 324.16,23.22 324.02,23.08 322.35,23.08 322.07,23.36 322.07,23.98 322.37,24.28 324.04,24.28
AUD_SPK_R-_C on IN1 (solid shape): 324.33,15.54 324.33,14.4 324.15,14.22 323.33,14.22 323.2,14.36 323.2,15.8 323.38,15.98 323.88,15.98
B+ on TOP (solid shape): 248.98,33.56 248.98,32.3 248.84,32.16 247.73,32.16 247.6,32.29 247.6,33.52 247.82,33.75 248.79,33.75
B+ on TOP (solid shape): 277.64,72.32 277.64,70.59 277.18,70.13 276.32,70.13 275.98,70.46 275.98,72.27 276.22,72.51 277.46,72.51
B+ on TOP (solid shape): 257.02,49.24 257.02,46.95 256.77,46.7 253.79,46.7 253.66,46.83 253.66,47.84 253.15,47.84 253.15,48.03 253.66,48.03 253.66,48.67 253.15,48.67 253.15,48.86 253.66,48.86 253.66,49.37 253.72,49.43 254.1,49.43 254.23,49.56 256.71,49.56
B+ on TOP (solid shape): 78.65,38.92 78.65,37.7 79.09,37.26 82.54,37.26 83.05,37.78 84.13,37.78 84.48,38.13 86.03,38.13 86.46,37.7 86.46,35.32 86.09,34.95 84.19,34.95 82.84,33.6 81.28,33.6 80.72,33.05 78.27,33.05 77.13,34.19 77.13,39.02 78.55,39.02
B+ on TOP (solid shape): 95.09,71.53 95.45,71.53 95.81,71.17 96.11,71.17 96.47,71.53 98.27,71.53 99.86,69.94 101.64,69.94 101.7,69.88 101.7,68.23 101.13,68.23 101.13,67.66 101.7,67.66 101.7,66.64 101.51,66.45 98.02,66.45 95.33,69.14 98.64,69.14 98.64,69.09 98.65,69.04 98.67,68.99 98.69,68.94 98.72,68.9 98.76,68.86 98.8,68.83 98.85,68.81 98.89,68.79 98.95,68.79 99,68.79 99.05,68.79 99.1,68.81 99.15,68.83 99.19,68.86 99.22,68.9 99.25,68.94 99.28,68.99 99.29,69.04 99.3,69.09 99.3,69.14 99.29,69.19 99.28,69.24 99.25,69.29 99.22,69.33 99.19,69.37 99.15,69.4 99.1,69.42 99.05,69.44 99,69.45 98.95,69.45 98.89,69.44 98.85,69.42 98.8,69.4 98.76,69.37 98.72,69.33 98.69,69.29 98.67,69.24 98.65,69.19 98.64,69.14 95.33,69.14 95.04,69.43 94.82,69.43 94.78,69.45 94.73,69.46 94.68,69.47 94.63,69.47 94.58,69.46 94.53,69.45 94.49,69.43 93.37,69.43 93.13,69.68 93.13,71.66 93.45,71.97 94.64,71.97
B+ on TOP (solid shape): outline of 2208 points within 105.18,78.6 125.26,109.5
B+ on BOTTOM (solid shape): 87.8,36.86 88.56,36.86 88.94,36.48 88.94,33.56 88.56,33.18 84.88,33.18 84.62,33.43 84.62,34.25 83.35,35.52 83.35,37.62 83.73,38 86.65,38
B+ on BOTTOM (solid shape): 277.98,74.2 277.98,71.4 277.76,71.19 276.39,71.19 276.39,71.21 276.2,71.4 276.2,72.29 276.52,72.61 276.52,73.56 277.09,73.56 277.09,74.07 276.52,74.07 276.52,74.32 276.58,74.39 277.79,74.39
B+ on BOTTOM (solid shape): 120.44,114.53 120.44,109.96 120.73,109.67 123.95,109.67 124.14,109.48 124.14,108.19 124.05,108.11 123.55,108.11 123.55,108.61 122.98,108.61 122.98,108.11 122.53,108.11 122.02,107.6 122.02,105.44 121.9,105.31 121.39,105.31 121.27,105.43 121.27,106.86 121.04,107.09 119.93,107.09 119.64,106.8 119.64,103.87 119.85,103.66 119.85,101.74 119.6,101.49 119.6,100.88 118.62,99.9 118.6,99.9 118.38,99.82 118.3,99.61 118.3,99.58 118.19,99.47 115.74,99.47 115.36,99.85 115.36,108.68 116.18,109.5 118.02,109.5 118.58,110.06 118.58,110.54 118.12,111 118.12,115.46 118.28,115.62 119.35,115.62
B+ on IN1 (solid shape): 43.79,35.3 43.79,33.72 43.59,33.52 40.11,33.52 39.65,33.98 39.65,35.4 39.8,35.55 43.54,35.55
B+ on IN1 (solid shape): 86.49,36.72 86.49,35.26 85.73,34.5 82.21,34.5 82,34.7 82,36.55 82.58,37.12 86.09,37.12
B+ on IN2 (solid shape): 42.55,35.34 42.55,33.69 42.3,33.44 39.69,33.44 39.57,33.56 39.57,35.4 39.69,35.53 42.36,35.53
B+ on IN2 (solid shape): 86.5,36.72 86.5,35.27 86.2,34.97 82.27,34.97 82.08,35.16 82.08,36.79 82.46,37.18 86.04,37.18
B+ on IN2 (solid shape): 249.85,34 249.85,33.43 249.4,32.98 247.78,32.98 247.6,33.17 247.6,34.1 247.85,34.35 249.5,34.35
B+ on IN2 (solid shape): 255.44,48.86 255.44,47.72 255.37,47.65 254.04,47.65 253.85,47.84 253.85,48.86 253.91,48.92 255.37,48.92
B+ on IN2 (solid shape): outline of 692 points within 98.21,65.84 110.86,83.96
B+ on IN3 (solid shape): 44.18,35.11 44.18,34.45 43.8,34.06 39.94,34.06 39.61,34.39 39.61,35.36 39.79,35.54 43.75,35.54
B+ on IN3 (solid shape): 86.5,36.68 86.5,35.28 84.27,33.05 82.89,33.05 82.76,33.17 82.76,35.99 84.01,37.24 85.94,37.24
B+ on IN5 (solid shape): outline of 691 points within 97.05,66.26 110.86,83.96
B+ on TOP: 65.41,55.95 65.41,55.51 65.57,55.34 65.57,54.79 65.79,54.57 68.31,54.57 68.42,54.68 68.43,54.68 68.43,54.69 68.57,54.83 69.9,54.83 70.13,54.6 70.13,52.06 69.98,51.91 63.92,51.91 61.25,49.24 61.25,41.37 60.24,40.35 58.27,40.35 57.82,39.91 57.82,35.72 53.89,31.78 43.44,31.78 41.94,33.27 40.39,33.27 39.52,34.15 39.52,35.5 39.61,35.59 42.95,35.59 44.28,34.25 48.43,34.25 49.32,35.14 53.51,35.14 54.59,36.22 54.59,38.76 54.97,39.14 55.47,39.14 55.86,39.53 55.86,40.35 55.54,40.35 55.54,40.86 56.24,40.86 56.49,41.11 56.49,41.37 56.24,41.62 55.54,41.62 55.54,42.26 55.79,42.51 57.44,42.51 58.08,43.14 58.08,50.13 60.36,52.42 60.43,52.42 62.65,54.64 62.65,55.4 63.29,56.04 65.32,56.04
B+ on BOTTOM: 38.49,38.72 40.28,38.72 40.43,38.57 40.43,36.34 41.32,35.44 41.32,34.59 41.2,34.47 39.84,34.47 39.52,34.78 38.77,34.78 38.36,35.19 38.36,38.59
B+ on VCC: 58.06,39.65 55.67,42.04 55.67,62.63 58.32,62.18 61,61.92 61.35,61.81 61.62,61.57 64.7,60.03 67.7,61.73 67.96,61.99 68.31,62.11 82.78,66.77 94.43,76.54 94.72,76.77 95.08,76.85 100.15,76.85 104.8,78.77 106.72,83.42 106.72,85.12 106.96,85.71 107.55,85.95 109.7,85.95 112.65,87.17 113.87,90.12 113.87,109.5 124.84,109.5 125.26,109.08 125.26,90.37 120.37,85.48 120.37,80.59 117.39,77.6 117.39,74.3 95.12,52.03 77.3,52.03 76.6,52.73 70.23,52.73 69.57,52.08 69.57,40.07 69.15,39.65
B+_VCCIO on BOTTOM (solid shape): 123.36,107.85 123.8,107.85 123.8,107.65 123.74,107.59 123.74,107.53 123.29,107.09 123.29,105.57 122.85,105.12 122.85,105.11 122.78,105.05 122.78,104.18 122.85,104.12 122.85,104.1 123.1,103.85 123.36,103.85 123.46,103.75 123.46,102.26 123.39,102.2 122.66,102.2 121.32,103.53 121.32,105.02 121.43,105.12 122.02,105.12 122.21,105.31 122.21,107.47 122.59,107.85 123.23,107.85 123.23,108.42 123.36,108.42
BATDRV_CHG on TOP (solid shape): 34.65,36.81 34.65,33.79 34.55,33.69 34.29,33.69 34.19,33.79 34.19,35.29 34.42,35.52 34.42,36.81 34.5,36.89 34.57,36.89
BATSRC_CHG on TOP (solid shape): 34.24,36.81 34.24,35.67 33.79,35.21 33.79,33.77 33.69,33.68 33.38,33.68 33.3,33.76 33.3,35.06 34.01,35.77 34.01,36.81 34.09,36.89 34.17,36.89
BATT+ on BOTTOM: 47.81,38.38 47.51,38.08 47.51,37.54 47.29,37.33 45.71,37.33 45.68,37.3 45.68,35.44 45.81,35.31 47.14,35.31 47.38,35.56 47.38,36.28 47.62,36.52 53.04,36.52 53.22,36.35 58.06,36.35 58.38,36.66 58.38,38.2 58.2,38.38
BATT++ on TOP: 57.49,31.27 56.24,31.27 55.86,31.65 55.86,33.18 57.29,34.61 57.29,34.91 57.91,35.52 59.6,35.52 59.73,35.39 59.73,35.07 58.97,34.31 58.97,33.43 58.84,33.3 57.82,33.3 57.76,33.24 57.76,31.54
BATT++ on BOTTOM: 52.91,36.15 55.67,36.15 55.88,35.94 55.88,35.19 56.68,34.39 57.46,34.39 57.82,34.02 57.82,31.97 57.33,31.48 49.49,31.48 49.24,31.73 49.24,34.23 49.42,34.41 52.21,34.41 52.72,34.92 52.72,35.95
BATT++ on IN2: 58.78,33.56 56.36,33.56 56.24,33.68 56.24,35 56.45,35.21 58.72,35.21 58.97,34.96 58.97,33.75
BOOT_1.2V on TOP (solid shape): 109.21,67.28 110.46,67.28 110.5,67.25 110.5,67.13 110.45,67.08 109.12,67.08 108.94,67.26 107.8,67.26 107.59,67.47 107.5,67.47 107.49,67.47 107.49,68.12 107.54,68.17 108.32,68.17
BOOT_GPU1 on BOTTOM (solid shape): 172.5,132.11 173.39,132.11 173.52,131.98 173.52,131.85 173.39,131.73 172.12,131.73 172,131.85 171.15,131.85 171.11,131.9 171.11,132.46 171.14,132.49 172.12,132.49
BOOT_GPU2 on BOTTOM (solid shape): 172.12,140.93 173.01,140.93 173.08,140.87 173.08,140.68 172.95,140.55 172.06,140.55 171.62,141 170.66,141 170.6,141.06 170.6,141.57 170.66,141.63 171.43,141.63
BOOT_GPU3 on BOTTOM (solid shape): 173.85,120.04 173.85,119.91 174.16,119.6 174.92,119.6 175.05,119.47 175.05,119.28 174.98,119.22 173.01,119.22 172.82,119.41 172.82,120.4 172.93,120.51 173.37,120.51
BS_1.8V on TOP (solid shape): 273.85,81.17 273.85,80.55 273.22,79.91 272.58,79.91 272.2,80.29 272.2,80.85 272.61,81.25 273.77,81.25
BS_1.8V on BOTTOM (solid shape): 273.09,80.93 273.09,80.04 272.96,79.91 271.67,79.91 271.58,80 271.58,80.18 272.45,81.05 272.96,81.05
BS_VCCIO on BOTTOM (solid shape): 122.53,102.07 123.36,102.07 123.46,101.97 123.46,101.83 123.38,101.76 121.13,101.76 120.94,101.95 120.94,102.58 121.01,102.64 121.96,102.64
BST_1.2V on TOP (solid shape): 108.43,70.73 108.43,68.92 108.38,68.87 107.49,68.87 107.44,68.92 107.44,70.71 107.52,70.79 108.37,70.79
BST_1.8V on TOP (solid shape): 273.79,82.58 273.79,81.88 273.66,81.75 271.95,81.75 271.88,81.82 271.88,82.64 272.01,82.77 273.6,82.77
BST_1V on TOP (solid shape): 252.39,45.78 252.39,43.92 251.63,43.92 251.63,45.78 251.69,45.84 252.32,45.84
BST_3V on TOP (solid shape): 82.26,48.11 82.26,47.54 82.2,47.47 80.36,47.47 80.29,47.54 80.29,48.11 80.36,48.17 82.2,48.17
BST_+1.35V on TOP (solid shape): 243.37,57.18 243.37,55.15 243.24,55.02 242.61,55.02 242.48,55.15 242.48,57.18 242.61,57.31 243.24,57.31
BST_CHG on TOP (solid shape): 40.17,39.46 40.55,39.08 40.55,38.06 39.92,38.06 39.92,38.83 39.66,39.08 39.66,39.97 40.17,39.97
BST_GPU_PH1 on BOTTOM (solid shape): 170.76,133.66 170.76,131.91 170.71,131.85 169.77,131.85 169.71,131.92 169.71,133.7 169.77,133.76 170.66,133.76
BST_GPU_PH2 on BOTTOM (solid shape): 170.09,142.71 170.09,142.34 170.38,142.05 170.38,141.06 170.31,140.99 169.77,140.99 169.69,141.06 169.69,141.7 169.49,141.91 169.18,141.91 169.13,141.96 169.13,142.83 169.2,142.9 169.9,142.9
BST_GPU_PH3 on BOTTOM (solid shape): 172.43,121.55 172.43,120.6 172.56,120.48 172.56,119.9 172.49,119.84 171.54,119.84 171.29,120.09 171.29,121.68 171.35,121.75 172.24,121.75
BST_VCCIO on BOTTOM (solid shape): 122.34,101.06 122.34,99.28 122.28,99.22 121.64,99.22 121.51,99.34 121.51,100.42 121.45,100.49 121.07,100.49 121.01,100.55 121.01,101.25 121.07,101.31 122.09,101.31
BTST_CHG on TOP (solid shape): 39.27,38.92 39.27,38.06 39.25,38.03 38.59,38.03 38.3,38.32 37.41,38.32 37.36,38.36 36.2,38.36 36.13,38.42 36.13,38.53 36.2,38.59 37.35,38.59 37.4,38.64 38.33,38.64 38.54,38.84 38.54,38.87 38.61,38.95 39.25,38.95
CHG_B+ on TOP (solid shape): 45.63,41.81 43.03,41.81 42.46,41.24 42.46,40.29 42.3,40.13 42.3,38.73 42.1,38.52 40.95,38.52 40.87,38.6 40.87,46.26 41.06,46.45 45.63,46.45
CHG_B+ on BOTTOM: 40.81,41.62 40.87,41.68 42.52,41.68 42.65,41.56 42.65,41.3 42.65,41.3 42.65,40.71 42.33,40.4 42.33,39.01 42.64,38.71 42.78,38.71 42.87,38.62 42.87,35.18 42.77,35.07 41.82,35.07 40.51,36.38 40.51,38.73 40.81,39.02
CMSRC_CHG on TOP (solid shape): 36.87,43.4 36.87,42.76 36.49,42.38 36,42.38 35.91,42.29 35.89,42.29 35.28,41.69 35.28,41.67 35.27,41.65 35.27,41.47 35.06,41.25 35.06,40.11 35,40.06 34.88,40.06 34.83,40.11 34.83,41.89 35.57,42.64 35.65,42.64 35.65,42.71 35.7,42.76 35.7,42.8 35.73,42.83 35.73,43.34 35.85,43.46 36.81,43.46
CPU_B+ on TOP (solid shape): 156.38,127.61 156.38,126.37 156.33,126.32 152.46,126.32 152.26,126.52 152.26,127.99 153.48,129.21 154.78,129.21
CPU_B+ on TOP (solid shape): 146.27,128.91 146.27,127.54 146.93,126.88 149.52,126.88 149.52,126.06 143.83,126.06 143.68,126.22 143.68,127.99 144.74,129.06 146.11,129.06
CPU_B+ on TOP (solid shape): 119.8,123.47 119.74,123.41 119.74,120.93 119.61,120.81 117.58,120.81 117.44,120.94 117.44,121.69 117.09,122.04 117.09,122.17 117.09,124.82 117.26,125 119.8,125
CPU_B+ on TOP (solid shape): 173.84,126.39 173.84,125.5 173.39,125.06 172.38,125.06 172.19,124.88 172.18,124.88 172.04,124.73 172.04,124.72 171.81,124.49 171.81,121.5 171.62,121.31 170.6,121.31 170.35,121.57 170.35,124.62 169.97,125 169.97,126.58 170.09,126.71 173.52,126.71
CPU_B+ on TOP (solid shape): 162.73,129.21 162.73,128.7 164.15,127.28 165.28,127.28 165.34,127.25 165.41,127.24 165.62,127.03 165.62,125.86 165.57,125.81 162.42,125.81 162.37,125.86 162.37,126.11 162.17,126.32 161.05,126.32 160.9,126.47 160.9,128.1 161.66,128.86 161.66,129.21 161.81,129.37 162.57,129.37
CPU_B+ on TOP (solid shape): 122.19,133.71 122.19,132.29 122.04,132.13 121.35,132.13 121.2,132.29 121.2,132.59 121.04,132.74 120.38,132.74 120.1,132.46 120.1,131.02 119.86,130.77 119.86,129.63 119.74,129.5 118.37,129.5 118.21,129.66 117.47,129.66 116.83,130.3 116.83,130.96 117.01,131.14 117.01,132.76 117.18,132.93 118.53,132.93 118.9,133.3 119.32,133.3 119.77,133.76 122.14,133.76
CPU_B+ on BOTTOM (solid shape): 124.37,114.01 124.37,110.2 124.12,109.95 120.75,109.95 120.56,110.14 120.56,113.95 120.75,114.14 124.25,114.14
CPU_B+ on BOTTOM (solid shape): 150.33,135 150.33,132.21 149.98,131.85 148.04,131.85 147.89,132.01 147.89,134.95 148.3,135.36 149.98,135.36
CPU_B+ on BOTTOM (solid shape): 173.7,126.67 173.7,124.95 173.24,124.49 171.11,124.49 170.65,124.95 169.08,124.95 169.08,126.14 169.71,126.14 170.54,126.96 173.41,126.96
CPU_B+ on BOTTOM (solid shape): 119.8,122.9 119.67,122.77 119.67,119.98 118.53,119.98 118.53,121.38 118.4,121.5 117.45,121.5 117.26,121.69 117.26,122.01 117.07,122.2 116.12,122.2 116.12,123.79 116.88,123.79 117.13,124.04 118.78,124.04 118.97,124.23 118.97,124.93 119.8,124.93
CPU_B+ on BOTTOM (solid shape): 164.19,129.38 164.19,129.37 164.3,129.25 164.3,126.85 164.5,126.65 165.08,126.65 165.08,125.82 165.01,125.76 163.49,125.76 162.92,126.33 160.12,126.33 160.12,127.41 160.19,127.47 161.39,127.47 161.65,127.73 161.65,129.31 161.52,129.44 161.2,129.44 161.2,130.01 163.55,130.01
CPU_B+ on BOTTOM (solid shape): 122.21,133.61 122.21,132.21 121.98,131.98 120.37,131.98 119.86,131.47 119.86,128.74 118.66,128.74 118.66,130.14 118.53,130.27 117.37,130.27 117.25,130.14 115.86,130.14 115.74,130.27 115.74,131.75 115.96,131.98 119.04,131.98 119.64,132.58 120.02,132.58 121.2,133.76 122.06,133.76
CPU_B+ on BOTTOM (solid shape): 145.45,130.46 145.45,130.01 145.71,129.76 147.36,129.76 147.36,129.25 147.3,129.19 147.11,129.19 146.91,129 146.91,127.09 147.04,126.96 147.8,126.96 147.8,126.08 142.91,126.08 142.85,126.14 142.85,127.28 144.25,127.28 144.37,127.41 144.37,129.06 144.06,129.38 144.06,130.46 144.12,130.52 145.39,130.52
CPU_B+ on BOTTOM (solid shape): 154.98,129.74 154.98,128.44 154.9,128.36 154.9,127.49 155.11,127.28 156.38,127.28 156.38,126.39 156.25,126.27 153.52,126.27 153.46,126.33 151.49,126.33 151.49,127.47 151.55,127.54 152.82,127.54 153.01,127.73 153.01,129.25 152.95,129.31 152.82,129.31 152.76,129.38 152.76,129.82 152.82,129.89 154.84,129.89
CPU_B+ on IN3 (solid shape): outline of 8665 points within 114.02,109.82 173.78,135.79
DSBL_GPU_PH2 on BOTTOM (solid shape): 173.52,138.33 173.52,137.51 172.51,136.49 170.73,136.49 170.66,136.55 170.66,137 170.73,137.06 171.81,137.06 173.2,138.46 173.39,138.46
DSBL_GPU_PH3 on BOTTOM (solid shape): 175.49,117.02 175.49,116.29 175.37,116.17 175.11,116.17 174.54,115.6 174.54,115.15 174.35,114.96 173.84,114.96 173.78,115.03 173.78,115.66 175.24,117.12 175.39,117.12
EN_1.0VS_VGAP on BOTTOM (solid shape): 122.28,93.88 122.28,90.58 122.21,90.52 121.58,90.52 121.2,90.9 121.2,92.67 120.24,93.63 120.24,93.82 120.37,93.94 122.21,93.94
FB_1.0VS_VGAP on BOTTOM (solid shape): 118.09,93.82 118.09,93.63 116.37,91.91 115.61,91.91 115.36,92.17 114.53,92.17 114.41,92.29 114.41,92.93 114.53,93.06 115.29,93.06 115.42,93.18 115.42,93.75 115.61,93.94 117.96,93.94
GPU_B+ on TOP (solid shape): 97,36.1 97,34.64 95.76,33.39 94.91,33.39 94.78,33.52 94.78,36.03 95.23,36.48 96.62,36.48
GPU_B+ on TOP (solid shape): 246.44,63.25 246.44,60.88 246.17,60.61 242.23,60.61 241.91,60.92 241.91,63.21 242.1,63.4 246.29,63.4
GPU_B+ on TOP (solid shape): 247.32,33.53 247.32,30.99 246.97,30.64 245.09,30.64 244.77,30.95 244.77,33.49 244.96,33.68 247.17,33.68
GPU_B+ on TOP (solid shape): 118.42,110.52 118.42,107.5 118.01,107.09 117.18,107.09 116.98,106.89 116.98,104.41 116.93,104.36 114.83,104.36 114.75,104.44 114.75,107.04 114.92,107.22 115.83,107.22 115.98,107.37 115.98,110.45 116.11,110.59 118.35,110.59
GPU_B+ on IN2 (solid shape): 246.48,61.31 246.48,59.65 246.36,59.53 244.96,59.53 244.64,59.85 244.64,61.24 244.76,61.36 246.43,61.36
GPU_B+ on IN2 (solid shape): 247.34,33.49 247.34,32.28 247.16,32.1 245.34,32.1 245.1,32.34 245.1,33.51 245.21,33.63 247.2,33.63
GPU_B+ on IN4 (solid shape): 97.7,37.68 97.7,36.35 96.91,35.56 94.97,35.56 94.69,35.84 94.69,37.33 95.35,38 97.38,38
GPU_B+ on IN4 (solid shape): 119.74,110.26 119.74,107.85 119.55,107.66 116.36,107.66 115.99,108.03 115.99,110.47 116.1,110.58 119.42,110.58
GPU_B+ on IN5 (solid shape): 246.74,61.94 246.74,61.18 246.36,60.8 242.8,60.8 242.67,60.92 242.67,62.13 242.99,62.45 246.23,62.45
GPU_B+ on IN5 (solid shape): 247.31,34.95 247.31,33.18 247.05,32.92 245.02,32.92 244.83,33.11 244.83,34.06 245.85,35.08 247.18,35.08
GPU_PWM1 on BOTTOM (solid shape): 173.51,129.99 173.51,129.75 172.06,128.3 171.17,128.3 171.04,128.43 171.04,129.82 171.11,129.89 172.51,129.89 172.7,130.08 173.43,130.08
GPU_PWM2 on BOTTOM (solid shape): 173.08,138.78 173.08,138.59 173.01,138.52 172.51,138.52 171.24,137.25 170.79,137.25 170.6,137.44 170.6,138.71 170.79,138.9 172.95,138.9
GPU_PWM3 on BOTTOM (solid shape): 175.05,117.5 175.05,117.12 173.58,115.66 173.01,115.66 172.89,115.79 172.89,117.19 173.01,117.31 173.71,117.31 173.97,117.57 174.98,117.57
LDO_1V on TOP (solid shape): 253.47,39.65 254.32,39.65 254.36,39.61 254.36,39.02 254.29,38.95 253.01,38.95 252.57,39.4 252.07,39.4 252.01,39.46 252.01,40.06 252.08,40.13 252.99,40.13
LG_1.2V on TOP (solid shape): 110.85,73.5 110.85,72.61 110.72,72.48 109.96,72.48 109.79,72.65 109.79,73.52 109.96,73.69 110.66,73.69
LG_1.2V on TOP (solid shape): 110.89,69.13 110.89,68.34 110.84,68.29 110.46,68.29 109.97,68.78 109.97,69.49 110.15,69.68 110.35,69.68
LG_1.2V on IN1 (solid shape): 110.85,73.5 110.85,71.59 110.66,71.4 110.66,68.85 110.41,68.61 110.15,68.61 109.64,69.12 109.64,73.37 109.96,73.69 110.66,73.69
LG_3V on TOP (solid shape): 70.59,44.03 70.59,43.14 70.46,43.02 69.64,43.02 69.44,43.21 69.44,43.97 69.64,44.16 70.46,44.16
LG_3V on TOP (solid shape): 79.72,44.81 79.72,44.23 80.29,43.66 80.29,43.54 80.23,43.47 79.34,43.47 79.28,43.54 79.28,43.85 79.15,43.98 79.15,44.87 79.28,45 79.53,45
LG_3V on IN5 (solid shape): 70.59,44.1 71.29,44.1 71.29,43.34 71.03,43.34 70.71,43.02 70.21,43.02 70.08,43.14 70.08,44.03 70.21,44.16 70.52,44.16
LG_3V on IN5 (solid shape): 79.66,44.87 79.66,43.98 79.53,43.85 78.96,43.85 78.7,43.6 78.39,43.6 78.13,43.85 78.13,44.11 79.02,45 79.53,45
LG_5V on TOP (solid shape): 80.18,42.06 80.18,41.77 79.21,40.8 78.83,40.8 78.7,40.93 78.7,41.82 78.83,41.95 79.09,41.95 79.28,42.14 80.1,42.14
LG_5V on TOP (solid shape): 66.14,40.16 66.14,39.65 66.08,39.59 66.08,38.19 65.95,38.06 65.19,38.06 65,38.26 65,40.22 65.13,40.35 65.95,40.35
LG_5V on IN5 (solid shape): 67.6,39.46 67.6,38.76 67.16,38.76 66.27,39.65 65.13,39.65 65,39.78 65,40.22 65.13,40.35 66.71,40.35
LG_5V on IN5 (solid shape): 78.51,41.95 79.09,41.95 79.21,41.82 79.21,41 79.02,40.8 78.58,40.8 77.88,41.5 77.88,42.39 78.07,42.39
LG_+1.35V on TOP (solid shape): 239.94,54.51 239.94,54 239.82,53.88 238.93,53.88 238.8,54 238.8,54.74 238.91,54.86 239.59,54.86
LG_+1.35V on TOP (solid shape): 251.88,52.61 251.88,51.59 251.75,51.46 250.86,51.46 250.74,51.59 250.74,52.61 250.86,52.73 251.75,52.73
LG_+1.35V on TOP (solid shape): 258.1,52.61 258.1,51.59 257.98,51.46 257.09,51.46 256.96,51.59 256.96,52.61 257.09,52.73 257.98,52.73
LG_+1.35V on IN1 (solid shape): 240.83,54.13 240.83,53.88 240.7,53.75 239.05,53.75 238.8,54 238.8,54.26 238.93,54.38 240.58,54.38
LG_+1.35V on IN1 (solid shape): 252.01,52.73 252.01,51.59 251.88,51.46 250.86,51.46 250.61,51.72 250.61,52.73 250.74,52.86 251.88,52.86
LG_+1.35V on IN1 (solid shape): 258.1,52.73 258.1,51.59 257.98,51.46 257.09,51.46 256.96,51.59 256.96,52.73 257.09,52.86 257.98,52.86
LG_CHG on TOP (solid shape): 38.2,37.19 38.2,36.99 38.08,36.86 37.75,36.86 37.04,37.57 36.2,37.57 36.14,37.63 36.14,37.71 36.2,37.78 37.62,37.78
LG_CHG on TOP (solid shape): 43.83,38.4 45.03,38.4 45.12,38.31 45.12,38.08 44.42,37.38 43.4,37.38 43.29,37.49 43.29,38.35 43.42,38.48 43.75,38.48
LG_CHG on IN1 (solid shape): 43.89,38.34 43.89,37.64 43.44,37.2 42.1,37.2 42.03,37.26 42.03,38.29 42.21,38.46 43.76,38.46
LG_CHG on IN1 (solid shape): 37.91,37.53 39.46,37.53 39.6,37.39 39.6,37 39.23,36.63 37.98,36.63 37.25,37.37 37.25,37.62 37.38,37.75 37.69,37.75
LX_1.0VS_VGAP on BOTTOM (solid shape): 121.07,92.61 121.07,90.77 120.94,90.64 119.55,90.64 119.48,90.71 119.48,92.74 119.61,92.87 120.82,92.87
LX_1.0VS_VGAP on BOTTOM (solid shape): 122.53,95.91 122.53,95.15 122.34,94.96 121.51,94.96 121.41,94.85 121.39,94.85 121.21,94.78 121.11,94.62 121.1,94.58 120.37,94.58 120.24,94.71 120.24,95.34 120.37,95.47 121.2,95.47 121.26,95.53 121.26,95.98 121.39,96.1 122.34,96.1
LX_1.0VS_VGAP on IN4 (solid shape): 121.83,95.98 121.83,95.28 121.32,94.77 120.24,94.77 120.18,94.83 120.18,95.53 120.75,96.1 121.71,96.1
LX_1.0VS_VGAP on IN4 (solid shape): 121.72,92.78 121.72,91.06 121.55,90.9 120.7,90.9 120.58,91.01 120.58,92.75 120.7,92.87 121.63,92.87
LX_1.2V on TOP (solid shape): 111.86,77.37 111.86,75.07 111.05,74.26 107.67,74.26 106.66,75.28 104.88,75.28 104.75,75.4 104.75,76.86 105.13,77.24 109.89,77.24 110.15,77.5 111.73,77.5
LX_1.2V on TOP (solid shape): 109.7,70.75 109.7,68.85 110.49,68.06 110.49,67.94 110.42,67.88 109.65,67.88 109.59,67.94 109.59,68.1 108.95,68.73 108.95,70.74 109.05,70.84 109.61,70.84
LX_1.2V on BOTTOM (solid shape): 115.55,77.18 115.55,74.58 114.9,73.93 104.5,73.93 104.31,74.12 104.31,76.74 104.81,77.24 110.24,77.24 110.49,77.5 115.23,77.5
LX_1.2V on IN1 (solid shape): 107.67,76.36 107.67,75.78 107.42,75.53 106.66,75.53 106.47,75.34 105.45,75.34 105.45,76.1 105.89,76.55 107.48,76.55
LX_1.2V on IN1 (solid shape): 109.89,68.66 109.89,68.34 109.78,68.22 109.36,68.22 108.97,68.61 107.8,68.61 107.63,68.78 107.63,69.35 107.86,69.58 108.96,69.58
LX_1.8V on TOP (solid shape): 271.76,83.78 271.76,81.69 272.07,81.37 272.07,78.26 272.71,77.63 272.71,77.12 272.58,76.99 272.02,76.99 271.94,77 271.18,77.75 271.18,81.12 270.49,81.82 270.49,83.72 270.67,83.9 271.64,83.9
LX_1.8V on BOTTOM (solid shape): 272.71,84.99 272.71,81.51 271.44,80.24 270.88,80.24 270.8,80.32 270.8,84.99 271,85.18 272.51,85.18
LX_1.8V on BOTTOM (solid shape): 271.51,77.99 272.21,77.99 272.58,77.63 272.58,77.12 272.45,76.99 271.36,76.99 271.24,77.11 271.24,77.96 271.33,78.06 271.45,78.06
LX_1V on TOP (solid shape): 249.47,42.51 249.47,41.81 249.82,41.46 249.82,41.29 249.74,41.21 248.98,41.21 248.83,41.37 248.83,42.57 248.96,42.7 249.28,42.7
LX_1V on TOP (solid shape): 255.58,45.7 255.58,40.08 255.4,39.91 254.28,39.91 254.23,39.96 254.23,40.73 254.04,40.92 253.02,40.92 252.87,40.77 252.1,40.77 252.01,40.86 252.01,41.49 252.97,42.46 252.97,43.04 253.02,43.05 253.24,43.32 253.02,43.6 252.97,43.61 252.97,45.7 253.15,45.88 255.4,45.88
LX_1V on BOTTOM (solid shape): 256.71,46.89 256.71,42.51 256.33,42.13 255.25,42.13 254.8,41.68 254.8,41.11 254.55,40.86 252.71,40.86 252.58,40.99 252.58,46.95 252.9,47.27 256.33,47.27
LX_1V on IN2 (solid shape): 250.17,42.45 250.17,41.7 250.02,41.56 248.98,41.56 248.84,41.69 248.84,42.55 249,42.7 249.91,42.7
LX_1V on IN2 (solid shape): 253.66,42.51 253.66,41.11 253.53,40.99 252.45,40.99 252.01,41.43 252.01,42.26 252.39,42.64 253.53,42.64
LX_3V on TOP (solid shape): 82.26,47.15 82.26,46.14 81.75,45.63 81.75,45.25 81.37,44.87 81.37,43.98 81.31,43.92 81.24,43.92 81.18,43.98 81.18,45.82 81.5,46.14 81.5,47.15 81.56,47.22 82.2,47.22
LX_3V on TOP (solid shape): 72.49,49.49 72.49,47.97 72.37,47.84 70.4,47.84 70.08,47.53 70.08,44.86 65.24,44.86 64.5,44.13 64.25,44.13 64.13,44.25 64.13,46.52 64.01,46.64 62.52,46.64 62.27,46.89 62.27,48.99 62.9,49.62 72.37,49.62
LX_3V on BOTTOM (solid shape): 67.54,47.65 67.54,44.21 67.41,44.07 63.56,44.07 62.78,44.86 62.78,47.72 63.54,48.48 66.71,48.48
LX_3V on IN5 (solid shape): 66.02,48.48 65.7,48.48 65.19,47.97 64.3,47.97 64.17,48.1 64.17,48.48 64.94,49.24 66.02,49.24
LX_3V on IN5 (solid shape): 81.75,47.25 81.75,46.46 81.94,46.27 81.94,45.82 81.69,45.57 81.69,45.09 81.63,45.03 81.18,45.03 81.12,45.09 81.12,46.77 80.99,46.9 80.99,47.5 81.5,47.5
LX_5V on TOP (solid shape): 81.38,41.67 81.38,40.73 81.56,40.55 81.56,38.84 81.5,38.77 80.99,38.77 80.93,38.84 80.93,39.41 81.05,39.53 81.05,40.61 81.18,40.74 81.18,41.66 81.25,41.73 81.33,41.73
LX_5V on TOP (solid shape): 64.81,39.27 64.81,37.68 65,37.49 69.89,37.49 70.08,37.3 70.08,35.65 70.65,35.08 72.05,35.08 72.18,34.95 72.18,33.43 72.05,33.3 71.1,33.3 70.91,33.11 70.91,32.73 70.78,32.6 64.32,32.6 63.48,33.45 63.48,35.4 63.03,35.84 61.7,35.84 60.94,36.6 60.94,38 61.63,38.7 62.46,38.7 63.16,39.4 64.68,39.4
LX_5V on BOTTOM (solid shape): 67.48,35.59 67.1,35.21 63.76,35.21 63.03,35.93 63.03,39.46 63.22,39.65 67.48,39.65
LX_5V on IN5 (solid shape): 71.9,34.25 71.51,33.87 70.5,33.87 70.4,33.98 70.4,34.9 70.51,35.02 71.9,35.02
LX_5V on IN5 (solid shape): 81.89,40.35 81.89,38.83 81.64,38.57 81.26,38.57 80.94,38.89 80.94,40.6 81.07,40.73 81.51,40.73
LX_+1.35V on TOP (solid shape): 241.9,55.97 241.9,55.08 241.85,55.04 241.19,55.04 240.83,55.4 239.94,55.4 239.82,55.53 238.93,55.53 238.83,55.62 238.83,55.82 238.93,55.91 241.09,55.91 241.19,56.01 241.86,56.01
LX_+1.35V on TOP (solid shape): 260.26,57.24 260.26,53.24 260.14,53.11 247.69,53.11 247.31,53.5 247.31,56.04 247.44,56.16 251.31,56.16 252.39,57.24 252.52,57.24 253.59,56.16 257.47,56.16 257.72,56.42 257.72,57.18 258.04,57.5 260.01,57.5
LX_+1.35V on BOTTOM (solid shape): 260.39,57.18 260.39,52.61 260.01,52.23 251.37,52.23 251.28,52.32 251.28,57.27 251.63,57.62 259.94,57.62
LX_+1.35V on IN1 (solid shape): 252.01,56.04 252.01,55.15 251.88,55.02 250.74,55.02 250.48,55.27 250.48,56.04 250.61,56.16 251.88,56.16
LX_+1.35V on IN1 (solid shape): 241.97,55.65 241.97,55.02 241.85,54.89 241.47,54.89 240.96,55.4 239.94,55.4 239.82,55.53 239.82,55.78 239.94,55.91 241.72,55.91
LX_CHG on TOP (solid shape): 39.25,40.11 39.25,39.4 39.2,39.35 38.52,39.35 38.41,39.46 37.5,39.46 37.21,39.17 36.17,39.17 36.13,39.21 36.13,39.34 36.17,39.38 37.04,39.38 37.24,39.58 37.24,39.78 37.65,40.19 39.17,40.19
LX_CHG on BOTTOM (solid shape): 49.89,45.03 49.89,44.35 49.89,42.15 48.64,40.91 45.32,40.91 44.57,41.66 44.57,45.42 44.77,45.62 49.3,45.62
LX_CHG on IN1 (solid shape): 38.84,40.35 38.46,39.97 38.46,39.53 38.39,39.46 37.76,39.46 37.57,39.65 37.57,40.41 37.82,40.67 38.84,40.67
LX_CHG on IN1 (solid shape): 48.81,42.76 48.81,42.57 48.68,42.45 48.68,42.13 48.81,42 48.81,41.87 48.62,41.68 48.3,41.68 48.11,41.87 47.09,41.87 47.09,42.89 48.68,42.89
LX_CHG on TOP: 45.7,40.67 46.39,41.37 46.39,44.92 46.52,45.05 48.63,45.05 48.77,44.91 48.77,43.18 49.38,42.57 49.76,42.57 49.95,42.38 49.95,41.56 48.93,40.54 48.93,35.65 48.63,35.34 47.25,35.34 47.16,35.43 47.16,37.37 46.52,38 45.76,38 45.7,38.06
LX_GPU1 on BOTTOM (solid shape): 172.38,133.12 173.39,133.12 173.52,133 173.52,132.87 173.39,132.74 171.17,132.74 171.11,132.81 171.11,133.7 171.17,133.76 171.74,133.76
LX_GPU2 on BOTTOM (solid shape): 171.93,142.4 171.93,142.08 172.12,141.89 172.95,141.89 173.08,141.76 173.08,141.63 173.01,141.57 171.77,141.57 171.45,141.89 170.61,141.89 170.54,141.96 170.54,142.83 170.61,142.9 171.43,142.9
LX_GPU3 on BOTTOM (solid shape): 173.85,121.63 173.85,120.85 174.09,120.61 174.92,120.61 175.05,120.49 175.05,120.3 174.98,120.23 173.87,120.23 173.36,120.74 172.95,120.74 172.95,120.73 172.92,120.73 172.76,120.89 172.76,121.65 172.9,121.79 173.69,121.79
LX_GPU_PH1 on BOTTOM (solid shape): 180.63,133 180.63,128.43 181.33,127.73 182.67,127.73 182.73,127.66 182.73,126.77 182.79,126.71 183.55,126.71 183.62,126.77 183.62,127.66 183.68,127.73 184.89,127.73 185.14,127.47 185.14,125.44 184.95,125.25 181.4,125.25 178.28,128.36 176.32,128.36 176.12,128.55 176.12,129.5 176.25,129.63 177.39,129.63 177.59,129.82 177.59,133.57 177.65,133.63 180,133.63
LX_GPU_PH2 on TOP (solid shape): 178.32,141.76 179.41,141.76 179.57,141.61 179.57,141.38 179.44,141.25 177.23,141.25 177.13,141.35 177.13,141.94 177.18,141.99 178.09,141.99
LX_GPU_PH2 on BOTTOM (solid shape): 184.68,143.86 184.68,141.55 184.57,141.44 183.43,141.44 183.36,141.51 183.36,142.46 183.3,142.52 182.54,142.52 182.47,142.46 182.47,140.87 182.03,140.43 179.62,140.43 179.05,139.86 179.05,137.95 178.6,137.51 175.81,137.51 175.68,137.63 175.68,138.33 175.81,138.46 177.01,138.46 177.14,138.59 177.14,142.33 177.27,142.46 179.94,142.46 179.95,142.48 181.12,143.64 181.12,143.83 181.16,143.87 184.67,143.87
LX_GPU_PH3 on BOTTOM (solid shape): 186.86,122.39 186.86,120.11 186.73,119.98 185.52,119.98 185.46,120.04 185.46,120.93 185.4,121 184.63,121 184.57,120.93 184.57,120.04 184.51,119.98 183.55,119.98 179.74,116.17 177.78,116.17 177.65,116.3 177.65,117 177.78,117.12 178.92,117.12 179.11,117.31 179.11,121 179.24,121.12 182.03,121.12 182.25,121.34 182.25,122.23 182.6,122.58 186.67,122.58
LX_VCCIO on BOTTOM (solid shape): 123.8,104.87 123.8,103.98 123.71,103.89 123.57,103.89 123.42,104.04 123.1,104.04 122.91,104.23 122.91,104.99 123.1,105.18 123.48,105.18
LX_VCCIO on BOTTOM (solid shape): 124.25,101.62 124.25,100.8 124.18,100.74 124.18,99.41 124.63,98.96 125.2,98.96 126.28,97.88 126.28,95.79 126.09,95.6 124.37,95.6 124.18,95.79 124.18,97.06 124.12,97.12 122.78,97.12 122.47,97.44 122.47,99.02 122.59,99.15 122.59,101.18 122.98,101.56 123.42,101.56 123.54,101.69 124.18,101.69
LX_VCCIO on IN1 (solid shape): 123.48,105.06 123.48,104.17 123.29,103.98 121.9,103.98 121.77,104.1 121.77,105.06 121.96,105.25 123.29,105.25
LX_VCCIO on IN1 (solid shape): 124.12,98.96 125.13,98.96 125.26,98.83 125.26,98.45 125.13,98.33 123.23,98.33 122.98,98.58 122.98,99.34 123.29,99.66 123.42,99.66
NVVDD_B+ on TOP (solid shape): 174.41,136.74 174.41,135.35 174.98,134.78 174.98,132.62 173.97,131.6 172.57,131.6 172.31,131.85 172.31,136.81 172.38,136.87 174.28,136.87
NVVDD_B+ on TOP (solid shape): 176.82,127.73 176.82,126.2 176.76,126.14 176.32,126.14 176,125.82 176,121.82 176.57,121.25 176.57,120.11 176.32,119.85 174.79,119.85 174.09,120.56 174.09,121.36 174.09,121.36 174.09,123.15 174.28,123.35 174.28,126.9 175.17,127.79 176.76,127.79
NVVDD_B+ on TOP (solid shape): 173.65,145.55 173.65,144.57 173.66,144.56 173.66,144.48 174.54,143.6 174.54,141.44 172.7,139.6 172.06,139.6 171.94,139.72 171.94,142.64 170.95,143.63 170.95,143.91 170.6,144.26 168.46,144.26 168.12,143.92 168.12,142.27 167.49,141.63 167.49,139.79 167.23,139.54 166.41,139.54 165.52,140.43 165.52,145.43 165.81,145.72 173.48,145.72
NVVDD_B+ on BOTTOM (solid shape): 176.06,126.33 176.06,126.01 175.93,125.89 175.93,122.71 176.57,122.08 176.57,119.28 176.44,119.15 175.36,119.15 175.24,119.28 175.24,120.55 175.05,120.74 174.22,120.74 174.03,120.93 174.03,123.98 174.54,124.49 174.79,124.49 174.92,124.62 174.92,126.33 175.05,126.46 175.93,126.46
NVVDD_B+ on BOTTOM (solid shape): outline of 276 points within 162.15,131.6 174.98,145.7
NVVDD_B+ on IN3 (solid shape): outline of 2919 points within 164.76,119.34 178.47,145.32
NVVDD_B+ on IN5: outline of 129 points within 165.01,118.9 177.08,145.44
NVVDDB_B+ on TOP (solid shape): 116.43,116.05 116.43,114.73 116.93,114.23 116.93,111.57 116.51,111.15 114.64,111.15 114.64,111.16 114.07,111.16 113.88,111.34 113.88,116.11 114.01,116.23 116.24,116.23
NVVDDB_B+ on BOTTOM (solid shape): 168.5,135.28 168.5,132.04 168.25,131.79 166.85,131.79 166.54,131.47 166.54,130.01 166.47,129.95 165.14,129.95 165.08,130.01 164.99,130.31 164.69,130.4 164.44,130.65 164.44,135.28 164.69,135.54 168.25,135.54
NVVDDB_B+ on IN5 (solid shape): outline of 9233 points within 113.88,110.96 168.16,135.66
NVVDDB_B+ on VCC: 113.87,110.01 113.87,132.74 117.56,132.74 121.05,136.24 168.21,136.24 169.27,135.18 169.27,127.9 168.4,127.03 142.51,127.03 139.34,130.2 127.31,130.2 126.4,129.29 126.4,110.43 125.98,110.01
P1 on TOP (solid shape): 57.51,53.69 57.51,43.91 57,43.4 54.48,43.4 54.27,43.61 54.27,46.45 54.46,46.64 55.41,46.64 55.86,47.08 55.86,49.37 55.67,49.56 54.4,49.56 54.2,49.75 54.2,52.54 54.4,52.73 55.6,52.73 55.92,53.05 55.92,54 56.05,54.13 57.06,54.13
P1 on BOTTOM (solid shape): 55.55,54.95 56.3,54.95 57.12,54.13 57.13,54.13 57.57,53.69 57.57,45.94 57.32,45.68 56.17,45.68 55.86,46 55.86,51.52 55.45,51.93 54.33,51.93 54.2,52.06 54.2,54.97 54.38,55.15 55.35,55.15
P1 on IN1 (solid shape): 57.44,53.81 57.44,45.94 57.19,45.68 55.79,45.68 54.62,46.86 54.62,52.86 56.08,54.32 56.94,54.32
P1 on IN2 (solid shape): 57.44,53.81 57.44,45.94 57.19,45.68 55.79,45.68 54.62,46.86 54.62,52.86 56.08,54.32 56.94,54.32
P1 on IN3 (solid shape): 57.44,53.81 57.44,45.94 57.19,45.68 55.79,45.68 54.62,46.86 54.62,52.86 56.08,54.32 56.94,54.32
P1 on IN4 (solid shape): 57.44,53.81 57.44,45.94 57.19,45.68 55.79,45.68 54.62,46.86 54.62,50.86 56.08,52.32 56.08,53.81 56.36,54.1 57.16,54.1
P1 on IN5 (solid shape): 57.44,53.81 57.44,45.94 57.19,45.68 55.79,45.68 54.62,46.86 54.62,52.86 56.08,54.32 56.94,54.32
P2 on TOP (solid shape): 53.44,47.72 53.44,43.72 54.52,42.64 54.52,41.62 53.82,41.62 53.63,41.43 53.63,41.05 53.82,40.86 54.52,40.86 54.52,40.35 53,40.35 53,40.92 52.74,41.18 51.41,41.18 49.66,42.92 49.35,42.92 48.93,43.34 48.93,47.97 53.19,47.97
PQ703_S on TOP (solid shape): 52.68,40.67 52.68,40.35 52.87,40.16 54.14,40.16 54.27,40.03 54.27,39.14 54.01,38.89 54.01,37.3 53.89,37.18 53.06,37.18 52.93,37.3 50.78,37.3 50.78,38.13 50.52,38.38 49.38,38.38 49.25,38.51 49.25,40.35 49.7,40.8 52.55,40.8
PQ703_S on IN2 (solid shape): 51.98,40.35 51.98,37.94 51.09,37.05 45.34,37.05 45.06,37.32 45.06,38.83 46.39,40.16 49.06,40.16 49.7,40.8 51.54,40.8
PQ703_S on IN5 (solid shape): 51.98,40.35 51.98,37.94 51.09,37.05 45.34,37.05 45.06,37.32 45.06,38.83 46.39,40.16 49.06,40.16 49.7,40.8 51.54,40.8
PQ703_S on BOTTOM: 43.16,35.43 43.04,35.56 43.04,38.03 43.54,38.53 44.26,38.53 44.63,38.9 44.64,38.9 46.41,40.66 48.78,40.66 50.33,42.21 50.33,44.47 51.38,45.52 57.69,45.52 57.76,45.45 57.76,41.12 57.32,40.67 54.59,40.67 54.27,40.35 54.27,39.08 54.08,38.89 48.12,38.89 47.4,38.17 47.4,37.64 47.22,37.46 45.72,37.46 44.77,36.51 44.77,35.46 44.75,35.43
REGN_CHG on TOP (solid shape): 38.56,37.73 39.16,37.73 39.22,37.66 39.22,36.73 38.58,36.73 38.58,36.78 38.59,36.79 38.59,37.04 37.66,37.97 36.2,37.97 36.13,38.03 36.13,38.12 36.2,38.18 38.1,38.18
RING2 on BOTTOM (solid shape): 344.12,16.2 344.12,15.32 344.47,14.97 344.81,14.97 344.83,14.95 344.83,14.47 344.81,14.45 343.51,14.45 343.14,14.82 343.14,16.12 343.36,16.35 343.97,16.35
RING2 on BOTTOM (solid shape): 366.1,13.91 366.1,13.78 366.37,13.52 366.88,13.52 366.98,13.41 366.98,12.6 366.97,12.59 366.1,12.59 366.09,12.6 365.71,12.97 365.3,13.3 365.29,13.3 365.01,13.58 365.01,14.36 365.16,14.51 365.51,14.51
RING2 on IN3 (solid shape): 365.72,14.29 365.72,13.43 365.54,13.24 364.09,13.24 363.8,13.53 363.8,14.19 363.89,14.29 364.77,14.29 364.96,14.48 365.53,14.48
RING2 on IN3 (solid shape): 344.1,16.19 344.1,15.34 344.66,14.78 346.93,14.78 347.12,14.59 347.12,13.77 346.96,13.61 343.68,13.61 342.83,14.47 342.83,16.1 343.07,16.35 343.95,16.35
RING2_R on BOTTOM (solid shape): 368.72,16.73 369.29,16.73 369.29,15.71 368.52,15.71 368.27,15.46 368.27,12.65 368.17,12.55 367.31,12.55 367.24,12.63 367.24,14.28 366.27,15.24 366.27,16.25 366.82,16.79 368.66,16.79
SLEEVE on BOTTOM (solid shape): 362.87,15.12 362.87,14.43 362.7,14.27 360.97,14.27 360.84,14.39 360.84,14.98 361,15.14 362.84,15.14
SLEEVE on BOTTOM (solid shape): 345.67,15.43 345.67,15.11 345.8,14.99 345.8,14.48 345.76,14.44 345.19,14.44 345.18,14.46 345.18,14.96 344.89,15.25 344.62,15.25 344.5,15.37 344.5,15.63 344.63,15.76 345.35,15.76
SLEEVE on IN4 (solid shape): 361.95,15.12 361.95,14.31 361.89,14.25 360.18,14.25 360.16,14.28 360.16,15.19 360.22,15.26 361.81,15.26
SLEEVE on IN4 (solid shape): 345.67,15.51 345.67,15.01 345.93,14.75 347.35,14.75 347.35,13.8 347.31,13.76 346.32,13.76 346.3,13.74 345.54,13.74 344.53,14.76 344.53,15.67 344.62,15.76 345.42,15.76
SLEEVE_R on BOTTOM (solid shape): 365.94,16.68 365.94,15.8 365.09,14.95 364.66,14.95 364.21,15.4 362.04,15.4 362.01,15.42 362.01,16.5 362.26,16.74 365.88,16.74
SLEEVE_R on IN2 (solid shape): 367.54,15.5 367.54,15.26 366.94,14.66 366.56,15.04 366.56,15.04 365.89,15.7 365.52,15.7 365.37,15.85 365.37,16.54 365.6,16.77 366.28,16.77
SLEEVE_R on IN2 (solid shape): 380.11,5.4 380.11,4.41 379.88,4.18 368.22,4.18 368.15,4.26 368.15,5.07 369.7,5.07 369.92,4.89 370.19,4.83 371.01,4.83 371.28,4.89 371.5,5.07 372.45,5.07 372.67,4.89 372.94,4.83 373.76,4.83 374.03,4.89 374.25,5.07 375.2,5.07 375.42,4.89 375.69,4.83 376.51,4.83 376.78,4.89 377,5.07 377.57,5.07 378.27,5.77 379.74,5.77
SNB_1.0VS_VGAP on BOTTOM (solid shape): 123.93,96.8 123.93,95.09 123.86,95.02 123.23,95.02 123.1,95.15 123.1,96.93 123.17,96.99 123.74,96.99
SNB_GPU1 on TOP (solid shape): 178.47,133.51 178.47,130.9 178.41,130.84 177.71,130.84 177.59,130.97 177.59,133.51 177.65,133.57 178.41,133.57
SNB_GPU3 on TOP (solid shape): 181.9,119.22 181.9,118.65 181.65,118.39 179.11,118.39 179.05,118.46 179.05,119.34 179.11,119.41 181.71,119.41
SNB_VCCIO on BOTTOM (solid shape): 119.93,100.23 119.93,99.15 120.05,99.02 121.07,99.02 121.2,98.9 121.2,97.25 121.07,97.12 119.29,97.12 119.1,97.31 119.1,100.17 119.29,100.36 119.8,100.36
SNUB_1.2V on BOTTOM (solid shape): 108.88,78.2 109.7,78.2 109.7,77.63 109.51,77.43 107.04,77.43 106.97,77.5 106.97,78.45 108.62,78.45
SNUB_1VALWP on TOP (solid shape): 257.91,41.62 257.91,40.8 257.98,40.73 259.12,40.73 259.18,40.67 259.18,39.97 259.12,39.91 256.83,39.91 256.71,40.03 256.71,41.62 256.77,41.68 257.85,41.68
SNUB_3V on TOP (solid shape): 63.98,44.41 63.86,44.29 62.71,44.29 62.33,44.67 62.33,46.32 63.98,46.32
SNUB_5V on TOP (solid shape): 63.09,41.43 63.09,39.65 62.78,39.33 61.19,39.33 61.06,39.46 61.06,40.54 62.14,41.62 62.9,41.62
SNUB_+1.35V on TOP (solid shape): 260.26,52.73 260.26,50.83 260.14,50.7 259.5,50.7 259.37,50.83 259.37,51.46 259.25,51.59 258.5,51.59 258.41,51.68 258.41,52.79 258.48,52.86 260.14,52.86
SNUB_CHG on TOP (solid shape): 45.74,37.01 45.74,35.47 45.6,35.33 43.57,35.33 43.5,35.4 43.5,36.04 43.57,36.12 44.28,36.12 44.45,36.29 44.45,36.97 44.58,37.09 45.66,37.09
SUNB_1.8V on TOP (solid shape): 272.94,84.82 272.94,83.03 272.87,82.96 272.04,82.96 271.97,83.03 271.97,84.82 272.07,84.93 272.84,84.93
TBT_SVR_IND on BOTTOM (solid shape): 368.25,62.09 368.25,60.56 367.81,60.12 363.37,60.12 363.28,60.15 363.2,60.16 362.6,60.16 362.56,60.12 362.5,60.12 361.19,58.81 361.19,58.66 361.05,58.52 361.01,58.49 360.98,58.45 360.31,57.79 359.73,57.79 359.64,57.88 359.64,58.08 359.48,58.21 359.44,58.22 359.34,58.22 359.3,58.26 359.3,58.39 359.41,58.51 360.13,58.51 362.15,60.52 362.15,62.02 362.28,62.15 362.37,62.18 362.44,62.12 362.81,61.92 363.09,62.22 363.1,62.27 368.06,62.27
UG_1.2V on TOP (solid shape): 104.5,76.24 104.5,75.39 104.4,75.29 102.87,75.29 102.78,75.38 102.78,76.19 102.96,76.37 104.37,76.37
UG_1.2V on TOP (solid shape): 109.45,67.95 109.45,67.87 109.59,67.73 110.45,67.73 110.5,67.68 110.5,67.53 110.45,67.47 109.21,67.47 108.6,68.08 108.6,68.35 108.71,68.47 108.93,68.47
UG_1.2V on IN1 (solid shape): 104.03,75.97 104.03,74.49 103.86,74.32 102.99,74.32 102.85,74.46 102.85,75.54 103.44,76.13 103.87,76.13
UG_1.2V on IN1 (solid shape): 109.46,67.86 109.46,67.65 109.28,67.47 108.44,67.47 108.39,67.53 106.72,67.53 106.72,68.42 106.73,68.43 108.89,68.43
UG_3V on TOP (solid shape): 72.86,47.41 72.86,46.71 72.72,46.57 71.79,46.57 71.5,46.87 71.5,47.53 71.63,47.65 72.62,47.65
UG_3V on TOP (solid shape): 80.48,45.82 80.48,44.93 80.61,44.81 80.61,43.98 80.55,43.92 80.29,43.92 79.97,44.23 79.97,44.74 79.85,44.87 79.85,45.5 79.97,45.63 79.97,45.88 80.04,45.95 80.36,45.95
UG_3V on IN5 (solid shape): 73.83,47.02 73.83,46.51 71.86,46.51 71.73,46.64 71.73,47.08 71.86,47.21 73.64,47.21
UG_3V on IN5 (solid shape): 80.48,45.88 80.48,45 80.29,44.81 79.97,44.81 79.53,45.25 78.96,45.25 78.89,45.31 78.89,45.69 79.21,46.01 80.36,46.01
UG_5V on TOP (solid shape): 80.59,41.68 80.59,40.84 80.29,40.55 80.29,40.11 80.16,39.98 79.78,39.98 79.66,40.11 79.66,41.06 80.33,41.73 80.53,41.73
UG_5V on TOP (solid shape): 72.22,32.91 72.22,32.08 72.04,31.91 71.28,31.91 71.12,32.07 71.12,32.91 71.29,33.08 72.04,33.08
UG_5V on IN5 (solid shape): 70.64,32.58 72.11,32.58 72.28,32.41 72.28,32.12 72.14,31.98 70.18,31.98 69.5,32.67 69.5,33.28 69.94,33.28
UG_5V on IN5 (solid shape): 80.24,41.11 80.24,40.03 80.05,39.84 79.03,39.84 78.84,40.03 78.84,40.6 78.92,40.68 79.07,40.68 79.13,40.73 79.29,40.73 79.8,41.24 80.11,41.24
UG_+1.35V on TOP (solid shape): 252.13,58.83 252.13,57.94 251.88,57.69 250.99,57.69 250.74,57.94 250.74,58.7 250.99,58.96 252.01,58.96
UG_+1.35V on TOP (solid shape): 258.36,58.83 258.36,57.94 258.12,57.71 257.07,57.71 256.96,57.81 256.96,58.83 257.21,59.08 258.1,59.08
UG_+1.35V on TOP (solid shape): 240.96,56.42 240.96,56.16 240.83,56.04 238.93,56.04 238.83,56.13 238.83,56.29 238.93,56.38 239.78,56.38 239.94,56.54 240.83,56.54
UG_+1.35V on IN1 (solid shape): 241.85,56.8 241.85,56.16 241.72,56.04 239.94,56.04 239.82,56.16 239.82,56.42 239.94,56.54 240.83,56.54 241.21,56.92 241.72,56.92
UG_+1.35V on IN1 (solid shape): 258.36,58.81 258.36,57.95 258.1,57.69 251.12,57.69 250.86,57.94 250.86,58.83 250.99,58.96 258.21,58.96
UG_CHG on TOP (solid shape): 47.6,46.7 47.6,45.94 47.41,45.75 46.58,45.75 46.46,45.88 46.46,46.7 46.58,46.83 47.47,46.83
UG_CHG on TOP (solid shape): 38.33,39.18 38.33,38.83 38.34,38.82 38.28,38.77 36.17,38.77 36.13,38.81 36.13,38.93 36.17,38.97 37.24,38.97 37.49,39.22 38.28,39.22
UG_CHG on IN1 (solid shape): 47.6,46.76 47.6,46.45 47.41,46.26 46.39,46.26 46.14,46.51 45.31,46.51 45.31,47.53 46.84,47.53
UG_CHG on IN1 (solid shape): 37.38,39.53 37.63,39.27 38.33,39.27 38.39,39.21 38.39,38.64 38.33,38.57 37.25,38.57 36.36,39.46 36.36,40.1 37.38,40.1
VBST1 on TOP (solid shape): 80.99,41.76 80.99,40.74 80.93,40.68 80.93,39.6 80.74,39.41 80.74,38.84 80.67,38.77 79.78,38.77 79.66,38.9 79.66,39.53 79.78,39.66 80.16,39.66 80.48,39.98 80.48,40.55 80.74,40.8 80.74,41.76 80.8,41.82 80.93,41.82
VBST2 on TOP (solid shape): 81.31,46.71 81.31,46.2 80.99,45.88 80.99,44.04 80.93,43.98 80.8,43.98 80.74,44.04 80.74,44.87 80.61,45 80.61,45.88 80.29,46.2 80.29,46.77 80.36,46.84 81.18,46.84
VBST_1V on TOP (solid shape): 252.32,43.59 252.32,42.76 251.94,42.38 251.94,41.62 251.88,41.56 251.75,41.56 251.69,41.62 251.69,43.59 251.74,43.64 252.27,43.64
VBST_+1.35V on TOP (solid shape): 241.9,57.25 241.9,56.38 241.84,56.32 241.18,56.32 241.09,56.42 241.09,56.47 240.88,56.67 239.89,56.67 239.82,56.67 239.7,56.56 238.91,56.56 238.83,56.64 238.83,56.96 239.18,57.31 241.85,57.31
VDRV_GPU_PH3 on BOTTOM (solid shape): 176.51,117 176.51,115.92 176.82,115.6 176.82,113.5 176.76,113.44 176.12,113.44 176.06,113.5 176.06,116.11 176.17,116.21 176.17,117.03 176.26,117.12 176.38,117.12
VL on TOP (solid shape): 79.15,42.96 80.23,42.96 80.29,42.9 80.29,42.77 80.23,42.71 79.02,42.71 78.96,42.77 78.51,42.77 78.32,42.58 78.32,42.33 78.26,42.27 77.37,42.27 77.31,42.33 77.31,42.84 77.56,43.09 78.13,43.09 78.32,43.28 78.83,43.28
ZCD_EN#_GPU_PH1 on BOTTOM (solid shape): 171.81,130.58 173.39,130.58 173.5,130.47 173.5,130.31 173.39,130.2 171.81,130.2 171.68,130.08 171.11,130.08 171.04,130.14 171.04,130.65 171.11,130.71 171.68,130.71
ZCD_EN#_GPU_PH2 on BOTTOM (solid shape): 171.62,139.41 173.01,139.41 173.08,139.35 173.08,139.09 173.01,139.03 170.73,139.03 170.6,139.16 170.6,139.66 170.66,139.73 171.3,139.73
ZCD_EN#_GPU_PH3 on BOTTOM (solid shape): 173.58,118.07 174.92,118.07 175.05,117.95 175.05,117.82 174.92,117.69 173.71,117.69 173.58,117.57 172.95,117.57 172.89,117.63 172.89,118.14 172.95,118.2 173.46,118.2
N18703353 on BOTTOM (solid shape): 115.1,97.88 115.74,97.88 116.05,98.2 117.26,98.2 117.39,98.07 117.39,97.37 117.07,97.06 114.47,97.06 114.28,97.25 114.28,97.82 114.34,97.88 114.97,97.88 114.97,98.45 115.1,98.45
N19213038 on BOTTOM (solid shape): 242.19,72.84 242.19,71.33 242,71.15 241.21,71.15 241.02,71.34 241.02,72.83 241.15,72.96 242.07,72.96
N21232186 on TOP: 335.94,9.41 337.4,9.41 337.67,9.69 337.67,11.25 337.52,11.4 335.67,11.4 335.15,10.88 335.15,10.19
N29426805 on TOP (solid shape): 154.28,123.35 155.17,123.35 155.17,122.65 154.28,122.65 153.96,122.33 153.96,121.95 153.84,121.82 152.88,121.82 152.82,121.88 152.82,123.66 152.88,123.73 153.9,123.73
N29426831 on TOP (solid shape): 145.96,123.03 145.01,123.03 144.69,122.71 144.69,121.95 143.68,121.95 143.68,123.6 143.74,123.66 145.96,123.66
N29426855 on TOP (solid shape): 162.78,120.93 162.68,120.83 162.07,120.83 161.76,121.14 161.76,123.73 162.78,123.73
N29435109 on TOP (solid shape): 167.17,122.84 167.17,122.13 167.67,121.63 167.67,121.06 167.48,120.88 166.92,120.88 166.92,120.87 166.69,120.87 166.43,121.12 166.43,121.14 166.28,121.29 165.37,121.29 165.32,121.34 165.32,122.96 167.04,122.96
N29435109 on BOTTOM: 169.67,122.75 169.58,122.84 166.73,122.84 166.54,122.65 166.54,118.74 166.53,118.73 166.53,118.61 166.63,118.5 169.31,118.5 169.41,118.6 169.41,121.05 169.67,121.31
N29435335 on TOP (solid shape): 169.08,122.9 169.08,120.49 168.95,120.36 168.12,120.36 167.93,120.55 167.93,122.9 168,122.96 169.01,122.96
N29436709 on TOP (solid shape): 126.82,130.61 126.82,129.73 126.56,129.47 123.83,129.47 123.73,129.58 123.73,130.66 123.87,130.8 126.62,130.8
N31425872 on TOP (solid shape): 151.93,130.04 151.93,129.45 152.18,129.2 152.18,128.93 152.06,128.81 151.8,128.81 151.62,128.99 151.62,129.02 151.63,129.08 151.61,129.15 151.61,129.22 151.39,129.44 150.88,129.44 150.82,129.5 150.82,130.14 150.89,130.2 151.77,130.2
N31425872 on BOTTOM (solid shape): 152.18,129.19 152.18,129 151.87,128.68 151.87,127.92 151.74,127.79 151.55,127.79 151.49,127.85 151.49,128.79 151.54,128.84 151.59,128.91 151.68,129 151.68,129.25 151.74,129.31 152.06,129.31
N31425874 on TOP (solid shape): 153.14,131.45 153.14,130.97 153.01,130.84 150.85,130.84 150.79,130.9 150.79,131.54 150.85,131.6 152.98,131.6
N31425876 on TOP (solid shape): 153.08,130.11 153.08,129.13 152.76,128.81 152.5,128.81 152.31,129 152.31,129.25 152.09,129.48 152.09,130.13 152.16,130.2 152.99,130.2
N31433757 on TOP (solid shape): 144.44,131.6 144.44,131.07 144.42,131.01 144.41,130.94 144.31,130.84 142.34,130.84 142.28,130.9 142.28,131.54 142.41,131.66 144.37,131.66
N31433760 on TOP (solid shape): 143.23,130.08 143.23,129.42 143.49,129.16 143.49,128.81 143.36,128.68 143.1,128.68 142.92,128.86 142.93,128.95 142.91,129.03 142.91,129.06 142.89,129.09 142.83,129.17 142.75,129.22 142.7,129.28 142.34,129.28 142.24,129.38 142.24,130.11 142.29,130.17 143.14,130.17
N31433761 on TOP (solid shape): 144.44,130.1 144.44,129 143.99,128.55 143.74,128.55 143.61,128.68 143.61,129.25 143.44,129.42 143.44,130.12 143.49,130.17 144.37,130.17
