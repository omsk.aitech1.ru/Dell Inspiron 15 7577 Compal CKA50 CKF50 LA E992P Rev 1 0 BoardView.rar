# Allegro board Dell_Inspiron_15_7577_Compal_CKA50_CKF50_LA_E992P_Rev_1_0_BoardView.brd (continued)
## Nets (continued)
DDI3_AUXP: CVGA4.1 UH1.A27
DDI3_AUXP_C: CVGA4.2 RVGA4.1 UVGA1.2
DDI3_DDPD_CTRLDAT: RH141.1 UH2.BE6
DDR4_DRAMRST#: CD97.1 JDIMM1.108 JDIMM2.108 RD31.1
DDR_A_ACT#: JDIMM1.114 UH1.AU3
DDR_A_ALERT#: JDIMM1.116 UH1.AU5
DDR_A_BG0: JDIMM1.115 UH1.AU1
DDR_A_BG1: JDIMM1.113 UH1.AU2
DDR_A_BS0: JDIMM1.150 UH1.AH5
DDR_A_BS1: JDIMM1.145 UH1.AH1
DDR_A_CAS#: JDIMM1.156 UH1.AD1
DDR_A_CKE0: JDIMM1.109 UH1.AT1
DDR_A_CKE1: JDIMM1.110 UH1.AT2
DDR_A_CLK0: JDIMM1.137 UH1.AG1
DDR_A_CLK1: JDIMM1.138 UH1.AK2
DDR_A_CLK#0: JDIMM1.139 UH1.AG2
DDR_A_CLK#1: JDIMM1.140 UH1.AK1
DDR_A_CS#0: JDIMM1.149 UH1.AD5
DDR_A_CS#1: JDIMM1.157 UH1.AE2
DDR_A_D0: JDIMM1.7 UH1.BR6
DDR_A_D1: JDIMM1.4 UH1.BT6
DDR_A_D2: JDIMM1.20 UH1.BP3
DDR_A_D3: JDIMM1.21 UH1.BR3
DDR_A_D4: JDIMM1.3 UH1.BN5
DDR_A_D5: JDIMM1.8 UH1.BP6
DDR_A_D6: JDIMM1.16 UH1.BP2
DDR_A_D7: JDIMM1.17 UH1.BN3
DDR_A_D8: JDIMM1.28 UH1.BL4
DDR_A_D9: JDIMM1.24 UH1.BL5
DDR_A_D10: JDIMM1.38 UH1.BL2
DDR_A_D11: JDIMM1.42 UH1.BM1
DDR_A_D12: JDIMM1.29 UH1.BK4
DDR_A_D13: JDIMM1.25 UH1.BK5
DDR_A_D14: JDIMM1.41 UH1.BK1
DDR_A_D15: JDIMM1.37 UH1.BK2
DDR_A_D16: JDIMM1.174 UH1.BT11
DDR_A_D17: JDIMM1.170 UH1.BR11
DDR_A_D18: JDIMM1.183 UH1.BT8
DDR_A_D19: JDIMM1.187 UH1.BR8
DDR_A_D20: JDIMM1.169 UH1.BP11
DDR_A_D21: JDIMM1.173 UH1.BN11
DDR_A_D22: JDIMM1.182 UH1.BP8
DDR_A_D23: JDIMM1.186 UH1.BN8
DDR_A_D24: JDIMM1.195 UH1.BL12
DDR_A_D25: JDIMM1.191 UH1.BL11
DDR_A_D26: JDIMM1.190 UH1.BL8
DDR_A_D27: JDIMM1.203 UH1.BJ8
DDR_A_D28: JDIMM1.208 UH1.BJ11
DDR_A_D29: JDIMM1.207 UH1.BJ10
DDR_A_D30: JDIMM1.194 UH1.BL7
DDR_A_D31: JDIMM1.204 UH1.BJ7
DDR_A_D32: JDIMM1.46 UH1.BG4
DDR_A_D33: JDIMM1.50 UH1.BG5
DDR_A_D34: JDIMM1.63 UH1.BF4
DDR_A_D35: JDIMM1.58 UH1.BF5
DDR_A_D36: JDIMM1.49 UH1.BG2
DDR_A_D37: JDIMM1.45 UH1.BG1
DDR_A_D38: JDIMM1.59 UH1.BF1
DDR_A_D39: JDIMM1.62 UH1.BF2
DDR_A_D40: JDIMM1.66 UH1.BD2
DDR_A_D41: JDIMM1.70 UH1.BD1
DDR_A_D42: JDIMM1.80 UH1.BC4
DDR_A_D43: JDIMM1.79 UH1.BC5
DDR_A_D44: JDIMM1.71 UH1.BD5
DDR_A_D45: JDIMM1.67 UH1.BD4
DDR_A_D46: JDIMM1.83 UH1.BC1
DDR_A_D47: JDIMM1.84 UH1.BC2
DDR_A_D48: JDIMM1.215 UH1.BG11
DDR_A_D49: JDIMM1.211 UH1.BG10
DDR_A_D50: JDIMM1.212 UH1.BG8
DDR_A_D51: JDIMM1.229 UH1.BF8
DDR_A_D52: JDIMM1.224 UH1.BF11
DDR_A_D53: JDIMM1.225 UH1.BF10
DDR_A_D54: JDIMM1.216 UH1.BG7
DDR_A_D55: JDIMM1.228 UH1.BF7
DDR_A_D56: JDIMM1.245 UH1.BB11
DDR_A_D57: JDIMM1.237 UH1.BC11
DDR_A_D58: JDIMM1.250 UH1.BB8
DDR_A_D59: JDIMM1.232 UH1.BC8
DDR_A_D60: JDIMM1.233 UH1.BC10
DDR_A_D61: JDIMM1.249 UH1.BB10
DDR_A_D62: JDIMM1.236 UH1.BC7
DDR_A_D63: JDIMM1.246 UH1.BB7
DDR_A_DQS0: JDIMM1.13 UH1.BP5
DDR_A_DQS1: JDIMM1.34 UH1.BK3
DDR_A_DQS2: JDIMM1.179 UH1.BR9
DDR_A_DQS3: JDIMM1.200 UH1.BJ9
DDR_A_DQS4: JDIMM1.55 UH1.BF3
DDR_A_DQS5: JDIMM1.76 UH1.BC3
DDR_A_DQS6: JDIMM1.221 UH1.BF9
DDR_A_DQS7: JDIMM1.242 UH1.BB9
DDR_A_DQS#0: JDIMM1.11 UH1.BR5
DDR_A_DQS#1: JDIMM1.32 UH1.BL3
DDR_A_DQS#2: JDIMM1.177 UH1.BP9
DDR_A_DQS#3: JDIMM1.198 UH1.BL9
DDR_A_DQS#4: JDIMM1.53 UH1.BG3
DDR_A_DQS#5: JDIMM1.74 UH1.BD3
DDR_A_DQS#6: JDIMM1.219 UH1.BG9
DDR_A_DQS#7: JDIMM1.240 UH1.BC9
DDR_A_MA0: JDIMM1.144 UH1.AH3
DDR_A_MA1: JDIMM1.133 UH1.AP4
DDR_A_MA2: JDIMM1.132 UH1.AN4
DDR_A_MA3: JDIMM1.131 UH1.AP5
DDR_A_MA4: JDIMM1.128 UH1.AP2
DDR_A_MA5: JDIMM1.126 UH1.AP1
DDR_A_MA6: JDIMM1.127 UH1.AP3
DDR_A_MA7: JDIMM1.122 UH1.AN1
DDR_A_MA8: JDIMM1.125 UH1.AN3
DDR_A_MA9: JDIMM1.121 UH1.AT4
DDR_A_MA10: JDIMM1.146 UH1.AH2
DDR_A_MA11: JDIMM1.120 UH1.AN2
DDR_A_MA12: JDIMM1.119 UH1.AU4
DDR_A_MA13: JDIMM1.158 UH1.AE3
DDR_A_ODT0: JDIMM1.155 UH1.AD3
DDR_A_ODT1: JDIMM1.161 UH1.AE4
DDR_A_PAR: JDIMM1.143 UH1.AG3
DDR_A_RAS#: JDIMM1.152 UH1.AH4
DDR_A_WE#: JDIMM1.151 UH1.AG4
DDR_B_ACT#: JDIMM2.114 UH1.AT9
DDR_B_ALERT#: JDIMM2.116 UH1.AR8
DDR_B_BG0: JDIMM2.115 UH1.AR9
DDR_B_BG1: JDIMM2.113 UH1.AR7
DDR_B_BS0: JDIMM2.150 UH1.AH8
DDR_B_BS1: JDIMM2.145 UH1.AH9
DDR_B_CAS#: JDIMM2.156 UH1.AF8
DDR_B_CKE0: JDIMM2.109 UH1.AT8
DDR_B_CKE1: JDIMM2.110 UH1.AT10
DDR_B_CLK0: JDIMM2.137 UH1.AM9
DDR_B_CLK1: JDIMM2.138 UH1.AM7
DDR_B_CLK#0: JDIMM2.139 UH1.AN9
DDR_B_CLK#1: JDIMM2.140 UH1.AM8
DDR_B_CS#0: JDIMM2.149 UH1.AF11
DDR_B_CS#1: JDIMM2.157 UH1.AE7
DDR_B_D0: JDIMM2.3 UH1.AB1
DDR_B_D1: JDIMM2.7 UH1.AB2
DDR_B_D2: JDIMM2.21 UH1.AA4
DDR_B_D3: JDIMM2.17 UH1.AA5
DDR_B_D4: JDIMM2.8 UH1.AB5
DDR_B_D5: JDIMM2.4 UH1.AB4
DDR_B_D6: JDIMM2.20 UH1.AA2
DDR_B_D7: JDIMM2.16 UH1.AA1
DDR_B_D8: JDIMM2.25 UH1.V5
DDR_B_D9: JDIMM2.24 UH1.V2
DDR_B_D10: JDIMM2.42 UH1.U1
DDR_B_D11: JDIMM2.38 UH1.U2
DDR_B_D12: JDIMM2.29 UH1.V1
DDR_B_D13: JDIMM2.28 UH1.V4
DDR_B_D14: JDIMM2.37 UH1.U5
DDR_B_D15: JDIMM2.41 UH1.U4
DDR_B_D16: JDIMM2.63 UH1.AA11
DDR_B_D17: JDIMM2.62 UH1.AA10
DDR_B_D18: JDIMM2.46 UH1.AC11
DDR_B_D19: JDIMM2.50 UH1.AC10
DDR_B_D20: JDIMM2.58 UH1.AA7
DDR_B_D21: JDIMM2.59 UH1.AA8
DDR_B_D22: JDIMM2.45 UH1.AC8
DDR_B_D23: JDIMM2.49 UH1.AC7
DDR_B_D24: JDIMM2.71 UH1.W8
DDR_B_D25: JDIMM2.67 UH1.W7
DDR_B_D26: JDIMM2.80 UH1.V10
DDR_B_D27: JDIMM2.83 UH1.V11
DDR_B_D28: JDIMM2.66 UH1.W11
DDR_B_D29: JDIMM2.70 UH1.W10
DDR_B_D30: JDIMM2.84 UH1.V7
DDR_B_D31: JDIMM2.79 UH1.V8
DDR_B_D32: JDIMM2.169 UH1.R2
DDR_B_D33: JDIMM2.186 UH1.P5
DDR_B_D34: JDIMM2.170 UH1.R4
DDR_B_D35: JDIMM2.182 UH1.P4
DDR_B_D36: JDIMM2.174 UH1.R5
DDR_B_D37: JDIMM2.183 UH1.P2
DDR_B_D38: JDIMM2.173 UH1.R1
DDR_B_D39: JDIMM2.187 UH1.P1
DDR_B_D40: JDIMM2.191 UH1.M4
DDR_B_D41: JDIMM2.194 UH1.M1
DDR_B_D42: JDIMM2.207 UH1.L4
DDR_B_D43: JDIMM2.208 UH1.L2
DDR_B_D44: JDIMM2.190 UH1.M5
DDR_B_D45: JDIMM2.195 UH1.M2
DDR_B_D46: JDIMM2.204 UH1.L5
DDR_B_D47: JDIMM2.203 UH1.L1
DDR_B_D48: JDIMM2.216 UH1.R11
DDR_B_D49: JDIMM2.228 UH1.P11
DDR_B_D50: JDIMM2.229 UH1.P7
DDR_B_D51: JDIMM2.215 UH1.R8
DDR_B_D52: JDIMM2.211 UH1.R10
DDR_B_D53: JDIMM2.224 UH1.P10
DDR_B_D54: JDIMM2.212 UH1.R7
DDR_B_D55: JDIMM2.225 UH1.P8
DDR_B_D56: JDIMM2.250 UH1.L11
DDR_B_D57: JDIMM2.237 UH1.M11
DDR_B_D58: JDIMM2.249 UH1.L7
DDR_B_D59: JDIMM2.232 UH1.M8
DDR_B_D60: JDIMM2.246 UH1.L10
DDR_B_D61: JDIMM2.233 UH1.M10
DDR_B_D62: JDIMM2.236 UH1.M7
DDR_B_D63: JDIMM2.245 UH1.L8
DDR_B_DQS0: JDIMM2.13 UH1.AB3
DDR_B_DQS1: JDIMM2.34 UH1.V3
DDR_B_DQS2: JDIMM2.55 UH1.AA9
DDR_B_DQS3: JDIMM2.76 UH1.V9
DDR_B_DQS4: JDIMM2.179 UH1.R3
DDR_B_DQS5: JDIMM2.200 UH1.M3
DDR_B_DQS6: JDIMM2.221 UH1.P9
DDR_B_DQS7: JDIMM2.242 UH1.L9
DDR_B_DQS#0: JDIMM2.11 UH1.AA3
DDR_B_DQS#1: JDIMM2.32 UH1.U3
DDR_B_DQS#2: JDIMM2.53 UH1.AC9
DDR_B_DQS#3: JDIMM2.74 UH1.W9
DDR_B_DQS#4: JDIMM2.177 UH1.P3
DDR_B_DQS#5: JDIMM2.198 UH1.L3
DDR_B_DQS#6: JDIMM2.219 UH1.R9
DDR_B_DQS#7: JDIMM2.240 UH1.M9
DDR_B_MA0: JDIMM2.144 UH1.AJ9
DDR_B_MA1: JDIMM2.133 UH1.AK6
DDR_B_MA2: JDIMM2.132 UH1.AK5
DDR_B_MA3: JDIMM2.131 UH1.AL5
DDR_B_MA4: JDIMM2.128 UH1.AL6
DDR_B_MA5: JDIMM2.126 UH1.AM6
DDR_B_MA6: JDIMM2.127 UH1.AN7
DDR_B_MA7: JDIMM2.122 UH1.AN10
DDR_B_MA8: JDIMM2.125 UH1.AN8
DDR_B_MA9: JDIMM2.121 UH1.AR11
DDR_B_MA10: JDIMM2.146 UH1.AH7
DDR_B_MA11: JDIMM2.120 UH1.AN11
DDR_B_MA12: JDIMM2.119 UH1.AR10
DDR_B_MA13: JDIMM2.158 UH1.AF9
DDR_B_ODT0: JDIMM2.155 UH1.AF7
DDR_B_ODT1: JDIMM2.161 UH1.AE8
DDR_B_PAR: JDIMM2.143 UH1.AJ7
DDR_B_RAS#: JDIMM2.152 UH1.AH10
DDR_B_WE#: JDIMM2.151 UH1.AH11
DDR_RCOMP0: RH148.2 UH1.G1
DDR_RCOMP1: RH149.2 UH1.H1
DDR_RCOMP2: RH150.2 UH1.J2
DDR_VTT_PG_CTRL: UC1.2 UH1.BT13
DEBUG_CTL1: RT66.2 UT4.E4
DEBUG_CTL2: RT67.2 UT4.D5
DGPU_HOLD_RST#: RG165.2 UG10.1 UH2.AL36
DGPU_PEX_RST#: DG9.1 QG6.2 QG6.5 QG7.2 QG7.5 RG160.2 RG161.2 RG562.1 RG584.1 UG9.BK26 UG22.1 UG30.2
DGPU_PWR_EN: RG551.1 RH127.1 RH129.1 UH2.AJ39
DGPU_PWROK: PR800.2 PU800.1 RH86.2 UG25.1 UG29.1 UH2.AJ38
DGPU_ROM_SCLK: RG75.1 UG13.6
DGPU_ROM_SI: RG77.1 UG13.5
DGPU_ROM_SO_R: RG76.2 UG13.2
DISPOFF#: JEDP1.17 RV536.1 RV566.2
DMI_CRX_PTX_N0: UH1.E8 UH2.C27
DMI_CRX_PTX_N1: UH1.F6 UH2.B28
DMI_CRX_PTX_N2: UH1.E5 UH2.B29
DMI_CRX_PTX_N3: UH1.J9 UH2.B30
DMI_CRX_PTX_P0: UH1.D8 UH2.B27
DMI_CRX_PTX_P1: UH1.E6 UH2.A28
DMI_CRX_PTX_P2: UH1.D5 UH2.C29
DMI_CRX_PTX_P3: UH1.J8 UH2.A30
DMI_CTX_PRX_N0: UH1.A8 UH2.L27
DMI_CTX_PRX_N1: UH1.B6 UH2.E24
DMI_CTX_PRX_N2: UH1.A5 UH2.G27
DMI_CTX_PRX_N3: UH1.B4 UH2.L29
DMI_CTX_PRX_P0: UH1.B8 UH2.N27
DMI_CTX_PRX_P1: UH1.C6 UH2.G24
DMI_CTX_PRX_P2: UH1.B5 UH2.E26
DMI_CTX_PRX_P3: UH1.D4 UH2.K29
DMIC_CLK: CA30.1 DA1.3 EC5206.1 JCAM1.2 LA1.1
DMIC_CLK_R: HDA1.3 LA1.2
DMIC_DAT: DA1.2 EC5205.1 JCAM1.3 RA27.1
DMIC_DATA_R: CA62.1 HDA1.2 RA27.2
DP_CRT_B: CVGA18.1 LVGA3.1 RVGA11.1 UVGA1.21
DP_CRT_G: CVGA17.1 LVGA2.1 RVGA12.1 UVGA1.22
DP_CRT_HSYNC_CON: RVGA14.2 UVGA1.19
DP_CRT_R: CVGA16.1 LVGA1.1 RVGA13.1 UVGA1.23
DP_CRT_VSYNC_CON: RVGA15.2 UVGA1.18
DP_N0: CVGA11.2 UVGA1.6
DP_N1: CVGA13.2 UVGA1.8
DP_P0: CVGA10.2 UVGA1.5
DP_P1: CVGA12.2 UVGA1.7
DPSNK1_DDC_CLK: RPT1.1 UT1.Y5
DPSNK1_DDC_DATA: RPT1.2 UT1.R4
DPSNK2_DDC_CLK: RPT1.3 UT1.Y8
DPSNK2_DDC_DATA: RPT1.4 UT1.N4
DPSNK_RBIAS: RT19.1 UT1.Y18
DPSRC_RBIAS: RT5.1 UT1.N6
DSBL_GPU_PH1: PR6103.1 PU6100.26
DSBL_GPU_PH2: PR6112.1 PU6101.26
DSBL_GPU_PH3: PR6117.1 PU6102.26
E51_TX2: JNGFF1.30 RN4.1 RN5.2
EAP: PR6018.2 PU6000.29
EAPD/DC DET: HDA1.4
EC_AC_BAT#: DG8.2 PR34.1 RG16.1 UG9.BE6
EC_AGND: CE81.2 CE87.2 CE98.2 CE104.2 CE107.2 RE14.1 RE67.2 RE124.1 UE1.112
EC_MUTE#: HDA1.47 RA23.2 RE58.1
EDP_AUXN: CV591.1 UH1.B26
EDP_AUXN_C: CV591.2 JEDP1.26
EDP_AUXP: CV592.1 UH1.C26
EDP_AUXP_C: CV592.2 JEDP1.25
EDP_COMP: RH30.1 UH1.D37
EDP_DISP_UTIL: RH20.1 UH1.A33
EDP_HPD: JEDP1.18 RV551.1 UH2.BD7
EDP_TXN0: CV581.1 UH1.E29
EDP_TXN0_C: CV581.2 JEDP1.29
EDP_TXN1: CV586.1 UH1.E28
EDP_TXN1_C: CV586.2 JEDP1.32
EDP_TXN2: CV588.1 UH1.B29
EDP_TXN2_C: CV588.2 JEDP1.35
EDP_TXN3: CV590.1 UH1.B28
EDP_TXN3_C: CV590.2 JEDP1.38
EDP_TXP0: CV580.1 UH1.D29
EDP_TXP0_C: CV580.2 JEDP1.28
EDP_TXP1: CV585.1 UH1.F28
EDP_TXP1_C: CV585.2 JEDP1.31
EDP_TXP2: CV587.1 UH1.A29
EDP_TXP2_C: CV587.2 JEDP1.34
EDP_TXP3: CV589.1 UH1.C28
EDP_TXP3_C: CV589.2 JEDP1.37
EN_0.6VSP: PC216.1 PR210.2 PR211.2 PU200.7
EN_1.0VS_VGAP: PC10V7.1 PR10V4.2 PR10V5.1 PR10V6.2 PU10V0.5
EN_1.2V: PC215.1 PR209.2 PU200.8
EN_1V: PC107.1 PR102.1 PR103.2 PU100.11
EN_2.5V: PC25V00.1 PR25V00.2 PR25V01.1 PU25V00.2
EN_+1.35V: PC800.1 PR803.2 PU800.3
EN_VCCIO: PC4011.1 PR4003.2 PR4005.1 PU4000.11
ENVDD: DV3.1 RZ40.1 UZ8.4
ENVDD_PCH: DV3.3 UH2.W42
ESPI_ALERT#: RH578.1 UE1.55 UH2.BA17
ESPI_CLK: CC4.2 JESPI1.10 RH168.2 UE1.57
ESPI_CS#: JESPI1.7 UE1.58 UH2.BE16
ESPI_IO0: JESPI1.3 RH574.2 UE1.59
ESPI_IO1: JESPI1.4 RH575.2 UE1.60
ESPI_IO2: JESPI1.5 RH576.2 UE1.61
ESPI_IO3: JESPI1.6 RH577.2 UE1.62
ESPI_RESET#: RE144.2 UE1.53 UH2.BC18
FAN1_PWM: Q12.3 RE121.2 UE1.47
FAN1_PWM_OUT: JFAN1.3 Q12.1 RE100.2
FAN1_TACH: CE99.1 DE7.2 RE81.2 UE1.40
FAN1_TACH_D: DE7.1 JFAN1.2 RE82.2
FAN2_PWM: Q13.3 RE122.2 UE1.34
FAN2_PWM_OUT: JFAN2.3 Q13.1 RE101.2
FAN2_TACH: CE100.1 DE9.2 RE83.2 UE1.41
FAN2_TACH_D: DE9.1 JFAN2.2 RE84.2
FB_1.0VS_VGAP: PC10V6.2 PR10V2.1 PR10V3.1 PU10V0.6
FB_1.2V: PR205.1 PR208.1 PU200.6
FB_1.8V: PC18V03.2 PR18V02.2 PR18V05.1 PU18V00.14
FB_1V: PC114.2 PR106.2 PR107.1 PU100.14
FB_2.5V: PC25V03.2 PR25V03.2 PR25V04.1 PU25V00.7
FB_3V: PR300.2 PR302.2 PU300.4
FB_5V: PR301.1 PR303.1 PU300.2
FB_+1.35V: PC814.1 PR807.1 PR809.1 PR812.1 PU800.4
FB_GPU: PC6011.2 PR6022.1 PR6025.1 PU6000.31
FB_RC_1: PC6011.1 PR6024.2
FB_RC_2: PR6021.1 PR6023.1 PR6024.1 PR6025.2
FB_VCCIO: PC4010.2 PR4006.2 PR4009.1 PU4000.14
FB_VCCIO_SENSE: PR4004.2 PR4006.1 PR4007.1
FB_VDDQ_SENSE: PR814.2 UG9.E52
FBA_CLK0: RG102.1 UG1.J12 UG9.AG45
FBA_CLK0#: RG523.1 UG1.J11 UG9.AG46
FBA_CLK1: RG103.1 UG2.J12 UG9.AK46
FBA_CLK1#: RG524.1 UG2.J11 UG9.AK45
FBA_CMD0: UG1.G3 UG9.Y51
FBA_CMD1: RG47.2 UG1.J3 UG9.Y52
FBA_CMD2: RG54.1 UG1.J2 UG9.Y49
FBA_CMD3: UG1.L3 UG9.AA52
FBA_CMD4: UG1.K5 UG9.AA51
FBA_CMD5: UG1.K4 UG9.AA50
FBA_CMD6: UG1.J5 UG9.AC50
FBA_CMD7: UG1.J4 UG9.AC51
FBA_CMD8: UG1.H5 UG9.AC52
FBA_CMD9: UG1.H4 UG9.AC49
FBA_CMD10: UG1.G12 UG9.AD52
FBA_CMD11: UG1.H10 UG9.AD51
FBA_CMD12: UG1.H11 UG9.AD50
FBA_CMD13: UG1.K11 UG9.AF50
FBA_CMD14: UG1.K10 UG9.AF51
FBA_CMD15: UG1.L12 UG9.AF52
FBA_CMD16: UG2.L3 UG9.AN50
FBA_CMD17: RG48.2 UG2.J3 UG9.AN51
FBA_CMD18: RG53.1 UG2.J2 UG9.AN52
FBA_CMD19: UG2.G3 UG9.AM49
FBA_CMD20: UG2.H5 UG9.AM52
FBA_CMD21: UG2.H4 UG9.AM51
FBA_CMD22: UG2.J5 UG9.AM50
FBA_CMD23: UG2.J4 UG9.AK50
FBA_CMD24: UG2.K5 UG9.AK51
FBA_CMD25: UG2.K4 UG9.AK52
FBA_CMD26: UG2.L12 UG9.AJ49
FBA_CMD27: UG2.K10 UG9.AJ52
FBA_CMD28: UG2.K11 UG9.AJ51
FBA_CMD29: UG2.H11 UG9.AJ50
FBA_CMD30: UG2.H10 UG9.AG50
FBA_CMD31: UG2.G12 UG9.AG51
FBA_D0: UG1.U4 UG9.U51
FBA_D1: UG1.U2 UG9.U48
FBA_D2: UG1.T4 UG9.U50
FBA_D3: UG1.T2 UG9.U49
FBA_D4: UG1.N4 UG9.R51
FBA_D5: UG1.N2 UG9.R50
FBA_D6: UG1.M4 UG9.R47
FBA_D7: UG1.M2 UG9.U46
FBA_D8: UG1.U11 UG9.V46
FBA_D9: UG1.U13 UG9.Y45
FBA_D10: UG1.T11 UG9.Y47
FBA_D11: UG1.T13 UG9.Y46
FBA_D12: UG1.N11 UG9.V50
FBA_D13: UG1.N13 UG9.V47
FBA_D14: UG1.M11 UG9.U52
FBA_D15: UG1.M13 UG9.V51
FBA_D16: UG1.A11 UG9.AJ44
FBA_D17: UG1.A13 UG9.AG48
FBA_D18: UG1.B11 UG9.AJ45
FBA_D19: UG1.B13 UG9.AG49
FBA_D20: UG1.E11 UG9.AF46
FBA_D21: UG1.E13 UG9.AF47
FBA_D22: UG1.F11 UG9.AF48
FBA_D23: UG1.F13 UG9.AD47
FBA_D24: UG1.A4 UG9.AD49
FBA_D25: UG1.A2 UG9.AD48
FBA_D26: UG1.B4 UG9.AC46
FBA_D27: UG1.B2 UG9.AC47
FBA_D28: UG1.E4 UG9.AA47
FBA_D29: UG1.E2 UG9.AA46
FBA_D30: UG1.F4 UG9.AA45
FBA_D31: UG1.F2 UG9.Y44
FBA_D32: UG2.A4 UG9.AW51
FBA_D33: UG2.A2 UG9.BA52
FBA_D34: UG2.B4 UG9.AW50
FBA_D35: UG2.B2 UG9.BA51
FBA_D36: UG2.E4 UG9.BA50
FBA_D37: UG2.E2 UG9.BB50
FBA_D38: UG2.F4 UG9.BA49
FBA_D39: UG2.F2 UG9.AW49
FBA_D40: UG2.A11 UG9.AV48
FBA_D41: UG2.A13 UG9.AT49
FBA_D42: UG2.B11 UG9.AT47
FBA_D43: UG2.B13 UG9.AT48
FBA_D44: UG2.E11 UG9.AT46
FBA_D45: UG2.E13 UG9.AV51
FBA_D46: UG2.F11 UG9.AV52
FBA_D47: UG2.F13 UG9.AV49
FBA_D48: UG2.U11 UG9.AJ48
FBA_D49: UG2.U13 UG9.AJ46
FBA_D50: UG2.T11 UG9.AJ47
FBA_D51: UG2.T13 UG9.AK49
FBA_D52: UG2.N11 UG9.AM47
FBA_D53: UG2.N13 UG9.AM46
FBA_D54: UG2.M11 UG9.AN48
FBA_D55: UG2.M13 UG9.AN49
FBA_D56: UG2.U4 UG9.AM44
FBA_D57: UG2.U2 UG9.AM45
FBA_D58: UG2.T4 UG9.AN45
FBA_D59: UG2.T2 UG9.AN46
FBA_D60: UG2.N4 UG9.AR48
FBA_D61: UG2.N2 UG9.AN47
FBA_D62: UG2.M4 UG9.AR47
FBA_D63: UG2.M2 UG9.AR46
FBA_DBI0: UG1.P2 UG9.U47
FBA_DBI1: UG1.P13 UG9.Y48
FBA_DBI2: UG1.D13 UG9.AG47
FBA_DBI3: UG1.D2 UG9.AC48
FBA_DBI4: UG2.D2 UG9.BB51
FBA_DBI5: UG2.D13 UG9.AV50
FBA_DBI6: UG2.P13 UG9.AM48
FBA_DBI7: UG2.P2 UG9.AR49
FBA_EDC0: UG1.R2 UG9.R48
FBA_EDC1: UG1.R13 UG9.V48
FBA_EDC2: UG1.C13 UG9.AF44
FBA_EDC3: UG1.C2 UG9.AA48
FBA_EDC4: UG2.C2 UG9.BB52
FBA_EDC5: UG2.C13 UG9.AT50
FBA_EDC6: UG2.R13 UG9.AK48
FBA_EDC7: UG2.R2 UG9.AR51
FBA_WCK01: UG1.P4 UG9.U45
FBA_WCK01#: UG1.P5 UG9.U44
FBA_WCK23: UG1.D4 UG9.AC45
FBA_WCK23#: UG1.D5 UG9.AC44
FBA_WCK45: UG2.D4 UG9.AV47
FBA_WCK45#: UG2.D5 UG9.AV46
FBA_WCK67: UG2.P4 UG9.AR45
FBA_WCK67#: UG2.P5 UG9.AR44
FBB_CLK0: RG113.1 UG3.J12 UG9.H42
FBB_CLK0#: RG525.1 UG3.J11 UG9.G42
FBB_CLK1: RG114.1 UG4.J12 UG9.F47
FBB_CLK1#: RG526.1 UG4.J11 UG9.E47
FBB_CMD0: UG3.G3 UG9.B35
FBB_CMD1: RG49.2 UG3.J3 UG9.A35
FBB_CMD2: RG56.1 UG3.J2 UG9.D35
FBB_CMD3: UG3.L3 UG9.A36
FBB_CMD4: UG3.K5 UG9.B36
FBB_CMD5: UG3.K4 UG9.C36
FBB_CMD6: UG3.J5 UG9.C38
FBB_CMD7: UG3.J4 UG9.B38
FBB_CMD8: UG3.H5 UG9.A38
FBB_CMD9: UG3.H4 UG9.D38
FBB_CMD10: UG3.G12 UG9.A39
FBB_CMD11: UG3.H10 UG9.B39
FBB_CMD12: UG3.H11 UG9.C39
FBB_CMD13: UG3.K11 UG9.C41
FBB_CMD14: UG3.K10 UG9.B41
FBB_CMD15: UG3.L12 UG9.A41
FBB_CMD16: UG4.L3 UG9.B49
FBB_CMD17: RG50.2 UG4.J3 UG9.A49
FBB_CMD18: RG55.1 UG4.J2 UG9.A48
FBB_CMD19: UG4.G3 UG9.D47
FBB_CMD20: UG4.H5 UG9.A47
FBB_CMD21: UG4.H4 UG9.B47
FBB_CMD22: UG4.J5 UG9.C47
FBB_CMD23: UG4.J4 UG9.C45
FBB_CMD24: UG4.K5 UG9.B45
FBB_CMD25: UG4.K4 UG9.A45
FBB_CMD26: UG4.L12 UG9.D44
FBB_CMD27: UG4.K10 UG9.A44
FBB_CMD28: UG4.K11 UG9.B44
FBB_CMD29: UG4.H11 UG9.C44
FBB_CMD30: UG4.H10 UG9.C42
FBB_CMD31: UG4.G12 UG9.B42
FBB_D0: UG3.U4 UG9.H32
FBB_D1: UG3.U2 UG9.D32
FBB_D2: UG3.T4 UG9.A33
FBB_D3: UG3.T2 UG9.B32
FBB_D4: UG3.N4 UG9.E32
FBB_D5: UG3.N2 UG9.G32
FBB_D6: UG3.M4 UG9.J30
FBB_D7: UG3.M2 UG9.F32
FBB_D8: UG3.U11 UG9.H36
FBB_D9: UG3.U13 UG9.G36
FBB_D10: UG3.T11 UG9.J36
FBB_D11: UG3.T13 UG9.F36
FBB_D12: UG3.N11 UG9.F33
FBB_D13: UG3.N13 UG9.D33
FBB_D14: UG3.M11 UG9.J32
FBB_D15: UG3.M13 UG9.G33
FBB_D16: UG3.A11 UG9.E45
FBB_D17: UG3.A13 UG9.D45
FBB_D18: UG3.B11 UG9.F45
FBB_D19: UG3.B13 UG9.G45
FBB_D20: UG3.E11 UG9.D42
FBB_D21: UG3.E13 UG9.E42
FBB_D22: UG3.F11 UG9.F42
FBB_D23: UG3.F13 UG9.H41
FBB_D24: UG3.A4 UG9.E41
FBB_D25: UG3.A2 UG9.F39
FBB_D26: UG3.B4 UG9.E39
FBB_D27: UG3.B2 UG9.D39
FBB_D28: UG3.E4 UG9.F38
FBB_D29: UG3.E2 UG9.E38
FBB_D30: UG3.F4 UG9.D36
FBB_D31: UG3.F2 UG9.E36
FBB_D32: UG4.A4 UG9.M50
FBB_D33: UG4.A2 UG9.P48
FBB_D34: UG4.B4 UG9.M51
FBB_D35: UG4.B2 UG9.M49
FBB_D36: UG4.E4 UG9.P47
FBB_D37: UG4.E2 UG9.P52
FBB_D38: UG4.F4 UG9.R46
FBB_D39: UG4.F2 UG9.P46
FBB_D40: UG4.A11 UG9.L50
FBB_D41: UG4.A13 UG9.L51
FBB_D42: UG4.B11 UG9.L52
FBB_D43: UG4.B13 UG9.L49
FBB_D44: UG4.E11 UG9.M46
FBB_D45: UG4.E13 UG9.L47
FBB_D46: UG4.F11 UG9.M48
FBB_D47: UG4.F13 UG9.M47
FBB_D48: UG4.U11 UG9.D48
FBB_D49: UG4.U13 UG9.C50
FBB_D50: UG4.T11 UG9.C48
FBB_D51: UG4.T13 UG9.C49
FBB_D52: UG4.N11 UG9.E49
FBB_D53: UG4.N13 UG9.E50
FBB_D54: UG4.M11 UG9.F49
FBB_D55: UG4.M13 UG9.F48
FBB_D56: UG4.U4 UG9.F50
FBB_D57: UG4.U2 UG9.D52
FBB_D58: UG4.T4 UG9.J50
FBB_D59: UG4.T2 UG9.H48
FBB_D60: UG4.N4 UG9.H51
FBB_D61: UG4.N2 UG9.J51
FBB_D62: UG4.M4 UG9.H49
FBB_D63: UG4.M2 UG9.H52
FBB_DBI0: UG3.P2 UG9.C32
FBB_DBI1: UG3.P13 UG9.E33
FBB_DBI2: UG3.D13 UG9.E44
FBB_DBI3: UG3.D2 UG9.G39
FBB_DBI4: UG4.D2 UG9.P49
FBB_DBI5: UG4.D13 UG9.L48
FBB_DBI6: UG4.P13 UG9.D50
FBB_DBI7: UG4.P2 UG9.H50
FBB_EDC0: UG3.R2 UG9.B33
FBB_EDC1: UG3.R13 UG9.E35
FBB_EDC2: UG3.C13 UG9.G44
FBB_EDC3: UG3.C2 UG9.H38
FBB_EDC4: UG4.C2 UG9.P50
FBB_EDC5: UG4.C13 UG9.J48
FBB_EDC6: UG4.R13 UG9.D51
FBB_EDC7: UG4.R2 UG9.F51
FBB_WCK01: UG3.P4 UG9.J33
FBB_WCK01#: UG3.P5 UG9.H33
FBB_WCK23: UG3.D4 UG9.J39
FBB_WCK23#: UG3.D5 UG9.H39
FBB_WCK45: UG4.D4 UG9.L46
FBB_WCK45#: UG4.D5 UG9.L45
FBB_WCK67: UG4.P4 UG9.H47
FBB_WCK67#: UG4.P5 UG9.H46
FBC_CLK0: RG124.1 UG5.J12 UG9.G15
FBC_CLK0#: RG527.1 UG5.J11 UG9.F15
FBC_CLK1: RG125.1 UG6.J12 UG9.H21
FBC_CLK1#: RG528.1 UG6.J11 UG9.J21
FBC_CMD0: UG5.G3 UG9.C11
FBC_CMD1: RG51.2 UG5.J3 UG9.B11
FBC_CMD2: RG58.1 UG5.J2 UG9.A11
FBC_CMD3: UG5.L3 UG9.D11
FBC_CMD4: UG5.K5 UG9.A12
FBC_CMD5: UG5.K4 UG9.B12
FBC_CMD6: UG5.J5 UG9.C12
FBC_CMD7: UG5.J4 UG9.C14
FBC_CMD8: UG5.H5 UG9.B14
FBC_CMD9: UG5.H4 UG9.A14
FBC_CMD10: UG5.G12 UG9.D14
FBC_CMD11: UG5.H10 UG9.A15
FBC_CMD12: UG5.H11 UG9.B15
FBC_CMD13: UG5.K11 UG9.C15
FBC_CMD14: UG5.K10 UG9.C17
FBC_CMD15: UG5.L12 UG9.B17
FBC_CMD16: UG6.L3 UG9.B24
FBC_CMD17: RG52.2 UG6.J3 UG9.A24
FBC_CMD18: RG57.1 UG6.J2 UG9.D23
FBC_CMD19: UG6.G3 UG9.A23
FBC_CMD20: UG6.H5 UG9.B23
FBC_CMD21: UG6.H4 UG9.C23
FBC_CMD22: UG6.J5 UG9.C21
FBC_CMD23: UG6.J4 UG9.B21
FBC_CMD24: UG6.K5 UG9.A21
FBC_CMD25: UG6.K4 UG9.D20
FBC_CMD26: UG6.L12 UG9.A20
FBC_CMD27: UG6.K10 UG9.B20
FBC_CMD28: UG6.K11 UG9.C20
FBC_CMD29: UG6.H11 UG9.C18
FBC_CMD30: UG6.H10 UG9.B18
FBC_CMD31: UG6.G12 UG9.A18
FBC_D0: UG5.U4 UG9.C6
FBC_D1: UG5.U2 UG9.D6
FBC_D2: UG5.T4 UG9.A6
FBC_D3: UG5.T2 UG9.B6
FBC_D4: UG5.N4 UG9.B4
FBC_D5: UG5.N2 UG9.A4
FBC_D6: UG5.M4 UG9.B3
FBC_D7: UG5.M2 UG9.C4
FBC_D8: UG5.U11 UG9.D9
FBC_D9: UG5.U13 UG9.C9
FBC_D10: UG5.T11 UG9.E9
FBC_D11: UG5.T13 UG9.B9
FBC_D12: UG5.N11 UG9.B8
FBC_D13: UG5.N13 UG9.A8
FBC_D14: UG5.M11 UG9.F6
FBC_D15: UG5.M13 UG9.E6
FBC_D16: UG5.A11 UG9.F18
FBC_D17: UG5.A13 UG9.G18
FBC_D18: UG5.B11 UG9.E18
FBC_D19: UG5.B13 UG9.H18
FBC_D20: UG5.E11 UG9.D15
FBC_D21: UG5.E13 UG9.E15
FBC_D22: UG5.F11 UG9.G17
FBC_D23: UG5.F13 UG9.H17
FBC_D24: UG5.A4 UG9.J15
FBC_D25: UG5.A2 UG9.H15
FBC_D26: UG5.B4 UG9.E14
FBC_D27: UG5.B2 UG9.F14
FBC_D28: UG5.E4 UG9.H11
FBC_D29: UG5.E2 UG9.G11
FBC_D30: UG5.F4 UG9.F11
FBC_D31: UG5.F2 UG9.E11
FBC_D32: UG6.A4 UG9.J29
FBC_D33: UG6.A2 UG9.F30
FBC_D34: UG6.B4 UG9.H29
FBC_D35: UG6.B2 UG9.G30
FBC_D36: UG6.E4 UG9.B30
FBC_D37: UG6.E2 UG9.A30
FBC_D38: UG6.F4 UG9.H30
FBC_D39: UG6.F2 UG9.C30
FBC_D40: UG6.A11 UG9.D27
FBC_D41: UG6.A13 UG9.J26
FBC_D42: UG6.B11 UG9.F27
FBC_D43: UG6.B13 UG9.G27
FBC_D44: UG6.E11 UG9.C27
FBC_D45: UG6.E13 UG9.B27
FBC_D46: UG6.F11 UG9.A27
FBC_D47: UG6.F13 UG9.G29
FBC_D48: UG6.U11 UG9.H20
FBC_D49: UG6.U13 UG9.D18
FBC_D50: UG6.T11 UG9.G20
FBC_D51: UG6.T13 UG9.E20
FBC_D52: UG6.N11 UG9.F23
FBC_D53: UG6.N13 UG9.E21
FBC_D54: UG6.M11 UG9.D21
FBC_D55: UG6.M13 UG9.E23
FBC_D56: UG6.U4 UG9.G24
FBC_D57: UG6.U2 UG9.H26
FBC_D58: UG6.T4 UG9.F24
FBC_D59: UG6.T2 UG9.G26
FBC_D60: UG6.N4 UG9.F26
FBC_D61: UG6.N2 UG9.D26
FBC_D62: UG6.M4 UG9.B26
FBC_D63: UG6.M2 UG9.C26
FBC_DBI0: UG5.P2 UG9.A5
FBC_DBI1: UG5.P13 UG9.C8
FBC_DBI2: UG5.D13 UG9.J18
FBC_DBI3: UG5.D2 UG9.F12
FBC_DBI4: UG6.D2 UG9.D29
FBC_DBI5: UG6.D13 UG9.E27
FBC_DBI6: UG6.P13 UG9.F20
FBC_DBI7: UG6.P2 UG9.E26
FBC_EDC0: UG5.R2 UG9.D5
FBC_EDC1: UG5.R13 UG9.D8
FBC_EDC2: UG5.C13 UG9.E17
FBC_EDC3: UG5.C2 UG9.E12
FBC_EDC4: UG6.C2 UG9.E30
FBC_EDC5: UG6.C13 UG9.B29
FBC_EDC6: UG6.R13 UG9.G21
FBC_EDC7: UG6.R2 UG9.E24
FBC_WCK01: UG5.P4 UG9.F8
FBC_WCK01#: UG5.P5 UG9.G8
FBC_WCK23: UG5.D4 UG9.H12
FBC_WCK23#: UG5.D5 UG9.G12
FBC_WCK45: UG6.D4 UG9.J27
FBC_WCK45#: UG6.D5 UG9.H27
FBC_WCK67: UG6.P4 UG9.G23
FBC_WCK67#: UG6.P5 UG9.H23
FBCAL_GND: RG68.1 UG9.P44
FBCAL_TERM: RG69.1 UG9.R45
FBCAL_VDDQ: RG67.1 UG9.R44
FBRTN: PC6002.1 PC6015.2 PR6026.1 PR6030.1 PR6062.2 PU6000.32
FBVDD/Q_EN: PR803.1 QG513.2 RG557.1 UG27.4
FCCM_GT: PR5204.1 PR5215.1 PU5000.11
FCCM_SA: PR5223.1 PU5000.34
FCCM_VCORE: PR5104.1 PR5117.1 PR5129.1 PU5000.24
FFS_INT1: RS40.2 U5603.12 UH2.BC27
FFS_INT2: QC5.5 RS41.2 U5603.11 UH2.AN41
FFS_INT2_Q: JHDD1.9 QC5.6 RS1.2
FPR_SCAN#: D5223.3 JPW.10 RE143.1 UE1.42
FRAME_LOCK#: RG502.1 UG9.BG2
FSW_GPU_R: PR6035.2 PR6038.2
GC6_EVENT#_D: DG2.2 RG164.1 UG9.BD1
GC6_THM_DIS#: RH573.1 UE1.23 UH2.BD24
GPIO3_OC_WARN#: RG522.1 RG529.2 UG9.BB4 UG11.8
GPU_B+: PC806.1 PC807.1 PL800.2 PR6100.4 PR6101.1
GPU_BUFRST#: T6.1(TP-1) UG9.BF9
GPU_EVENT#: DG2.1 UH2.AR24
GPU_GC6_FB_EN: QG511.3 RG22.1 RG553.1 UG9.BB5 UG27.1
GPU_GC6_FB_EN_H: QG511.1 RH545.2 UH2.AW27
GPU_HPD_RT: RG575.2 RP45.2 UG30.1
GPU_ID1: RH551.2 RH552.1 UH2.AJ33
GPU_ID2: RH553.2 RH554.1 UH2.AM43
GPU_IMON: PR6013.2 PU6000.25
GPU_JTAG_TCK: T10.1(TP-1) UG9.BK24
GPU_JTAG_TDI: T12.1(TP-1) UG9.BM23
GPU_JTAG_TDO: T13.1(TP-1) UG9.BM24
GPU_JTAG_TMS: T11.1(TP-1) UG9.BL23
GPU_JTAG_TRST#: RG518.1 UG9.BL24
GPU_LPC: PR6050.1 PR6063.2 PU6000.35
GPU_PEX_RST_HOLD#: DG9.3 RG166.1 UG9.BG3
GPU_PROG1: PR6046.1 PR6056.2 PU6000.24
GPU_PROG2: PR6047.1 PR6057.2 PU6000.23
GPU_PROG3: PR6048.1 PR6058.2 PU6000.33
GPU_PROG4: PR6044.1 PR6059.2 PU6000.34
GPU_PROG5: PR6060.2 PU6000.26
GPU_PROG6: PR6035.1 PU6000.3
GPU_PSI: PR6042.1 PR6051.2 PR6054.2 PU6000.37
GPU_PWM1: PR6041.2 PR6102.1 PR6105.2 PU6100.1
GPU_PWM2: PR6045.2 PR6109.1 PR6111.2 PU6101.1
GPU_PWM3: PR6053.1 PR6116.1 PR6119.2 PU6102.1
GPU_PWR_EN: RG551.2 UG25.2 UG26.1 UG31.1
GPU_PWR_LEVEL: DG8.1 UE1.10
GPU_THM_SMBCLK: QG6.3 QTH3.3 RE46.1 RTH6.2 UE1.12 UH2.AW42
GPU_THM_SMBDAT: QG6.6 QTH3.6 RE45.1 RTH5.2 UE1.11 UH2.AW45
GPU_VID: PR6069.2 PU6000.39
H_CATERR#: RH144.2 UH1.BM30
H_CPUPWRGD: UH1.BT31 UH2.AM3
H_DRAMRST#: CD69.1 RD31.2 RD35.2 UH2.BC14
H_PECI: RE17.1 UE1.94
H_PM_DOWN: RH155.1 UH2.AH2
H_PM_DOWN_R: RH155.2 UH1.BP31
H_PM_SYNC: RH189.1 UH2.AJ4
H_PM_SYNC_R: RH189.2 UH1.BM34
H_PROCHOT#: CE86.1 PC5000.1 PQ5.1 PR24.2 PR25.1 PR729.1 PR5000.1 RH158.1 RH165.2 UE6.4
H_PROCHOT#_R: CH211.1 RH158.2 UH1.BR30
H_THERMTRIP#: RH191.1 UH2.AJ3
H_THERMTRIP#_R: RH163.2 RH191.2 UH1.J31
H_VCCST_PWRGD: CH210.1 RH154.1 RH164.2 RH542.1 UC16.4
HDA_BITCLK: RH572.2 UH2.BA9
HDA_BITCLK_AUDIO: CA66.1 CH50.2 HDA1.6 RH572.1
HDA_CODEC_SDIN0: HDA1.8 RA32.2
HDA_SDIN0_AUDIO: RA32.1 UH2.BE7
HDA_SDOUT: CH51.2 RH18.2 RP15.8 UH2.BB7
HDA_SDOUT_AUDIO: HDA1.5 RP15.1
HDA_SYNC: RP15.6 UH2.BD9
HDA_SYNC_AUDIO: HDA1.10 RP15.3
HDD_DEVSLP: RD62.1 UH2.AG43
HDD_DEVSLP_R: JHDD1.8 RD62.2
HDMI_CEC: CV601.2 JHDMI1.13 RP11.2
HDMI_HPD: CP47.1 CV599.2 JHDMI1.19 RP46.2 UP2.21
HDMI_HPD_PCH: QP1.3 RH567.2 UH2.AT44
HDMI_RESERVED: CV600.2 JHDMI1.14
HOST_DEBUG_TX: JDEG1.8 RE64.2 RN5.1 RN8.1 UE1.81
HPD_IFPC: QG9.1 RG572.1 UG9.BA4
HW_ACAV_IN: RE138.2 UE1.128
I2C1_SCK_TP: QE19.4 RH119.2 UH2.AR41
I2C1_SCK_TP_C: CE105.1 DE4.1 JTP.6 QE19.3 RE9.1
I2C1_SDA_TP: QE19.1 RH120.2 UH2.AR44
I2C1_SDA_TP_C: CE80.1 DE4.3 JTP.7 QE19.6 RE7.1
I2C_EN8713: RI25.2 UI3.24
I2CC_SCL: QG7.3 RG60.2 UG11.6
I2CC_SCL_R: QG7.4 RG167.2 UG9.BG9
I2CC_SDA: QG7.6 RG61.2 UG11.7
I2CC_SDA_R: QG7.1 RG159.2 UG9.BH9
I_ADP: CE87.1 RE36.1 UE1.110
I_ADP_R: PR27.1 PR721.1 RE36.2
I_BATT: CE107.1 RE147.1 UE1.114
I_BATT_CHG: PC725.2 PR727.2 PU700.8
I_BATT_R: PR727.1 RE147.2
IADP_CHG: PC723.2 PR721.2 PU700.7
ICSP_CLK: RE109.1 UE1.101
ICSP_CLR: RE110.1 UE1.87
ICSP_DAT: RE112.1 UE1.102
IFPAB_PLLVDD: UG9.BD21
IFPC_CLK_CN: CP15.2 UP2.48
IFPC_CLK_CP: CP16.2 UP2.47
IFPC_CLK_N: CP15.1 UG9.BF17
IFPC_CLK_P: CP16.1 UG9.BE17
IFPC_I2C_8409_CLK: RP9.2 RP25.1 UP2.34
IFPC_I2C_8409_DAT: RP10.2 RP24.1 UP2.33
IFPC_I2C_CLK: QG8.4 RG571.2 UG9.BK9
IFPC_I2C_CLK_R: QG8.3 RG578.1 RP9.1
IFPC_I2C_DAT: QG8.1 RG156.2 UG9.BL9
IFPC_I2C_DAT_R: QG8.6 RG577.1 RP10.1
IFPC_TX0_CN: CP21.2 UP2.45
IFPC_TX0_CP: CP22.2 UP2.44
IFPC_TX0_N: CP21.1 UG9.BF18
IFPC_TX0_P: CP22.1 UG9.BG18
IFPC_TX1_CN: CP20.2 UP2.42
IFPC_TX1_CP: CP19.2 UP2.41
IFPC_TX1_N: CP20.1 UG9.BG20
IFPC_TX1_P: CP19.1 UG9.BH20
IFPC_TX2_CN: CP18.2 UP2.39
IFPC_TX2_CP: CP17.2 UP2.38
IFPC_TX2_N: CP18.1 UG9.BF20
IFPC_TX2_P: CP17.1 UG9.BE20
IFPCD_RSET: RG37.1 UG9.BD20
IFPEF_PLLVDD: UG9.BD15
ILIM_CHG: PQ706.3 PR714.1 PR715.1 PU700.21
ILIM_HI1: RI45.1 US1.16
ILIM_LO1: RI49.1 US1.15
ILIM_SEL_R: RI30.2 US1.4
ILMT_1.8V: PR18V06.1 PR18V07.2 PU18V00.13
ILMT_1V: PR108.2 PR109.1 PU100.13
ILMT_VCCIO: PR4008.1 PR4011.2 PU4000.13
IMVP_VR_ON: CE82.1 RE23.1 RE135.2 UZ21.1
IMVP_VR_PG: PR5020.1 UH14.1
INTRUDER#: RH143.1 UH2.BE11
INV_PWM: DV2.1 JEDP1.16 RV537.1
IR_CAM_DET#: RZ96.2 UH2.AN43
ISEN1: PR6027.2 PU6000.20
ISEN1_GT: PC5029.2 PR5208.2 PR5211.2 PU5000.9
ISEN1_VCORE: PC5028.1 PR5108.2 PR5111.2 PR5112.2 PU5000.21
ISEN2: PR6028.2 PU6000.19
ISEN2_GT: PC5026.2 PR5220.2 PR5222.2 PU5000.10
ISEN2_VCORE: PC5027.1 PR5120.2 PR5123.2 PR5124.2 PU5000.22
ISEN3: PR6029.2 PU6000.18
ISEN3_VCORE: PC5025.1 PR5133.2 PR5135.2 PR5136.2 PU5000.23
ISEN4: PR6033.2 PU6000.17
ISOLATEB: RL1.2 RL30.1 RL33.2 UL1.20
ISUMN_GT: PC5017.2 PC5018.2 PC5024.1 PC5026.1 PC5029.1 PH5002.2 PR5035.2 PR5038.1 PR5040.1 PR5209.1 PR5221.1
ISUMN_SA: PC5011.1 PC5012.1 PC5013.1 PH5001.1 PR5024.2 PR5027.1 PR5029.1 PR5228.1
ISUMN_VCORE: PC5025.2 PC5027.2 PC5028.2 PC5030.1 PC5031.1 PC5032.1 PH5003.1 PR5041.2 PR5042.1 PR5043.2 PR5109.1 PR5122.1 PR5134.1
ISUMP_GT: PC5017.1 PC5018.1 PR5034.1 PR5035.1 PR5207.1 PR5210.2 PR5219.1 PU5000.7
ISUMP_SA: PC5011.2 PC5012.2 PR5029.2 PR5030.2 PR5227.2 PR5231.2 PU5000.32
ISUMP_VCORE: PC5031.2 PC5032.2 PR5042.2 PR5044.2 PR5107.1 PR5110.2 PR5119.1 PR5132.1 PU5000.19
JACK_PLUG: DA5.3 JHP1.6 RA56.1
JTAG_CLK: JDEG1.4 RE111.2
JTAG_TDI: JDEG1.2 RE109.2
JTAG_TDO: JDEG1.5 RE112.2
JTAG_TMS: JDEG1.3 RE110.2
KB_BL_DET: RE3.1 RE4.2 UH2.T45
KB_DET#: JKB1.30 RH128.1 UH2.BD22
KB_LED_PWM: QE5.2 UE1.44
KB_LED_PWM#: JBL1.4 QE5.1
KSI0: JKB1.22 RPE2.4 UE1.98
KSI1: JKB1.24 RPE2.3 UE1.99
KSI2: JKB1.26 RPE2.2 UE1.6
KSI3: JKB1.23 RPE2.1 UE1.7
KSI4: JKB1.27 RPE3.4 UE1.104
KSI5: JKB1.25 RPE3.3 UE1.105
KSI6: JKB1.28 RPE3.2 UE1.107
KSI7: JKB1.29 RPE3.1 UE1.108
KSO0: JKB1.13 RPE4.8 UE1.2
KSO1: JKB1.15 RPE4.7 UE1.14
KSO2: JKB1.14 RPE4.6 UE1.15
KSO3: JKB1.16 RPE4.5 UE1.16
KSO4: JKB1.20 RPE5.8 UE1.37
KSO5: JKB1.21 RPE5.7 UE1.38
KSO6: JKB1.18 RPE5.6 UE1.39
KSO7: JKB1.19 RPE5.5 UE1.50
KSO8: JKB1.17 RPE7.8 UE1.46
KSO9: JKB1.7 RE30.1 UE1.68
KSO10: JKB1.5 RPE6.8 UE1.72
KSO11: JKB1.6 RPE6.7 UE1.74
KSO12: JKB1.12 RPE6.6 UE1.75
KSO13: JKB1.9 RPE6.5 UE1.76
KSO14: JKB1.8 RPE7.6 UE1.77
KSO15: JKB1.10 RPE7.7 UE1.86
KSO16: JKB1.11 RPE7.5 UE1.92
L_BKLT_EN_EC: RE134.2 UH2.W35
LAN_CLKREQ#: RP3.5 UH2.AT24 UL1.12
LAN_DISABLE#_R: RL1.1 RL43.1 UH2.AL27
LAN_EN: RE131.2 RL27.2 UL2.4
LAN_WAKE#: RH11.1 RH181.1 UH2.BD11
LAN_WAKE#_R: RL2.2 RL42.2 UL1.21
LANWAKE#: RH11.2 UE1.35
LCD_DBC: RH559.2 RH560.1 UH2.U35
LCD_TST: DV2.3 RV538.1 UE1.26
LCD_TST_R: JEDP1.5 RV538.2
LCD_VCC_TEST_EN: DV3.2 UE1.113
LDO1_CAP: CA19.2 HDA1.27 RA11.2
LDO2_CAP: CA22.2 HDA1.39
LDO3_CAP: CA27.1 HDA1.7
LDO_1V: PC115.1 PU100.16 PU100.17
LED1: JLED.3 QE20.6
LED2: JLED.2 QE21.3 QE23.3
LG_1.2V: PQ202.4 PU200.15
LG_3V: PQ302.4 PU300.11
LG_5V: PQ304.4 PU300.15
LG_+1.35V: PQ800.6 PQ801.6 PU800.6
LG_CHG: PQ707.4 PU700.23
LID_CL_SIO#: CE8.1 RE25.2 RE68.2 UE1.66
LID_CLOSE#: CE17.1 RE68.1 UE3.3
LINE1-L_C: CA64.2 RA48.1
LINE1-L_R: CA65.2 RA51.1
LINE1_L: CA64.1 HDA1.22
LINE1_R: CA65.1 HDA1.21
LINE1_VREFO_L: HDA1.31 RA46.1
LINE1_VREFO_R: HDA1.30 RA53.1
LX_1.0VS_VGAP: PL10V0.1 PR10V0.1 PU10V0.2 PU10V0.3
LX_1.2V: PC206.2 PL200.2 PQ201.1 PQ201.2 PQ201.3 PQ202.5 PR202.1 PU200.16
LX_1.8V: PC18V01.2 PL18V00.1 PR18V03.1 PU18V00.6 PU18V00.19 PU18V00.20
LX_1V: PC106.2 PL100.1 PR104.1 PU100.6 PU100.19 PU100.20
LX_3V: PC309.1 PL302.2 PQ301.1 PQ301.2 PQ301.3 PQ302.5 PR309.1 PU300.8
LX_5V: PC310.2 PL303.1 PQ303.1 PQ303.2 PQ303.3 PQ304.5 PR310.1 PU300.18
LX_+1.35V: PC808.2 PL801.1 PQ800.7 PQ801.7 PR805.1 PU800.8
LX_CHG: PC713.1 PL701.1 PQ705.1 PQ705.2 PQ705.3 PQ707.5 PR717.1 PU700.27
LX_GPU1: PC6102.2 PU6100.7
LX_GPU2: PC6115.2 PU6101.7
LX_GPU3: PC6129.2 PU6102.7
LX_GPU_PH1: PL6101.1 PR6027.1 PR6108.1 PU6100.11 PU6100.12 PU6100.13 PU6100.14 PU6100.15 PU6100.16 PU6100.17 PU6100.18 PU6100.19 PU6100.20 PU6100.21
LX_GPU_PH2: PL6102.1 PR6028.1 PR6115.1 PU6101.11 PU6101.12 PU6101.13 PU6101.14 PU6101.15 PU6101.16 PU6101.17 PU6101.18 PU6101.19 PU6101.20 PU6101.21
LX_GPU_PH3: PL6103.1 PR6029.1 PR6122.1 PU6102.11 PU6102.12 PU6102.13 PU6102.14 PU6102.15 PU6102.16 PU6102.17 PU6102.18 PU6102.19 PU6102.20 PU6102.21
LX_VCCIO: PC4005.2 PL4000.1 PR4002.1 PU4000.6 PU4000.19 PU4000.20
MAINPWON: RTH2.2 UTH1.7
MASK_SATA_LED#: RE132.1 UE1.56
MAX-Q_DET: RG579.1 UG9.BE4
MCARD_PCIE_SATA#: RD58.1 RH68.1 UH2.AG36
MCT0: RL19.1 TL2.24
MCT1: RL20.1 TL2.21
MCT2: RL39.1 TL2.18
MCT3: RL40.1 TL2.15
MDI0+: TL2.12 UL1.1
MDI0-: TL2.11 UL1.2
MDI1+: TL2.9 UL1.4
MDI1-: TL2.8 UL1.5
MDI2+: TL2.6 UL1.6
MDI2-: TL2.5 UL1.7
MDI3+: TL2.3 UL1.9
MDI3-: TL2.2 UL1.10
MDO0+: JLAN.1 TL2.13
MDO0-: JLAN.2 TL2.14
MDO1+: JLAN.3 TL2.16
MDO1-: JLAN.6 TL2.17
MDO2+: JLAN.4 TL2.19
MDO2-: JLAN.5 TL2.20
MDO3+: JLAN.7 TL2.22
MDO3-: JLAN.8 TL2.23
ME_FWP: RE21.1 RH18.1 UE1.80
ME_SUS_PWR_ACK: RH67.1 UH2.BD19
MEC_XTAL1: CE102.1 RE66.2 Y1.1
MEC_XTAL1_R: RE66.1 UE1.123
MEC_XTAL2: CE101.1 RE106.1 UE1.125 Y1.2
MEM_VDD_CTL: PR810.1 UG9.BH4
MEM_VREF: QG2.2 QG3.2 QG4.2 RG24.1 UG9.BD3
MIC2_VREFO: HDA1.29 RA42.1 RA43.1
MODEL_ID: CE104.1 RE124.2 RE125.2 UE1.109
MSATA_DEVSLP: RD59.2 UH2.AG42
MSCLK: JDEG1.6 RE63.2
MSDATA: JDEG1.7 RE65.2
NB_MUTE#: RE58.2 UE1.119
NC_B4: RT45.1 RT86.2 UT1.B4
NC_B5: RT46.1 UT1.B5
NC_G2: RT47.1 UT1.G2
NRB_BIT: RH92.2 UH2.BD28
NTC_LA: PH6000.1 PR6007.2 PR6008.1
NTC_LB: PC6007.2 PC6009.1 PH6000.2 PR6008.2 PR6009.2 PR6010.2 PR6011.2 PR6012.2 PR6020.1
NVVDD1_EN: CG442.1 DG7.1 PQ6000.2 PR6040.2 RG549.2
NVVDD1_ENP: PQ6000.3 PR6036.1 PU6000.36
NVVDD1_PGOOD: DG4.1 PR6061.2 PU6000.38 UG29.2
NVVDD_B+: PC6000.2 PC6103.1 PC6104.1 PC6105.1 PC6106.1 PC6110.1 PC6111.1 PC6112.1 PC6117.1 PC6118.1 PC6119.1 PC6122.1 PC6123.1 PC6124.1 PC6125.1 PC6126.1 PC6131.1 PC6132.1 PC6133.1 PC6134.1 PC6135.1 PC6136.1 PC6137.1 PC6138.1 PL6100.2 PR6006.1 PU6100.8 PU6100.9 PU6101.8 PU6101.9 PU6102.8 PU6102.9
NVVDD_ISUMN1: PL6101.3 PR6009.1
NVVDD_ISUMN2: PL6102.3 PR6010.1
NVVDD_ISUMN3: PL6103.3 PR6012.1
NVVDD_ISUMP1: PL6101.2 PR6002.1
NVVDD_ISUMP2: PL6102.2 PR6003.1
NVVDD_ISUMP3: PL6103.2 PR6004.1
NVVDD_PSI: PR6051.1 RG162.1 RG566.2
NVVDD_VCC_SENSE: PR6021.2 UG9.BK45 UG9.BM45
NVVDD_VID: PR6069.1 UG9.BD6
NVVDD_VSS_SENSE: PR6026.2 UG9.BL45 UG9.BM44
NVVDDB_B+: PC6108.1 PC6109.1 PL6100.1 PR6101.4
OVERT#: RG168.1 RG576.1 UG9.BG5
P1: PC702.1 PQ700.3 PQ701.1 PQ701.2 PQ701.3 PQ702.1 PQ702.2 PQ702.3 PQ703.1 PQ703.2 PQ703.3 PR700.2 PR710.1
P2: PQ703.5 PR703.1
P_SYS: PR728.2 PR5028.1 PU700.9
PA_USB2_RBIAS: RT43.1 UT1.H19
PANEL_BKEN_EC: RV566.1 UE1.117
PB_USB2_RBIAS: RT44.1 UT1.F19
PBAT_CHG_SMBCLK: PD3.2 PR8.2 PR731.1 RE44.1 UE1.9
PBAT_CHG_SMBDAT: PD3.3 PR10.2 PR730.1 RE43.1 UE1.8
PBAT_PRES#: CE76.1 PC12.1 PD4.2 PR12.2 PR13.1 PR723.1 UE1.29
PCH_BATLOW#: RH81.1 UH2.BD13
PCH_CPU_BCLK_N: UH1.A32 UH2.H2
PCH_CPU_BCLK_P: UH1.B31 UH2.G2
PCH_CPU_PCIBCLK_N: UH1.C36 UH2.J1
PCH_CPU_PCIBCLK_P: UH1.D35 UH2.J2
PCH_DPWROK: RH9.2 UH2.AV11
PCH_ESPI_CLK: RH168.1 UH2.BC17
PCH_ESPI_IO0: RH574.1 UH2.AT22
PCH_ESPI_IO1: RH575.1 UH2.AV22
PCH_ESPI_IO2: RH576.1 UH2.AT19
PCH_ESPI_IO3: RH577.1 UH2.BD16
PCH_ITP_PMODE: RH522.1 UH2.AT2
PCH_JTAG_TCK: JXDP1.55 RH95.2 UH2.AN3
PCH_JTAG_TDI: RH100.2 RH537.2 UH2.AP2
PCH_JTAG_TDO: RH97.2 RH539.2 UH2.AP1
PCH_JTAG_TMS: RH98.2 RH538.2 UH2.AR2
PCH_JTAGX: RH38.1 UH2.AR3
PCH_PCIE_WAKE#: RH17.1 RH114.1 UH2.BC13
PCH_PLTRST#: CH208.1 RH1.1 UH2.BB27 UH7.1 UH7.2
PCH_PLTRST#_EC: JNGFF1.44 JNGFF2.50 RE145.2 RH1.2 RH77.1 RT1.1 UG10.2 UH7.4 UL1.19 UTPM1.17
PCH_PWROK: RH94.1 UH2.AW11 UH14.4
PCH_RSMRST#: CH212.1 RH9.1 RH13.2 RH503.1 RH541.1 UE1.27
PCH_RSMRST#_R: RH503.2 UH2.BA11
PCH_RTCRST#: CH53.1 CLRP1.1 QH6.1 RH84.2 UH2.BC10
PCH_RTCX1: CH45.1 RH70.1 UH2.BC9 YH1.1
PCH_RTCX2: CH46.1 RH70.2 UH2.BD10 YH1.2
PCH_SATA_LED#: QE21.2 RH80.1 RH502.1 UH2.AD44
PCH_SMBCLK: JDIMM1.253 JDIMM2.253 JXDP1.53 QH4.1 RH27.2 U5603.1 UVGA1.30
PCH_SMBDATA: JDIMM1.254 JDIMM2.254 JXDP1.51 QH4.4 RH26.2 U5603.4 UVGA1.29
PCH_SPI1_CLK_R: RTPM5.2 UTPM1.19
PCH_SPI_CLK: RH582.2 UH2.BC31
PCH_SPI_CLK_R: RE126.2 UH8.6
PCH_SPI_CLK_R1: CH215.1 RE126.1 RH582.1 RTPM5.1
PCH_SPI_CS2#: RTPM6.1 UH2.AT31
PCH_SPI_CS2#_R: RTPM6.2 RTPM8.1 RTPM13.1 UTPM1.20
PCH_SPI_CS#: RH74.2 RH101.1 UH2.BD31
PCH_SPI_CS#_R: RH101.2 UH8.1
PCH_SPI_HOLD#: RE71.1 UH2.BD30
PCH_SPI_HOLD#_R: RE71.2 UH8.7
PCH_SPI_MISO: RTPM2.2 UTPM1.24
PCH_SPI_MOSI: RTPM4.2 UTPM1.21
PCH_SPI_SI: RE128.1 RH525.1 RTPM4.1 UH2.BB29
PCH_SPI_SI_R: RE128.2 UH8.5
PCH_SPI_SO: RE127.1 RTPM2.1 UH2.BE30
PCH_SPI_SO_R: RE127.2 UH8.2
PCH_SPI_WP#: RE129.1 RH519.2 UH2.BC29
PCH_SPI_WP#_R: RE129.2 UH8.3
PCH_SRTCRST#: CH52.1 RH83.2 UH2.BB10
PCH_SYS_PWROK_XDP: JXDP1.47 RH521.2 RH524.2 RH525.2
PCH_TRIGGER: RH167.1 UH2.AL2
PCH_TRIGGER_R: RH167.2 UH1.H23
PCH_XDP_CLK_N: JXDP1.42 UH2.L1
PCH_XDP_CLK_P: JXDP1.40 UH2.L2
PCIE_PRX_LANTX_N5: CL31.1 UH2.K19
PCIE_PRX_LANTX_N5_C: CL31.2 UL1.18
PCIE_PRX_LANTX_P5: CL30.1 UH2.L19
PCIE_PRX_LANTX_P5_C: CL30.2 UL1.17
PCIE_PRX_SSDTX_N10: JNGFF2.29 UH2.G29
PCIE_PRX_SSDTX_N11: JNGFF2.17 UH2.L31
PCIE_PRX_SSDTX_N12: JNGFF2.5 UH2.G33
PCIE_PRX_SSDTX_P10: JNGFF2.31 UH2.E29
PCIE_PRX_SSDTX_P11: JNGFF2.19 UH2.K31
PCIE_PRX_SSDTX_P12: JNGFF2.7 UH2.H33
PCIE_PRX_TBTTX_N1: CT16.1 UH2.H15
PCIE_PRX_TBTTX_N1_C: CT16.2 UT1.V22
PCIE_PRX_TBTTX_N2: CT2.1 UH2.E17
PCIE_PRX_TBTTX_N2_C: CT2.2 UT1.P22
PCIE_PRX_TBTTX_N3: CT108.1 UH2.L17
PCIE_PRX_TBTTX_N3_C: CT108.2 UT1.K22
PCIE_PRX_TBTTX_N4: CT110.1 UH2.E20
PCIE_PRX_TBTTX_N4_C: CT110.2 UT1.F22
PCIE_PRX_TBTTX_P1: CT14.1 UH2.G15
PCIE_PRX_TBTTX_P1_C: CT14.2 UT1.V23
PCIE_PRX_TBTTX_P2: CT12.1 UH2.G17
PCIE_PRX_TBTTX_P2_C: CT12.2 UT1.P23
PCIE_PRX_TBTTX_P3: CT109.1 UH2.K17
PCIE_PRX_TBTTX_P3_C: CT109.2 UT1.K23
PCIE_PRX_TBTTX_P4: CT111.1 UH2.G19
PCIE_PRX_TBTTX_P4_C: CT111.2 UT1.F23
PCIE_PRX_WLANTX_N6: JNGFF1.35 UH2.G22
PCIE_PRX_WLANTX_P6: JNGFF1.33 UH2.E22
PCIE_PTX_LANRX_N5: CL48.1 UH2.D22
PCIE_PTX_LANRX_N5_C: CL48.2 UL1.14
PCIE_PTX_LANRX_P5: CL47.1 UH2.C22
PCIE_PTX_LANRX_P5_C: CL47.2 UL1.13
PCIE_PTX_SSDRX_N10: CD45.1 UH2.C32
PCIE_PTX_SSDRX_N10_C: CD45.2 JNGFF2.35
PCIE_PTX_SSDRX_N11: CD43.1 UH2.C33
PCIE_PTX_SSDRX_N11_C: CD43.2 JNGFF2.23
PCIE_PTX_SSDRX_N12: CD37.1 UH2.B35
PCIE_PTX_SSDRX_N12_C: CD37.2 JNGFF2.11
PCIE_PTX_SSDRX_P10: CD46.1 UH2.B32
PCIE_PTX_SSDRX_P10_C: CD46.2 JNGFF2.37
PCIE_PTX_SSDRX_P11: CD44.1 UH2.B33
PCIE_PTX_SSDRX_P11_C: CD44.2 JNGFF2.25
PCIE_PTX_SSDRX_P12: CD42.1 UH2.A35
PCIE_PTX_SSDRX_P12_C: CD42.2 JNGFF2.13
PCIE_PTX_TBTRX_N1: CT15.1 UH2.A16
PCIE_PTX_TBTRX_N1_C: CT15.2 UT1.Y22
PCIE_PTX_TBTRX_N2: CT13.1 UH2.B19
PCIE_PTX_TBTRX_N2_C: CT13.2 UT1.T22
PCIE_PTX_TBTRX_N3: CT18.1 UH2.B20
PCIE_PTX_TBTRX_N3_C: CT18.2 UT1.M22
PCIE_PTX_TBTRX_N4: CT21.1 UH2.B21
PCIE_PTX_TBTRX_N4_C: CT21.2 UT1.H22
PCIE_PTX_TBTRX_P1: CT3.1 UH2.B16
PCIE_PTX_TBTRX_P1_C: CT3.2 UT1.Y23
PCIE_PTX_TBTRX_P2: CT1.1 UH2.C19
PCIE_PTX_TBTRX_P2_C: CT1.2 UT1.T23
PCIE_PTX_TBTRX_P3: CT4.1 UH2.C20
PCIE_PTX_TBTRX_P3_C: CT4.2 UT1.M23
PCIE_PTX_TBTRX_P4: CT5.1 UH2.A21
PCIE_PTX_TBTRX_P4_C: CT5.2 UT1.H23
PCIE_PTX_WLANRX_N6: CN20.1 UH2.B22
PCIE_PTX_WLANRX_P6: CN21.1 UH2.A23
PCIE_PTX_WLANRX_RE_N6: CN20.2 JNGFF1.29
PCIE_PTX_WLANRX_RE_P6: CN21.2 JNGFF1.27
PCIE_RBIAS: RT3.1 UT1.N16
PCIE_RCOMPN: RH108.1 UH2.B18
PCIE_RCOMPP: RH108.2 UH2.C17
PCIE_WAKE#: JNGFF1.47 RH114.2 RL2.1 RT10.2 UE1.4
PD_EE_CLK: RT123.1 UT4.A3
PD_EE_CLK_R: RT123.2 UT5.6
PD_EE_CS_N: RT126.1 UT4.B3 UT5.1
PD_EE_DI: UT4.B4 UT5.5
PD_EE_DO: RT125.1 UT4.A4 UT5.2
PD_EE_HOLD#: RT128.1 UT5.7
PD_EE_WP#: RT127.1 UT5.3
PD_I2C_INT#: RT120.1 UT4.B6
PD_I2C_SCL_R: RT57.2 RT60.2 RT118.2 UT4.B5
PD_I2C_SDA_R: RT58.2 RT59.2 RT119.2 UT4.A5
PD_UART: RT62.1 UT4.E2 UT4.F2
PECI: RH138.1 UH2.AL3
PECI_EC: RE17.2 RH138.2 RH190.1
PECI_EC_R: RH190.2 UH1.BT34
PEG_GTX_C_HRX_N0: CG516.1 UH1.E10
PEG_GTX_C_HRX_N1: CG513.1 UH1.E11
PEG_GTX_C_HRX_N2: CG25.1 UH1.E12
PEG_GTX_C_HRX_N3: CG27.1 UH1.E13
PEG_GTX_C_HRX_N4: CG29.1 UH1.E14
PEG_GTX_C_HRX_N5: CG31.1 UH1.E15
PEG_GTX_C_HRX_N6: CG33.1 UH1.E16
PEG_GTX_C_HRX_N7: CG36.1 UH1.E17
PEG_GTX_C_HRX_N8: CG489.1 UH1.F18
PEG_GTX_C_HRX_N9: CG490.1 UH1.D19
PEG_GTX_C_HRX_N10: CG492.1 UH1.F20
PEG_GTX_C_HRX_N11: CG494.1 UH1.D21
PEG_GTX_C_HRX_N12: CG496.1 UH1.F22
PEG_GTX_C_HRX_N13: CG498.1 UH1.D23
PEG_GTX_C_HRX_N14: CG500.1 UH1.F24
PEG_GTX_C_HRX_N15: CG502.1 UH1.D25
PEG_GTX_C_HRX_P0: CG519.1 UH1.F10
PEG_GTX_C_HRX_P1: CG506.1 UH1.D11
PEG_GTX_C_HRX_P2: CG518.1 UH1.F12
PEG_GTX_C_HRX_P3: CG26.1 UH1.D13
PEG_GTX_C_HRX_P4: CG28.1 UH1.F14
PEG_GTX_C_HRX_P5: CG30.1 UH1.D15
PEG_GTX_C_HRX_P6: CG32.1 UH1.F16
PEG_GTX_C_HRX_P7: CG35.1 UH1.D17
PEG_GTX_C_HRX_P8: CG488.1 UH1.E18
PEG_GTX_C_HRX_P9: CG491.1 UH1.E19
PEG_GTX_C_HRX_P10: CG493.1 UH1.E20
PEG_GTX_C_HRX_P11: CG495.1 UH1.E21
PEG_GTX_C_HRX_P12: CG497.1 UH1.E22
PEG_GTX_C_HRX_P13: CG499.1 UH1.E23
PEG_GTX_C_HRX_P14: CG501.1 UH1.E24
PEG_GTX_C_HRX_P15: CG503.1 UH1.E25
PEG_GTX_HRX_N0: CG516.2 UG9.BH26
PEG_GTX_HRX_N1: CG513.2 UG9.BE26
PEG_GTX_HRX_N2: CG25.2 UG9.BG27
PEG_GTX_HRX_N3: CG27.2 UG9.BH29
PEG_GTX_HRX_N4: CG29.2 UG9.BE29
PEG_GTX_HRX_N5: CG31.2 UG9.BG30
PEG_GTX_HRX_N6: CG33.2 UG9.BH32
PEG_GTX_HRX_N7: CG36.2 UG9.BE32
PEG_GTX_HRX_N8: CG489.2 UG9.BG33
PEG_GTX_HRX_N9: CG490.2 UG9.BH35
PEG_GTX_HRX_N10: CG492.2 UG9.BE35
PEG_GTX_HRX_N11: CG494.2 UG9.BG36
PEG_GTX_HRX_N12: CG496.2 UG9.BH38
PEG_GTX_HRX_N13: CG498.2 UG9.BE38
PEG_GTX_HRX_N14: CG500.2 UG9.BG39
PEG_GTX_HRX_N15: CG502.2 UG9.BG41
PEG_GTX_HRX_P0: CG519.2 UG9.BG26
PEG_GTX_HRX_P1: CG506.2 UG9.BF26
PEG_GTX_HRX_P2: CG518.2 UG9.BF27
PEG_GTX_HRX_P3: CG26.2 UG9.BG29
PEG_GTX_HRX_P4: CG28.2 UG9.BF29
PEG_GTX_HRX_P5: CG30.2 UG9.BF30
PEG_GTX_HRX_P6: CG32.2 UG9.BG32
PEG_GTX_HRX_P7: CG35.2 UG9.BF32
PEG_GTX_HRX_P8: CG488.2 UG9.BF33
PEG_GTX_HRX_P9: CG491.2 UG9.BG35
PEG_GTX_HRX_P10: CG493.2 UG9.BF35
PEG_GTX_HRX_P11: CG495.2 UG9.BF36
PEG_GTX_HRX_P12: CG497.2 UG9.BG38
PEG_GTX_HRX_P13: CG499.2 UG9.BF38
PEG_GTX_HRX_P14: CG501.2 UG9.BF39
PEG_GTX_HRX_P15: CG503.2 UG9.BH41
PEG_HTX_C_GRX_N0: CH36.2 UG9.BK27
PEG_HTX_C_GRX_N1: CH34.2 UG9.BL29
PEG_HTX_C_GRX_N2: CH32.2 UG9.BM30
PEG_HTX_C_GRX_N3: CH30.2 UG9.BK30
PEG_HTX_C_GRX_N4: CH28.2 UG9.BL32
PEG_HTX_C_GRX_N5: CH26.2 UG9.BM33
PEG_HTX_C_GRX_N6: CH24.2 UG9.BK33
PEG_HTX_C_GRX_N7: CH22.2 UG9.BL35
PEG_HTX_C_GRX_N8: CH20.2 UG9.BM36
PEG_HTX_C_GRX_N9: CH18.2 UG9.BK36
PEG_HTX_C_GRX_N10: CH16.2 UG9.BL38
PEG_HTX_C_GRX_N11: CH14.2 UG9.BM39
PEG_HTX_C_GRX_N12: CH12.2 UG9.BK39
PEG_HTX_C_GRX_N13: CH10.2 UG9.BL41
PEG_HTX_C_GRX_N14: CH8.2 UG9.BM42
PEG_HTX_C_GRX_N15: CH6.2 UG9.BK42
PEG_HTX_C_GRX_P0: CH35.2 UG9.BL27
PEG_HTX_C_GRX_P1: CH33.2 UG9.BK29
PEG_HTX_C_GRX_P2: CH31.2 UG9.BM29
PEG_HTX_C_GRX_P3: CH29.2 UG9.BL30
PEG_HTX_C_GRX_P4: CH27.2 UG9.BK32
PEG_HTX_C_GRX_P5: CH25.2 UG9.BM32
PEG_HTX_C_GRX_P6: CH23.2 UG9.BL33
PEG_HTX_C_GRX_P7: CH21.2 UG9.BK35
PEG_HTX_C_GRX_P8: CH19.2 UG9.BM35
PEG_HTX_C_GRX_P9: CH17.2 UG9.BL36
PEG_HTX_C_GRX_P10: CH15.2 UG9.BK38
PEG_HTX_C_GRX_P11: CH13.2 UG9.BM38
PEG_HTX_C_GRX_P12: CH11.2 UG9.BL39
PEG_HTX_C_GRX_P13: CH9.2 UG9.BK41
PEG_HTX_C_GRX_P14: CH7.2 UG9.BM41
PEG_HTX_C_GRX_P15: CH5.2 UG9.BL42
PEG_HTX_GRX_N0: CH36.1 UH1.B10
PEG_HTX_GRX_N1: CH34.1 UH1.B11
PEG_HTX_GRX_N2: CH32.1 UH1.B12
PEG_HTX_GRX_N3: CH30.1 UH1.B13
PEG_HTX_GRX_N4: CH28.1 UH1.B14
PEG_HTX_GRX_N5: CH26.1 UH1.B15
PEG_HTX_GRX_N6: CH24.1 UH1.B16
PEG_HTX_GRX_N7: CH22.1 UH1.B17
PEG_HTX_GRX_N8: CH20.1 UH1.C18
PEG_HTX_GRX_N9: CH18.1 UH1.A19
PEG_HTX_GRX_N10: CH16.1 UH1.C20
PEG_HTX_GRX_N11: CH14.1 UH1.A21
PEG_HTX_GRX_N12: CH12.1 UH1.C22
PEG_HTX_GRX_N13: CH10.1 UH1.A23
PEG_HTX_GRX_N14: CH8.1 UH1.C24
PEG_HTX_GRX_N15: CH6.1 UH1.A25
PEG_HTX_GRX_P0: CH35.1 UH1.C10
PEG_HTX_GRX_P1: CH33.1 UH1.A11
PEG_HTX_GRX_P2: CH31.1 UH1.C12
PEG_HTX_GRX_P3: CH29.1 UH1.A13
PEG_HTX_GRX_P4: CH27.1 UH1.C14
PEG_HTX_GRX_P5: CH25.1 UH1.A15
PEG_HTX_GRX_P6: CH23.1 UH1.C16
PEG_HTX_GRX_P7: CH21.1 UH1.A17
PEG_HTX_GRX_P8: CH19.1 UH1.B18
PEG_HTX_GRX_P9: CH17.1 UH1.B19
PEG_HTX_GRX_P10: CH15.1 UH1.B20
PEG_HTX_GRX_P11: CH13.1 UH1.B21
PEG_HTX_GRX_P12: CH11.1 UH1.B22
PEG_HTX_GRX_P13: CH9.1 UH1.B23
PEG_HTX_GRX_P14: CH7.1 UH1.B24
PEG_HTX_GRX_P15: CH5.1 UH1.B25
PEG_RCOMP: RH24.2 UH1.G2
PEX_CLKREQ#: QG510.3 RG163.1 UG9.BL26
PEX_TERMP: RG23.2 UG9.BL44
PEX_VDD_EN: PR10V4.1 QG509.2 UG31.4
PEX_VDD_EN_U: CG482.1 DG10.2 RG550.2 UG31.2
PHASE_ID1: RH547.2 RH548.1 UH2.AU43
PHASE_ID2: RH549.2 RH550.1 UH2.AT43
PIRQA#: RH546.1 UH2.AW17
PLTRST_CPU#: RH523.1 UH1.BP35 UH2.AK2
POL1_SCL: RVGA6.1 UVGA1.9
POL1_SDA: RVGA5.1 UVGA1.10
POWER_SW#_MB: D5225.2 JPW.4 RE47.2 SW5.1
POWER_SW_IN#: CE12.1 RE31.2 RE47.1 UE1.127
PQ5_G: PC12.2 PQ5.2 PR21.2
PQ6A_D: PQ6.6 PR15.2
PQ6A_G: PQ6.2 PQ6.3 PR16.1 PR22.2
PQ6B_G: PC13.1 PQ6.5 PR20.2
PQ700_G: PQ700.2 PR700.1 PR701.2
PQ701_G: PQ701.4 PR702.1
PQ702_G: PQ702.4 PR704.1
PQ703_S: PC703.2 PL701.2 PQ704.1 PQ704.2 PQ704.3 PR708.1 PR716.1
PQ704_G: PC703.1 PQ704.4 PR707.1
PQ707_D: PQ706.1 PR713.2
PQ8203B_G: PQ6000.5 PQ6000.6 PR6034.2
PRIM_PWRGD: RE133.1 RE149.1 RE150.1 UE1.30
PRIM_PWRGD_R: PR103.1 PR314.1 PU18V00.9 PU300.7 RE133.2
PROC_DETECT#: RH89.1 UH2.Y44
PROCHOT: RE27.2 UE1.83 UE6.2
PROCHOT_CHG: PR729.2 PU700.10
PROJECT_ID1: RH557.2 RH558.1 UH2.L44
PROJECT_ID2: RH561.2 RH562.1 UH2.L43
PS_ID: PR1.2 PR2.1 UE1.36
PSID: PD1.2 PJPDC1.1 PL3.2
PSID-0: PL3.1 PQ1.1 PR3.2
PSID-1: PQ2.2 PR3.1 PR5.2
PSID-3: PQ1.3 PR1.1
PTP_DIS#: RE57.2 UE1.90
PTP_DIS#_R: JTP.3 RE57.1 RE123.2
PTP_INT#: DH1.1 QE13.1 RE61.2
PTP_INT#_R: JTP.4 QE13.3 RE87.2
PWM1: PR6041.1 PU6000.11
PWM1_GT: PR5202.1 PU5000.12
PWM1_VCORE: PR5102.1 PU5000.25
PWM2: PR6045.1 PU6000.10
PWM2_GT: PR5213.1 PU5000.13
PWM2_VCORE: PR5114.1 PU5000.26
PWM3: PR6053.2 PU6000.9
PWM3_VCORE: PR5126.1 PU5000.27
PWM_SA: PR5224.2 PU5000.35
PWR_DEBUG#_XDP: JXDP1.45 RH526.2 RH528.1
PWRBTN#_XDP: CH206.1 JXDP1.41 RH529.2 RH530.1
REFADJ: PR6039.1 PU6000.40
REFIN: PR6043.1 PR6052.1 PU6000.1
REFIN_1: PC6015.1 PR6039.2 PR6043.2 PR6064.2
REFIN_2: PR6052.2 PR6062.1
REGN_CHG: PC714.1 PR28.1 PR718.1 PU700.24
REMOTE1+: CTH3.1 CTH4.1 QTH1.1 QTH1.2 UTH1.2
REMOTE1-: CTH3.2 CTH4.2 QTH1.3 UTH1.3
REMOTE2+: CT114.1 CTH5.1 QTH2.1 QTH2.2 UTH1.4
REMOTE2-: CT114.2 CTH5.2 QTH2.3 UTH1.5
RESET_N: RT102.1 UT4.F11
RESET_OUT#: RE135.1 UE1.73
REXT_8713: RI23.2 UI3.7
RF_+1.35V: PR804.1 PU800.5
RING2: HDA1.17 LA19.1 RA43.2
RING2_R: CA43.1 DA4.2 JHP1.4 LA19.2
ROM_CS#: RG74.2 UG9.BJ4 UG13.1
ROM_SCLK: RG75.2 RG86.1 RG89.2 UG9.BK3
ROM_SI: RG77.2 RG84.1 RG87.2 UG9.BK2
ROM_SO: RG76.1 RG85.1 RG88.2 UG9.BK4
RREF: RI3.1 UR1.2
RTCRST_ON: QH6.2 RH571.1 UE1.31
RTD3_CIO_PWR_EN: RT16.2 UH2.R39
RTD3_CIO_PWR_EN_R: RT16.1 RT36.1 UT1.F1
RTD3_USB_PWR_EN_R: RT37.1 UT1.D4
RTM_CSCL: RP48.1 UP2.29
RTM_CSDA: RP49.1 UP2.28
RTM_DCIN_ENB: RP33.2 RP39.2 UP2.3
RTM_EQ: RP34.2 RP40.2 UP2.5
RTM_HDMI_ID: RP36.2 RP43.2 UP2.32
RTM_I2C_ADDR: RP38.2 RP41.2 UP2.31
RTM_PDB: RP44.2 UP2.4
RTM_PRE: RP37.2 RP42.2 UP2.27
RTM_RST#: CP27.1 RP35.2 UP2.35
RUNPWROK: RE62.1 UE1.48
SATA_LED_EN: QE21.5 QE21.6 RE132.2 RE146.2 RE152.1
SATA_PRX_DTX_N1B: CS25.1 UH2.D39
SATA_PRX_DTX_N1B_RC: CS25.2 JHDD1.5
SATA_PRX_DTX_P1B: CS26.1 UH2.E37
SATA_PRX_DTX_P1B_RC: CS26.2 JHDD1.6
SATA_PRX_SSDTX_N0A: JNGFF2.43 UH2.G31
SATA_PRX_SSDTX_P0A: JNGFF2.41 UH2.H31
SATA_PTX_DRX_N1B: CS27.1 UH2.B38
SATA_PTX_DRX_N1B_RC: CS27.2 JHDD1.3
SATA_PTX_DRX_P1B: CS28.1 UH2.C38
SATA_PTX_DRX_P1B_RC: CS28.2 JHDD1.2
SATA_PTX_SSDRX_N0A: CD53.1 UH2.C31
SATA_PTX_SSDRX_N0A_C: CD53.2 JNGFF2.47
SATA_PTX_SSDRX_P0A: CD51.1 UH2.B31
SATA_PTX_SSDRX_P0A_C: CD51.2 JNGFF2.49
SCL_CHG: PR731.2 PU700.12
SD_CD#: JREAD1.10 UR1.10
SD_CLK: CR4.1 JREAD1.5 RI53.2
SD_CLK_R: RI53.1 UR1.18
SD_CMD: JREAD1.2 UR1.20
SD_D0: JREAD1.7 UR1.13
SD_D1: JREAD1.8 UR1.12
SD_D2: JREAD1.9 UR1.23
SD_D3: JREAD1.1 UR1.22
SD_WP: JREAD1.11 UR1.11
SDA_CHG: PR730.2 PU700.11
SDREG: CR7.2 UR1.16
SIO_EXT_SCI#: RH10.2 UH2.AV29
SIO_EXT_WAKE#: RH91.2 UE1.116 UH2.AN44
SIO_PWRBTN#: RH530.2 UE1.52 UH2.AT13
SIO_SLP_S0#: RTPM3.1 RTPM11.1 UH2.BC26
SIO_SLP_S0#_R: RTPM3.2 UTPM1.29
SIO_SLP_S3#: DZ2.1 PR210.1 QV2.2 QZ2.2 RT110.2 RZ108.1 RZ112.1 UH2.AW15 UZ1.3 UZ1.5 UZ9.4 UZ16.3 UZ21.2
SIO_SLP_S3#_AR: RT30.2 RT110.1 UT1.D2
SIO_SLP_S4#: DZ1.1 PR25V00.1 RZ102.1 RZ111.1 UH2.BD15
SIO_SLP_S5#: T4938.1(TP-1) UH2.BA13
SLEEVE: HDA1.18 LA22.1 RA42.2
SLEEVE_R: CA42.1 DA4.3 JHP1.3 LA22.2
SM_PG_CTRL: PR211.1 RH93.2 UC1.4
SMBALERT#: RH66.2 UH2.BB41
SMBCLK: QH4.6 RH21.2 UH2.AW44
SMBDATA: QH4.3 RH22.2 UH2.BB43
SML0_SMBCLK: RH62.2 UH2.AY44
SML0_SMBDATA: RH63.2 UH2.BB39
SML0ALERT#: RH64.2 UH2.BA40
SML1ALERT#: RH65.2 UH2.AT27
SNB_1.0VS_VGAP: PC10V5.1 PR10V0.2
SNB_GPU1: PC6113.1 PR6108.2
SNB_GPU2: PC6127.1 PR6115.2
SNB_GPU3: PC6141.1 PR6122.2
SNB_VCCIO: PC4013.1 PR4002.2
SNUB_1.2V: PC213.1 PR202.2
SNUB_1VALWP: PC111.1 PR104.2
SNUB_3V: PC313.1 PR309.2
SNUB_5V: PC314.1 PR310.2
SNUB_+1.35V: PC812.1 PR805.2
SNUB_CHG: PC719.1 PR717.2
SPKR: D1.3 RH82.2 UH2.BD26
SRN_CHG: PR726.1 PU700.19
SRP_CHG: PR724.1 PU700.20
SS: PC6002.2 PR6018.1 PU6000.28
SSD_CLK_REQ#: JNGFF2.52 RP3.8 UH2.AT33
SSD_LED#: JNGFF2.10 RH502.2
SSD_PCIE_WAKE#: JNGFF2.54 RD8.1
STRAP0: RG78.1 RG90.2 UG9.BL3
STRAP1: RG79.1 RG91.2 UG9.BL4
STRAP2: RG80.1 RG92.2 UG9.BM4
STRAP3: RG81.1 RG93.2 UG9.BM5
STRAP4: RG82.1 RG94.2 UG9.BK5
STRAP5: RG83.1 RG95.2 UG9.BJ5
SUNB_1.8V: PC18V10.1 PR18V03.2
SUSCLK: RD9.2 RE106.2 RN1.2 UH2.AN15
SUSCLK_R: JNGFF1.42 RN1.1
SYS_PEX_RST_MON#: DG9.2 RG21.1 RG537.2 UG9.BE2
SYS_PWROK: RH524.1 RH581.2 UE1.28 UH2.AY1
SYS_RESET#: CH209.1 RH193.1 RH532.2 UH2.AW1
SYSPWR_PRES: RE20.1 RE22.1 UE1.120
TB_STAT#_CHG: PQ706.2 PR722.1 PU700.16
TBT_A_AUX_N: CT44.2 UT1.W15
TBT_A_AUX_N_C: CT44.1 RT70.2 UT4.J2
TBT_A_AUX_P: CT43.2 UT1.Y15
TBT_A_AUX_P_C: CT43.1 RT73.1 UT4.J1
TBT_A_USB20_L_NB: DT10.4 DT10.7 JUSBC1.A7 LT3.3
TBT_A_USB20_L_NT: DT10.2 DT10.8 JUSBC1.B7 LT2.2
TBT_A_USB20_L_PB: DT10.5 DT10.6 JUSBC1.A6 LT3.2
TBT_A_USB20_L_PT: DT10.1 DT10.9 JUSBC1.B6 LT2.3
TBT_A_USB20_N: UT1.D20 UT4.K5
TBT_A_USB20_NB: LT3.4 UT4.L7
TBT_A_USB20_NT: LT2.1 UT4.L6
TBT_A_USB20_P: UT1.E20 UT4.L5
TBT_A_USB20_PB: LT3.1 UT4.K7
TBT_A_USB20_PT: LT2.4 UT4.K6
TBT_CIO_PLUG_EVENT#: RT29.2 UH2.U41 UT1.W2
TBT_CLK_REQ#: RT2.2 RT24.1 UH2.BE25
TBT_CLK_REQ#_R: RT2.1 RT20.2 UT1.AC5
TBT_CONFIG: RT112.2 RT113.1 UT4.H6
TBT_EE_CLK: RT101.1 UT1.AB4
TBT_EE_CLK_R: RT101.2 UT2.6
TBT_EE_CS_N: RT49.1 UT1.AC3 UT2.1
TBT_EE_DI: UT1.AB3 UT2.5
TBT_EE_DO: RT50.1 UT1.AC4 UT2.2
TBT_EE_WP_N: RT48.2 UT1.V1 UT2.3
TBT_FORCE_PWR: RT13.2 UH2.P43
TBT_FORCE_PWR_R: RT13.1 RT35.1 RT94.2 UT1.H4
TBT_HDMI_DDC_CLK: T9.1(TP-1) UT1.Y2
TBT_HDMI_DDC_DATA: T7.1(TP-1) UT1.Y1
TBT_HOLD_N: RT51.2 UT2.7
TBT_I2C_SCL: RT27.2 UT1.U2 UT4.D2
TBT_I2C_SDA: RT26.2 UT1.U1 UT4.D1
TBT_PCIE_WAKE_N: RT10.1 RT28.2 UT1.W1
TBT_RBIAS: RT25.1 UT1.H6
TBT_RESET_N: RT80.2 RT102.2 RT121.1 UT1.F4
TBT_RESET_N_EC#: RE151.2 RT121.2 RT122.2 UE1.97
TBT_RSENSE: RT25.2 UT1.J6
TBT_RST#_R: RT1.2 UT1.L4
TBT_SRC_AUX_N: T26.1(TP-1) UT1.Y19
TBT_SRC_AUX_P: T25.1(TP-1) UT1.W19
TBT_SRC_CFG1: RT11.1 UT1.AA1
TBT_SRC_HPD: RT4.1 UT1.G1
TBT_SVR_IND: LT1.1 UT1.C1 UT1.C2 UT1.D1
TBT_TCK: RT7.2 UT1.T4
TBT_TDI: RT9.2 UT1.Y4
TBT_TDO: RT6.2 UT1.W4
TBT_TEST_EN: RT17.1 UT1.E1
TBT_TEST_PWG: RT18.1 UT1.AB5
TBT_TMS: RT8.2 UT1.V4
TBT_TMU_CLK_OUT: RT34.1 UT1.V2
TBT_XTAL_25_IN: RT116.1 UT1.D22
TBT_XTAL_25_IN_R: CT38.1 RT116.2 YT1.3
TBT_XTAL_25_OUT: RT117.1 UT1.D23
TBT_XTAL_25_OUT_R: CT37.1 RT117.2 YT1.1
TBTA_CC1: CT112.1 DT11.3 JUSBC1.B5 UT4.L9
TBTA_CC2: CT113.1 DT11.2 JUSBC1.A5 UT4.L10
TBTA_DEBUG1: RT71.1 RT118.1 UT4.L2
TBTA_DEBUG2: RT72.1 RT119.1 UT4.K2
TBTA_DIG_AUD_N: RT69.1 RT115.2 UT4.K3
TBTA_DIG_AUD_P: RT68.1 RT114.2 UT4.L3
TBTA_HPD: RT41.1 UT1.M4 UT4.C10
TBTA_HRESET: RE148.1 RT108.1 UT4.D6
TBTA_HRESET_EC: RE148.2 UE1.96
TBTA_I2C_INT: RT32.2 UT1.J4 UT4.C1
TBTA_LDO_BMC: CT98.1 UT4.E1
TBTA_LSRX: RT42.1 RT115.1 UT1.A4 UT4.K4
TBTA_LSTX: RT21.2 RT40.1 RT114.1 UT1.A5 UT4.L4
TBTA_MRESET: RT63.1 RT122.1 UT4.E11
TBTA_ROSC: RT75.1 UT4.G2
TBTA_SBU1: DT13.1 JUSBC1.B8 UT4.K8
TBTA_SBU2: DT14.1 JUSBC1.A8 UT4.L8
TBTB_I2C_INT: RT33.2 UT1.E2
THERMDA: UT1.AB23 UT1.AC23
THM_SML1_CLK: QTH3.4 RTH3.2 RTH6.1 UTH1.10
THM_SML1_DATA: QTH3.1 RTH4.2 RTH5.1 UTH1.9
TMDS_T_TX0N: RV557.2 RV612.1 UP2.16
TMDS_T_TX0N_R: JHDMI1.9 RV612.2
TMDS_T_TX0P: RV557.1 RV611.1 UP2.17
TMDS_T_TX0P_R: JHDMI1.7 RV611.2
TMDS_T_TX1N: RV562.2 RV614.1 UP2.19
TMDS_T_TX1N_R: JHDMI1.6 RV614.2
TMDS_T_TX1P: RV562.1 RV613.1 UP2.20
TMDS_T_TX1P_R: JHDMI1.4 RV613.2
TMDS_T_TX2N: RV565.2 RV616.1 UP2.22
TMDS_T_TX2N_R: JHDMI1.3 RV616.2
TMDS_T_TX2P: RV565.1 RV615.1 UP2.23
TMDS_T_TX2P_R: JHDMI1.1 RV615.2
TMDS_T_TXCN: CP23.2 RV554.2 RV610.1 UP2.13
TMDS_T_TXCN_R: JHDMI1.12 RV610.2
TMDS_T_TXCP: CP23.1 RV554.1 RV609.1 UP2.14
TMDS_T_TXCP_R: JHDMI1.10 RV609.2
TON_1.2V: PR207.2 PU200.9
TOUCH_SCREEN_PD#: DI1.1 RH69.1 UH2.AE44
TOUCHPAD_INTR#: DH1.2 RH179.1 UH2.BC23
TP_EN#: RZ32.1 UE1.49 UE4.4
TP_WAKE_KBC#: RE53.1 RE61.1 UE1.33
TPM_LPM#: QTPM1.1 RTPM9.1 RTPM11.2 UTPM1.3
TPM_PIRQ#: RH568.2 RTPM12.1 UH2.AN38
TPM_PIRQ#_R: RTPM12.2 UTPM1.18
TRIP_+1.35V: PR802.2 PU800.2
TS_EN: DI1.2 JEDP1.12
TYPEC_SMBCLK: RE140.1 RT60.1 UE1.91
TYPEC_SMBDA: RE139.1 RT59.1 UE1.89
UART_2_CRXD_DTXD: RH160.2 RN6.2 UH2.AR45
UART_2_CRXD_DTXD_R: JNGFF1.22 RN6.1
UART_2_CTXD_DRXD: RH159.2 RN7.2 UH2.AR39
UART_2_CTXD_DRXD_R: JNGFF1.24 RN7.1 RN8.2
UG_1.2V: PQ201.4 PU200.17
UG_3V: PQ301.4 PU300.10
UG_5V: PQ303.4 PU300.16
UG_+1.35V: PQ800.1 PQ801.1 PU800.9
UG_CHG: PQ705.4 PU700.26
UPD1_ALERT: RE141.1 RT120.2 UE1.32
USB2_COMP: RH109.1 UH2.AG3
USB2_ID: RH113.1 UH2.AG2
