# Allegro board Dell_Inspiron_15_7577_Compal_CKA50_CKF50_LA_E992P_Rev_1_0_BoardView.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
RG161  10K_0201_5%  [R_0201]  195.64 75.02 0 bottom
RG162  10K_0201_5%  [R_0201]  207.1 75.46 180 bottom
RG163  10K_0201_5%  [R_0201]  197.31 95.09 180 top
RG164  10K_0201_5%  [R_0201]  206.49 76.64 270 bottom
RG165  10K_0201_5%  [R_0201]  201.97 70.73 90 bottom
RG166  10K_0201_5%  [R_0201]  192.7 70.35 90 bottom
RG167  1.8K_0402_1%  [R_0402]  209.34 73.56 180 bottom
RG168  10K_0201_5%  [R_0201]  203.87 82.55 270 top
RG502  10K_0201_5%  [R_0201]  203.02 77.38 0 bottom
RG504  10K_0201_5%  [R_0201]  206.07 77.37 180 top
RG505  10K_0201_5%  [R_0201]  227.1 62.61 270 top
RG506  10K_0201_5%  [R_0201]  222.93 64.5 90 top
RG509  10K_0402_5%  [R_0402]  217.32 65.37 0 top
RG510  10_0402_1%  [R_0402]  217.63 61.44 0 top
RG511  10K_0402_5%  [R_0402]  214.58 65.37 0 top
RG512  10_0402_1%  [R_0402]  215.53 61.44 0 top
RG513  10K_0402_5%  [R_0402]  212.76 65.37 180 top
RG514  51_0402_5%  [R_0402]  214.14 61.45 180 top
RG515  10K_0402_5%  [R_0402]  212.13 81.13 270 top
RG516  10K_0201_5%  [R_0201]  220.97 62.32 0 top
RG518  10K_0201_5%  [R_0201]  197.78 92.27 270 bottom
RG522  10K_0201_5%  [R_0201]  207.37 81.47 270 top
RG523  40.2_0402_1%  [R_0402]  217.46 133.12 180 top
RG524  40.2_0402_1%  [R_0402]  212.82 134.07 0 top
RG525  40.2_0402_1%  [R_0402]  257.73 121.82 90 top
RG526  40.2_0402_1%  [R_0402]  247.94 134.07 0 bottom
RG527  40.2_0402_1%  [R_0402]  257.48 87.08 90 top
RG528  40.2_0402_1%  [R_0402]  256.07 91.02 180 top
RG529  0_0201_5%  [R_0201]  222.33 77.12 180 bottom
RG537  0_0201_5%  [R_0201]  200.95 75.81 90 bottom
RG543  10K_0402_5%  [R_0402]  195.49 60.59 90 top
RG544  10_0402_1%  [R_0402]  197.13 60.67 0 top
RG545  68K_0402_1%  [R_0402]  203.92 64.8 0 top
RG546  10K_0402_5%  [R_0402]  211.95 82.01 180 top
RG549  100K_0402_5%  [R_0402]  224.4 59.46 0 top
RG550  39K_0402_1%  [R_0402]  116.65 86.24 180 bottom
RG551  0_0201_5%  [R_0201]  210.99 60.91 180 top
RG553  0_0201_5%  [R_0201]  218.75 58.87 270 top
RG554  0_0201_5%  [R_0201]  225.49 62.88 180 top
RG557  10K_0402_5%  [R_0402]  208.57 78.46 270 top
RG562  100K_0402_5%  [R_0402]  200.27 75.97 180 bottom
RG566  0_0201_5%  [R_0201]  207.07 76.67 270 bottom
RG571  10K_0402_5%  [R_0402]  191.2 62.67 315 top
RG572  10K_0201_5%  [R_0201]  202.41 61.97 90 top
RG573  100K_0402_5%  [R_0402]  199.11 61.32 270 top
RG575  0_0402_5%  [R_0402]  199.11 62.18 90 top
RG576  0_0402_5%  [R_0402]  207.23 80.04 0 top
RG577  0_0402_5%  [R_0402]  194.22 64.66 90 top
RG578  0_0402_5%  [R_0402]  195.11 64.66 90 top
RG579  10K_0201_5%  [R_0201]  204.8 77.38 180 bottom
RG580  0_0402_5%  [R_0402]  213.13 78.13 0 top
RG582  51_0402_5%  [R_0402]  241.52 75.53 0 bottom
RG583  10K_0402_5%  [R_0402]  242.75 71.59 180 bottom
RG584  0_0402_5%  [R_0402]  206.71 82.78 0 top
RH1  0_0402_5%  [R_0402]  283.92 18.19 270 top
RH9  0_0402_5%  [R0402_0OHM]  294.35 33.45 180 top
RH10  10K_0402_5%  [R_0402]  281.34 30.24 90 top
RH11  0_0402_5%  [R0402_0OHM]  292.14 22.39 0 bottom
RH13  100K_0402_5%  [R_0402]  296.51 33.56 180 top
RH17  1K_0402_5%  [R_0402]  289.55 24.81 270 bottom
RH18  1K_0402_5%  [R_0402]  299.89 25.19 90 bottom
RH20  0_0402_5%  [R_0402]  278.8 43.39 0 top
RH21  1K_0402_5%  [R_0402]  267.49 28.03 90 top
RH22  1K_0402_5%  [R_0402]  271.95 31.41 270 top
RH24  24.9_0402_1%  [R_0402]  173.55 70.65 0 bottom
RH26  1K_0402_5%  [R_0402]  266.46 30.09 0 top
RH27  1K_0402_5%  [R_0402]  272.4 28.86 180 top
RH28  0_0402_5%  [R0402_0OHM]  158.04 108.99 180 bottom
RH29  100_0402_1%  [R_0402]  158.9 109.18 0 bottom
RH30  24.9_0402_1%  [R_0402]  177.2 103.72 180 top
RH31  0_0402_5%  [R0402_0OHM]  169.61 107.67 90 bottom
RH32  0_0402_5%  [R0402_0OHM]  158.04 108.11 180 bottom
RH33  100_0402_1%  [R_0402]  158.9 108.27 0 bottom
RH38  0_0402_5%  [R0402_0OHM]  136.49 96.64 0 bottom
RH41  100_0402_1%  [R_0402]  168.72 107.67 90 bottom
RH45  2_0402_1%  [R_0402]  112.55 57.37 90 top
RH46  2_0402_1%  [R_0402]  221.13 35.12 270 top
RH56  51_0402_5%  [R_0402]  137 100.33 0 top
RH57  49.9_0402_1%  [R_0402]  136.49 93.09 0 bottom
RH58  49.9_0402_1%  [R_0402]  136.49 94.87 0 bottom
RH59  49.9_0402_1%  [R_0402]  137.41 93.98 180 bottom
RH60  51_0402_5%  [R_0402]  134.21 99.95 0 bottom
RH61  51_0402_5%  [R_0402]  136.49 95.75 0 bottom
RH62  499_0402_1%  [R_0402]  270.8 30.43 90 bottom
RH63  499_0402_1%  [R_0402]  274.66 30.51 0 top
RH64  2.2K_0402_5%  [R_0402]  279.21 31.87 90 top
RH65  150K_0402_5%  [R_0402]  283.08 36.6 270 top
RH66  2.2K_0402_5%  [R_0402]  274.66 31.4 0 top
RH67  1M_0402_5%  [R_0402]  287.92 27.12 270 top
RH68  10K_0402_5%  [R_0402]  270.75 41.81 180 top
RH69  10K_0402_5%  [R_0402]  272.78 38.32 180 bottom
RH70  10M_0402_5%  [R_0402]  293.55 27.31 180 bottom
RH71  2.7K_0402_1%  [R_0402]  297.23 48.12 90 top
RH72  1M_0402_5%  [R_0402]  300.01 52.17 270 bottom
RH74  4.7K_0402_5%  [R_0402]  300.2 39.89 90 top
RH77  100K_0402_5%  [R_0402]  286.86 18.81 90 bottom
RH79  10K_0402_5%  [R_0402]  270.7 46.36 180 bottom
RH80  10K_0402_5%  [R_0402]  272.78 39.21 180 bottom
RH81  10K_0402_5%  [R_0402]  288.65 25.06 270 bottom
RH82  2.2K_0402_5%  [R_0402]  285.07 26.37 90 bottom
RH83  20K_0402_5%  [R_0402]  295.16 26.5 90 top
RH84  20K_0402_5%  [R_0402]  293.38 26.5 90 top
RH86  10K_0402_5%  [R_0402]  271.95 39.02 0 top
RH89  0_0402_5%  [R_0402]  270.75 42.7 180 top
RH91  10K_0402_5%  [R_0402]  271.87 37.37 0 bottom
RH92  2.2K_0402_5%  [R_0402]  284.16 26.37 90 bottom
RH93  220K_0402_5%  [R_0402]  132.59 86.28 0 bottom
RH94  10K_0402_5%  [R_0402]  307.77 29.58 0 top
RH95  51_0402_5%  [R_0402]  194.48 57.04 90 top
RH97  51_0402_5%  [R_0402]  302.11 33.78 270 top
RH98  51_0402_5%  [R_0402]  300.33 33.78 270 top
RH100  51_0402_5%  [R_0402]  301.22 33.78 270 top
RH101  0_0402_5%  [R0402_0OHM]  300.2 41.86 90 top
RH103  0_0402_5%  [R0402_0OHM]  306.95 31.52 0 top
RH105  0_0402_5%  [R0402_0OHM]  309 31.52 0 top
RH107  0_0402_5%  [R_0402]  168.81 85.69 0 top
RH108  100_0402_1%  [R_0402]  288.51 54.32 0 bottom
RH109  113_0402_1%  [R_0402]  299 38.89 180 top
RH112  1K_0402_5%  [R_0402]  292.63 40.12 90 top
RH113  1K_0402_5%  [R_0402]  301.94 36.21 270 bottom
RH114  0_0402_5%  [R0402_0OHM]  292.14 21.5 0 bottom
RH119  2.2K_0402_5%  [R_0402]  271.95 36.1 0 top
RH120  2.2K_0402_5%  [R_0402]  271.87 35.49 0 bottom
RH121  0_0603_5%  [R0603_0OHM]  301.16 39.4 0 top
RH122  0_0603_5%  [R0603_0OHM]  304.14 46.83 180 bottom
RH123  0_0603_5%  [R0603_0OHM]  292.9 36.44 0 top
RH124  0_0603_5%  [R0603_0OHM]  278.21 53.5 180 top
RH125  100K_0402_5%  [R_0402]  290.64 23.98 180 top
RH127  10K_0402_5%  [R_0402]  280.38 36.88 270 top
RH128  10K_0402_5%  [R_0402]  286.97 27.28 270 bottom
RH129  10K_0402_5%  [R_0402]  272.86 38.06 180 top
RH130  2.2K_0402_5%  [R_0402]  282.18 36.6 270 top
RH137  0_0603_5%  [R0603_0OHM]  292.82 21.43 180 top
RH138  13_0402_5%  [R_0402]  300.52 34.33 0 bottom
RH141  2.2K_0402_5%  [R_0402]  296.09 31.41 0 top
RH143  1M_0402_5%  [R_0402]  294.27 27.42 270 top
RH144  49.9_0402_1%  [R_0402]  137 99.44 0 top
RH145  20_0402_5%  [R_0402]  183.03 98.52 0 top
RH146  30_0402_5%  [R_0402]  301.44 33.45 180 bottom
RH147  30_0402_5%  [R_0402]  301.45 32.55 180 bottom
RH148  121_0402_1%  [R_0402]  173.55 71.52 0 bottom
RH149  75_0402_1%  [R_0402]  173.56 73.3 0 bottom
RH150  100_0402_1%  [R_0402]  173.56 72.4 0 bottom
RH151  100_0402_5%  [R_0402]  138.02 94.74 0 top
RH152  56.2_0402_1%  [R_0402]  137.08 94.66 90 top
RH153  220_0402_5%  [R_0402]  138.02 95.75 0 top
RH154  60.4_0402_1%  [R_0402]  180.8 80.93 90 top
RH155  20_0402_5%  [R_0402]  135.47 102.03 0 bottom
RH156  51_0402_5%  [R_0402]  134.21 97.91 0 bottom
RH158  499_0402_1%  [R_0402]  136.49 99.06 0 bottom
RH159  49.9K_0402_1%  [R_0402]  271.95 37.11 0 top
RH160  49.9K_0402_1%  [R_0402]  271.87 36.41 0 bottom
RH163  1K_0402_5%  [R_0402]  175.27 99.97 180 top
RH164  1K_0402_5%  [R_0402]  182.74 80.93 180 top
RH165  1K_0402_5%  [R_0402]  134.21 99.06 0 bottom
RH166  49.9_0402_1%  [R_0402]  136.49 97.79 0 bottom
RH167  30_0402_5%  [R_0402]  183.95 96.74 180 top
RH168  22_0402_5%  [R_0402]  288.2 27.02 270 bottom
RH179  10K_0402_5%  [R_0402]  281.39 29.15 180 top
RH180  100K_0402_5%  [R_0402]  306.95 32.44 0 top
RH181  10K_0402_5%  [R_0402]  290.49 24.81 270 bottom
RH183  1K_0402_5%  [R_0402]  141.27 95.32 270 top
RH184  1K_0402_5%  [R_0402]  140.3 95.7 270 top
RH185  1K_0402_5%  [R_0402]  137.41 90.36 180 bottom
RH186  1K_0402_5%  [R_0402]  137.41 89.4 180 bottom
RH187  1K_0402_5%  [R_0402]  137.41 91.31 180 bottom
RH188  1K_0402_5%  [R_0402]  137.41 92.2 180 bottom
RH189  30_0402_5%  [R_0402]  299.72 36.31 270 bottom
RH190  0_0402_5%  [R0402_0OHM]  135.47 103.05 0 bottom
RH191  620_0402_5%  [R_0402]  300.62 36.31 270 bottom
RH192  30_0402_5%  [R_0402]  183.95 97.63 180 top
RH193  8.2K_0402_5%  [R_0402]  299.94 29.09 270 bottom
RH196  0_0402_5%  [R_0402]  285.54 37.25 270 top
RH197  100_0402_1%  [R_0402]  159.82 110.33 180 bottom
RH198  0_0402_5%  [R0402_0OHM]  158.04 110.33 180 bottom
RH201  100_0402_1%  [R_0402]  171.52 107.67 90 bottom
RH202  0_0402_5%  [R0402_0OHM]  170.5 107.67 90 bottom
RH203  100_0402_1%  [R_0402]  158.84 107.03 0 bottom
RH204  0_0402_5%  [R0402_0OHM]  157.98 107.03 180 bottom
RH206  1K_0402_1%  [R_0402]  115.43 58.51 180 top
RH207  1K_0402_1%  [R_0402]  224.06 35.12 270 top
RH209  1K_0402_1%  [R_0402]  113.57 58.29 270 top
RH210  1K_0402_1%  [R_0402]  222.05 34.19 90 top
RH211  24.9_0402_1%  [R_0402]  110.67 58.26 180 top
RH212  24.9_0402_1%  [R_0402]  220.08 33.24 180 top
RH493  0_0603_5%  [R0603_0OHM]  268.66 30.76 90 bottom
RH496  51_0402_5%  [R_0402]  135.17 95.93 90 bottom
RH497  51_0402_5%  [R_0402]  137 97.66 0 top
RH502  0_0402_5%  [R0402_0OHM]  226.96 54.81 0 top
RH503  0_0402_5%  [R0402_0OHM]  298.06 24.67 180 top
RH504  100K_0402_5%  [R_0402]  218.91 56.51 90 top
RH505  100K_0402_5%  [R_0402]  217.9 56.51 90 top
RH506  100K_0402_5%  [R_0402]  281.04 10.89 180 top
RH513  0_0402_5%  [R0402_0OHM]  173.6 87.78 180 top
RH514  0_0402_5%  [R0402_0OHM]  173.6 88.66 180 top
RH515  100_0402_1%  [R_0402]  175.2 88.26 0 top
RH516  100_0402_1%  [R_0402]  175.2 87.37 0 top
RH517  1K_0402_5%  [R_0402]  211.98 59.65 270 top
RH518  0_0402_5%  [R_0402]  211.09 59.65 270 top
RH519  1K_0402_5%  [R_0402]  196.69 65.56 0 top
RH520  2.2K_0402_5%  [R_0402]  190.79 64.72 90 top
RH521  2.2K_0402_5%  [R_0402]  195.43 57.04 90 top
RH522  0_0402_5%  [R_0402]  191.68 64.72 90 top
RH523  1K_0402_5%  [R_0402]  192.57 64.72 90 top
RH524  0_0402_5%  [R_0402]  196.38 57.04 90 top
RH525  1K_0402_5%  [R_0402]  197.33 57.04 90 top
RH526  150_0402_5%  [R_0402]  198.29 57.04 90 top
RH528  1K_0402_5%  [R_0402]  199.24 57.95 270 top
RH529  1K_0402_5%  [R_0402]  204 57.04 90 top
RH530  0_0402_5%  [R0402_0OHM]  201.14 57.95 270 top
RH531  1K_0402_5%  [R_0402]  97.18 72.16 0 top
RH532  0_0402_5%  [R0402_0OHM]  200.46 65.56 180 top
RH533  0_0402_5%  [R0402_0OHM]  137 98.55 0 top
RH534  0_0402_5%  [R0402_0OHM]  137 101.22 0 top
RH535  0_0402_5%  [R0402_0OHM]  133.72 95.53 90 bottom
RH536  0_0402_5%  [R0402_0OHM]  132.63 99.9 90 bottom
RH537  0_0402_5%  [R0402_0OHM]  301.87 29.97 90 bottom
RH538  0_0402_5%  [R0402_0OHM]  300.98 30.18 90 bottom
RH539  0_0402_5%  [R0402_0OHM]  302.76 29.97 90 bottom
RH540  1K_0402_5%  [R_0402]  197.6 64.61 180 top
RH541  1K_0402_5%  [R_0402]  202.1 57.04 90 top
RH542  1K_0402_5%  [R_0402]  203.05 57.04 90 top
RH543  0_0402_5%  [R0402_0OHM]  291.11 32.92 0 top
RH544  0_0402_5%  [R0402_0OHM]  284.07 43.35 270 top
RH545  100K_0402_5%  [R_0402]  282.23 30.24 90 top
RH546  10K_0402_5%  [R_0402]  288.66 33.92 90 top
RH547  10K_0402_5%  [R_0402]  271.71 33.47 0 top
RH548  10K_0402_5%  [R_0402]  272.62 34.36 180 top
RH549  10K_0402_5%  [R_0402]  270.79 32.73 0 bottom
RH550  10K_0402_5%  [R_0402]  271.7 33.62 180 bottom
RH551  10K_0402_5%  [R_0402]  269.84 40.92 0 top
RH552  10K_0402_5%  [R_0402]  270.75 40.03 180 top
RH553  10K_0402_5%  [R_0402]  269.84 38.26 0 top
RH554  10K_0402_5%  [R_0402]  270.75 39.14 180 top
RH557  10K_0402_5%  [R_0402]  269.79 51.21 0 bottom
RH558  10K_0402_5%  [R_0402]  270.7 50.32 180 bottom
RH559  10K_0402_5%  [R_0402]  278.97 46.38 0 top
RH560  10K_0402_5%  [R_0402]  280.35 45.49 180 top
RH561  10K_0402_5%  [R_0402]  269.79 48.42 0 bottom
RH562  10K_0402_5%  [R_0402]  270.7 49.37 180 bottom
RH567  100K_0402_5%  [R_0402]  271.87 34.56 0 bottom
RH568  10K_0402_5%  [R_0402]  280.16 31.87 90 top
RH569  33_0201_5%  [R_0201]  300.01 53.53 270 bottom
RH570  33_0201_5%  [R_0201]  299.95 49.9 90 bottom
RH571  100K_0402_5%  [R_0402]  289.85 11.14 90 top
RH572  33_0402_5%  [R_0402]  296.66 26.98 180 bottom
RH573  10K_0402_5%  [R_0402]  286.08 27.28 270 bottom
RH574  15_0402_5%  [R_0402]  287.03 27.13 270 top
RH575  15_0402_5%  [R_0402]  286.14 27.13 270 top
RH576  15_0402_5%  [R_0402]  285.26 27.13 270 top
RH577  15_0402_5%  [R_0402]  288.84 27.09 270 top
RH578  8.2K_0402_5%  [R_0402]  312.92 7.65 180 bottom
RH579  2.2K_0402_5%  [R_0402]  300.84 26.29 270 bottom
RH580  2.2K_0402_5%  [R_0402]  301.79 26.27 270 bottom
RH581  100K_0402_5%  [R_0402]  296.38 32.35 0 top
RH582  15_0402_5%  [R_0402]  283.6 23.65 90 bottom
RI1  0_0402_5%  [R_0402-NPM]  83.15 42.13 0 bottom
RI2  0_0402_5%  [R_0402-NPM]  83.15 41.24 0 bottom
RI3  6.19K_0402_1%  [R_0402]  12.05 30.76 180 bottom
RI9  100K_0402_5%  [R_0402]  8.55 32.97 90 bottom
RI10  100K_0402_5%  [R_0402]  9.44 32.97 90 bottom
RI11  10K_0402_5%  [R_0402]  14.39 46.95 180 bottom
RI12  10K_0402_5%  [R_0402]  14.39 46.07 180 bottom
RI15  10K_0402_5%  [R_0402]  13.48 52.29 0 bottom
RI16  4.7K_0402_5%  [R_0402]  13.48 47.84 0 bottom
RI17  10K_0402_5%  [R_0402]  5.39 51.27 180 bottom
RI18  4.7K_0402_5%  [R_0402]  5.39 47.46 180 bottom
RI19  4.7K_0402_5%  [R_0402]  13.48 49.62 0 bottom
RI20  4.7K_0402_5%  [R_0402]  13.44 45.13 270 bottom
RI21  4.7K_0402_5%  [R_0402]  5.39 48.42 180 bottom
RI22  4.7K_0402_5%  [R_0402]  5.39 52.23 180 bottom
RI23  4.99K_0402_1%~D  [R_0402]  11.6 44.21 90 bottom
RI24  4.7K_0402_5%  [R_0402]  5.39 45.56 180 bottom
RI25  0_0402_5%~D  [R_0402]  10.71 54.33 270 bottom
RI30  100K_0402_5%  [R_0402]  11.22 32.97 90 bottom
RI45  22.1K_0402_1%  [R_0402]  12.91 38.57 0 bottom
RI46  10K_0402_5%  [R_0402]  14.39 48.73 180 bottom
RI47  10K_0402_5%  [R_0402]  4.47 50.32 0 bottom
RI48  10K_0402_5%  [R_0402]  4.47 46.51 0 bottom
RI49  22.1K_0402_1%  [R_0402]  12.91 39.46 0 bottom
RI51  1M_0402_5%  [R_0402]  10.33 32.97 90 bottom
RI52  0_0603_5%  [R0603_0OHM]  19.58 34.51 180 bottom
RI53  22_0402_5%  [R_0402]  14.52 24.23 270 bottom
RI54  10K_0402_5%  [R_0402]  14.39 50.51 180 bottom
RI55  10K_0402_5%  [R_0402]  14.39 51.4 180 bottom
RI56  4.7K_0402_5%  [R_0402]  4.47 49.37 0 bottom
RI57  4.7K_0402_5%  [R_0402]  12.49 44.21 90 bottom
RI58  4.7K_0402_5%  [R_0402]  4.47 53.18 0 bottom
RI59  0_0603_5%  [R0603_0OHM]  17.18 50.96 180 bottom
RI65  0_0402_5%  [R_0402-NPM]  18.33 57.48 90 bottom
RI66  0_0402_5%  [R_0402-NPM]  17.31 57.48 90 bottom
RI67  0_0603_5%  [R_0603]  17.18 52.16 180 bottom
RL1  0_0402_5%  [R_0402]  28.17 38.5 90 bottom
RL2  0_0402_5%  [R0402_0OHM]  27.22 38.5 90 bottom
RL19  75_0402_5%  [R_0402]  30.96 73.36 90 top
RL20  75_0402_5%  [R_0402]  27.98 73.36 90 top
RL27  100K_0402_5%  [R_0402]  22.3 55.72 0 bottom
RL30  15K_0402_1%  [R_0402]  27.06 41.57 270 bottom
RL31  2.49K_0402_1%  [R_0402]  21.87 48.35 0 bottom
RL33  1K_0402_5%  [R_0402]  29.06 38.5 90 bottom
RL39  75_0402_5%  [R_0402]  24.99 73.36 90 top
RL40  75_0402_5%  [R_0402]  22.01 73.36 90 top
RL41  100K_0402_5%  [R_0402]  22.29 50.21 90 bottom
RL42  1K_0402_5%  [R_0402]  25.43 39.4 0 bottom
RL43  0_0402_5%  [R0402_0OHM]  22.54 40.64 90 bottom
RM3  2.2K_0402_5%  [R_0402]  365.85 85.5 0 bottom
RM4  2.2K_0402_5%  [R_0402]  365.85 86.39 0 bottom
RM22  0_0603_5%  [R0603_0OHM]  342.49 36.41 270 top
RN1  0_0402_5%  [R_0402]  341.59 42.76 0 top
RN2  0_0402_5%  [R_0402]  343.64 35.85 270 top
RN4  100K_0402_5%  [R_0402]  341.59 41.87 0 top
RN5  0_0402_5%  [R_0402]  342.51 40.92 180 top
RN6  0_0402_5%  [R_0402]  331.29 35.26 180 top
RN7  0_0402_5%  [R_0402]  341.59 39.14 0 top
RN8  0_0402_5%  [R0402_0OHM]  342.51 40.03 180 top
RP3  10K_0804_8P4R_5%  [RP_0804_8P4R]  280.85 26.75 0 top
RP8  10K_0804_8P4R_5%  [RP_0804_8P4R]  272.52 44.78 180 bottom
RP9  0_0402_5%  [R_0402]  194.67 62.71 225 top
RP10  0_0402_5%  [R_0402]  194.04 63.34 225 top
RP11  0_0402_5%  [R_0402]  341.53 50.13 0 top
RP15  33_0804_8P4R_5%  [RP_0804_8P4R]  297.91 24.03 90 bottom
RP16  10K_0804_8P4R_5%  [RP_0804_8P4R]  272.52 41.93 180 bottom
RP24  47K_0402_5%  [R_0402]  329.22 42.01 270 bottom
RP25  47K_0402_5%  [R_0402]  330.11 42.01 270 bottom
RP28  0_0603_5%  [R0603_0OHM]  329.99 52.86 0 top
RP31  0_0603_5%  [R_0603]  338.43 37.24 180 top
RP32  4.99K_0402_1%  [R_0402]  328.41 42.07 180 top
RP33  10K_0402_5%  [R_0402]  340.17 43.21 180 top
RP34  10K_0402_5%  [R_0402]  342.58 47.96 180 top
RP35  10K_0402_5%  [R_0402]  327.5 43.84 0 top
RP36  10K_0402_5%  [R_0402]  328.33 41.1 90 bottom
RP37  10K_0402_5%  [R_0402]  327.24 52.54 0 top
RP38  10K_0402_5%  [R_0402]  327.5 44.73 0 top
RP39  10K_0402_5%  [R_0402]  340.15 44.16 180 top
RP40  10K_0402_5%  [R_0402]  342.56 47.08 180 top
RP41  10K_0402_5%  [R_0402]  327.5 45.62 0 top
RP42  10K_0402_5%  [R_0402]  327.24 53.43 0 top
RP43  10K_0402_5%  [R_0402]  327.45 41.1 90 bottom
RP44  10K_0402_5%  [R_0402]  342.56 46.19 180 top
RP45  1K_0402_5%  [R_0402]  331.83 40.36 270 top
RP46  150K_0402_5%  [R_0402]  331.7 51.79 270 top
RP48  10K_0402_5%  [R_0402]  328.16 50.76 180 top
RP49  10K_0402_5%  [R_0402]  328.16 51.65 180 top
RPE2  10K_0804_8P4R_5%  [RP_0804_8P4R]  311.07 20.35 270 bottom
RPE3  10K_0804_8P4R_5%  [RP_0804_8P4R]  308.79 23.72 270 bottom
RPE4  100K_0804_8P4R_5%  [RP_0804_8P4R]  295.12 18.3 0 top
RPE5  100K_0804_8P4R_5%  [RP_0804_8P4R]  296.11 6.61 0 top
RPE6  100K_0804_8P4R_5%  [RP_0804_8P4R]  311.38 12.74 0 bottom
RPE7  100K_0804_8P4R_5%  [RP_0804_8P4R]  305.74 12.03 270 bottom
RPT1  100K_0804_8P4R_5%  [RP_0804_8P4R]  358.23 42.07 270 top
RS1  100K_0402_5%  [R_0402]  253.71 22.22 0 bottom
RS39  100K_0402_5%  [R_0402]  255.44 27.05 270 bottom
RS40  100K_0402_5%  [R_0402]  265.83 11.13 0 top
RS41  100K_0402_5%  [R_0402]  268.52 11.13 180 top
RT1  0_0201_5%  [R0201_0OHM]  160.83 88.39 0 top
RT2  0_0201_5%  [R0201_0OHM]  359.83 45.66 270 bottom
RT3  3.01K_0201_1%  [R_0201]  353.06 53.13 0 top
RT4  1M_0201_1%  [R_0201]  362.78 54.7 0 bottom
RT5  14K_0402_1%  [R_0402]  357.75 52.86 90 top
RT6  10K_0201_5%  [R_0201]  368.24 77.56 0 bottom
RT7  10K_0201_5%  [R_0201]  365.38 76.29 0 bottom
RT8  10K_0201_5%  [R_0201]  359.51 50 90 top
RT9  10K_0201_5%  [R_0201]  365.38 76.93 0 bottom
RT10  0_0201_5%  [R0201_0OHM]  364.08 51.17 90 bottom
RT11  1M_0201_1%  [R_0201]  364.06 50.46 180 bottom
RT13  0_0201_5%  [R0201_0OHM]  358.91 55.2 270 top
RT16  0_0201_5%  [R0201_0OHM]  361.57 56.35 0 bottom
RT17  100_0201_5%  [R_0201]  361.89 57.62 0 bottom
RT18  100_0201_5%  [R_0201]  359.13 46.61 0 bottom
RT19  14K_0402_1%  [R_0402]  352.29 49.56 180 top
RT20  10K_0201_5%  [R_0201]  358.59 45.68 0 bottom
RT21  10K_0201_5%  [R_0201]  357.23 61.79 270 bottom
RT24  10K_0201_5%  [R_0201]  359.17 45.05 180 bottom
RT25  4.75K_0402_0.5%  [R_0402]  356.42 57.26 270 top
RT26  3.3K_0201_5%  [R_0201]  363.36 52.8 180 bottom
RT27  3.3K_0201_5%  [R_0201]  363.36 53.43 180 bottom
RT28  10K_0201_5%  [R_0201]  363.45 51.76 270 bottom
RT29  10K_0201_5%  [R_0201]  362.47 51.53 180 bottom
RT30  10K_0201_5%  [R_0201]  362.47 58.19 180 bottom
RT31  10K_0201_5%  [R_0201]  362.15 55.08 180 bottom
RT32  10K_0201_5%  [R_0201]  357.57 58.58 0 top
RT33  10K_0201_5%  [R_0201]  362.15 56.99 180 bottom
RT34  100K_0201_5%  [R_0201]  361.89 52.16 0 bottom
RT35  100K_0201_5%  [R_0201]  359.51 55.21 270 top
RT36  100K_0201_5%  [R_0201]  361.57 55.72 0 bottom
RT37  100K_0201_5%  [R_0201]  359.26 56.9 270 top
RT38  100K_0201_5%  [R_0201]  361.89 49.6 0 bottom
RT39  100K_0201_5%  [R_0201]  357.71 49.46 0 top
RT40  1M_0201_1%  [R_0201]  357.86 61.2 90 bottom
RT41  100K_0201_5%  [R_0201]  358.94 53.79 270 top
RT42  1M_0201_1%  [R_0201]  358.48 61.15 90 bottom
RT43  499_0201_1%  [R_0201]  352.22 57.75 45 top
RT44  499_0201_1%  [R_0201]  351.81 58.16 45 top
RT45  100K_0201_5%  [R_0201]  359.13 61.2 90 bottom
RT46  100K_0201_5%  [R_0201]  356.59 61.2 90 bottom
RT47  100K_0201_5%  [R_0201]  362.78 54.07 0 bottom
RT48  3.3K_0402_5%  [R_0402]  363.51 46.37 90 bottom
RT49  2.2K_0402_5%  [R_0402]  360.83 47.28 0 bottom
RT50  2.2K_0402_5%  [R_0402]  362.62 46.37 90 bottom
RT51  3.3K_0402_5%  [R_0402]  361.75 45.43 180 bottom
RT53  0_0402_5%  [R0402_0OHM]  352.91 70.5 90 bottom
RT57  10K_0201_5%  [R_0201]  362.62 65.78 90 bottom
RT58  10K_0201_5%  [R_0201]  359.51 65.78 90 bottom
RT59  0_0201_5%  [R0201_0OHM]  360.15 65.78 90 bottom
RT60  0_0201_5%  [R0201_0OHM]  363.26 65.78 90 bottom
RT61  0_0201_5%  [R_0201]  355.68 72.35 180 bottom
RT62  100K_0201_5%  [R_0201]  356.36 68.7 180 bottom
RT63  100K_0201_5%  [R_0201]  366.08 68.99 0 bottom
RT66  10K_0201_5%  [R_0201]  354.13 66.91 180 bottom
RT67  10K_0201_5%  [R_0201]  354.13 66.27 180 bottom
RT68  100K_0201_5%  [R_0201]  362.59 76.42 0 bottom
RT69  100K_0201_5%  [R_0201]  362.59 77.05 0 bottom
RT70  100K_0201_5%  [R_0201]  352.81 73.37 0 bottom
RT71  100K_0201_5%  [R_0201]  353.39 74.7 180 bottom
RT72  100K_0201_5%  [R_0201]  353.39 74.01 180 bottom
RT73  100K_0201_5%  [R_0201]  353.39 72.61 180 bottom
RT74  0_0201_5%  [R0201_0OHM]  366.66 70.39 180 bottom
RT75  15K_0402_0.1%  [R_0402]  355.72 71.4 270 bottom
RT76  100K_0201_5%  [R_0201]  353.23 42.74 270 top
RT77  100K_0201_5%  [R_0201]  351.32 42.74 270 top
RT78  100K_0201_5%  [R_0201]  352.59 42.74 270 top
RT79  100K_0201_5%  [R_0201]  351.96 42.74 270 top
RT80  10K_0201_5%  [R_0201]  360.4 61.79 270 bottom
RT83  0_0201_5%  [R0201_0OHM]  355.78 69.29 0 bottom
RT86  10K_0201_5%  [R_0201]  359.77 61.79 270 bottom
RT94  10K_0201_5%  [R_0201]  357.61 57.03 270 top
RT95  0_0603_5%  [R_0603]  358.53 61.31 0 top
RT97  0_0402_5%  [R0402_0OHM]  357.61 61.7 270 top
RT101  15_0201_1%  [R_0201]  359.54 47.34 0 bottom
RT102  0_0201_5%  [R_0201]  366.08 69.81 0 bottom
RT108  0_0201_5%  [R0201_0OHM]  360.33 68.23 270 top
RT110  0_0201_5%  [R0201_0OHM]  361.89 58.77 0 bottom
RT111  1M_0201_1%  [R_0201]  366.08 68.42 0 bottom
RT112  10K_0201_5%  [R_0201]  354.41 68.67 180 bottom
RT113  100K_0201_5%  [R_0201]  352.67 68.12 225 bottom
RT114  0_0201_5%  [R_0201]  363.17 75.78 180 bottom
RT115  0_0201_5%  [R_0201]  363.17 77.69 180 bottom
RT116  33_0201_5%  [R_0201]  347.89 59.87 90 bottom
RT117  33_0201_5%  [R_0201]  347.26 59.87 90 bottom
RT118  0_0402_5%  [R_0402]  361.86 65.36 90 bottom
RT119  0_0402_5%  [R_0402]  360.97 65.36 90 bottom
RT120  0_0402_5%  [R0402_0OHM]  364.02 66.21 270 bottom
RT121  0_0201_5%  [R0201_0OHM]  361.04 61.18 90 bottom
RT122  0_0201_5%  [R_0201]  367.32 68.99 0 bottom
RT123  15_0201_1%  [R_0201]  358.8 67.64 0 top
RT124  0_0603_5%  [R_0603]  359.7 40.29 90 top
RT125  3.3K_0201_5%  [R_0201]  361.44 89.25 270 bottom
RT126  3.3K_0201_5%  [R_0201]  362.36 89.25 270 bottom
RT127  3.3K_0201_5%  [R_0201]  360.58 89.25 270 bottom
RT128  3.3K_0201_5%  [R_0201]  361.93 98.82 0 bottom
RTH1  7.87K_0402_1%  [R_0402]  161.42 87.02 180 top
RTH2  10K_0402_5%  [R_0402]  94.51 65.5 0 bottom
RTH3  10K_0402_5%  [R_0402]  96.61 76.1 0 top
RTH4  10K_0402_5%  [R_0402]  92.99 73.85 0 top
RTH5  0_0402_5%  [R_0402]  94.78 73.68 90 top
RTH6  0_0402_5%  [R_0402]  98.53 74.59 270 top
RTPM1  0_0402_5%  [R_0402]  291.77 9.74 180 bottom
RTPM2  33_0402_5%  [R_0402]  293.47 19.73 270 bottom
RTPM3  0_0402_5%  [R_0402]  295.87 14.39 180 bottom
RTPM4  33_0402_5%  [R_0402]  291.57 19.73 270 bottom
RTPM5  33_0402_5%  [R_0402]  288.71 19.73 270 bottom
RTPM6  0_0402_5%  [R0402_0OHM]  290.62 19.73 270 bottom
RTPM7  10K_0402_5%  [R_0402]  294.96 15.41 0 bottom
RTPM8  100_0402_5%  [R_0402]  289.66 18.81 90 bottom
RTPM9  10K_0402_5%  [R_0402]  288.9 9.76 270 top
RTPM10  0_0402_5%  [R_0402]  291 7.95 90 bottom
RTPM11  0_0402_5%  [R0402_0OHM]  296.79 14.26 270 bottom
RTPM12  0_0402_5%  [R_0402]  287.76 19.73 270 bottom
RTPM13  4.7K_0402_5%  [R_0402]  285.79 16.36 270 bottom
RTPM14  0_0402_5%  [R_0402]  294.81 10.85 0 bottom
RTPM15  0_0402_5%  [R_0402]  285.87 11.19 0 bottom
RV535  1M_0402_5%  [R_0402]  83.68 36.22 180 bottom
RV536  100K_0402_5%  [R_0402]  88.82 49.81 180 bottom
RV537  100K_0402_5%  [R_0402]  88.82 48.86 180 bottom
RV538  0_0402_5%  [R0402_0OHM]  92.3 48.62 270 top
RV545  0_0402_5%  [R_0402-NPM]  291.89 57.14 90 top
RV547  0_0402_5%  [R_0402-NPM]  291 57.14 90 top
RV551  100K_0402_5%  [R_0402]  88.82 50.76 180 bottom
RV554  300_0402_5%  [R_0402]  364.07 85.82 0 top
RV557  300_0402_5%  [R_0402]  366.1 85.82 0 top
RV562  300_0402_5%  [R_0402]  367.06 92.93 0 top
RV565  300_0402_5%  [R_0402]  365.28 92.93 0 top
RV566  0_0402_5%  [R0402_0OHM]  93.51 50.14 270 top
RV570  120K_0402_5%  [R_0402]  81.89 37.12 270 bottom
RV609  2.2_0402_1%  [R_0402]  364.08 86.95 90 top
RV610  2.2_0402_1%  [R_0402]  364.97 86.95 90 top
RV611  2.2_0402_1%  [R_0402]  366.12 86.95 90 top
RV612  2.2_0402_1%  [R_0402]  367.01 86.95 90 top
RV613  2.2_0402_1%  [R_0402]  367.07 94.06 90 top
RV614  2.2_0402_1%  [R_0402]  367.96 94.06 90 top
RV615  2.2_0402_1%  [R_0402]  365.29 94.06 90 top
RV616  2.2_0402_1%  [R_0402]  366.18 94.06 90 top
RVGA1  0_0603_5%  [R0603_0OHM]  315.25 34.25 90 top
RVGA2  0_0603_5%  [R0603_0OHM]  313.92 34.25 90 top
RVGA3  100K_0402_5%  [R_0402]  318.05 31.98 270 top
RVGA4  100K_0402_5%  [R_0402]  315.38 31.98 270 top
RVGA5  4.7K_0402_5%  [R_0402]  324.35 38 0 top
RVGA6  4.7K_0402_5%  [R_0402]  324.35 37.11 0 top
RVGA7  2.2K_0402_5%  [R_0402]  371.34 116.8 180 bottom
RVGA8  2.2K_0402_5%  [R_0402]  371.34 120.68 180 bottom
RVGA9  0_0402_5%  [R0402_0OHM]  315.3 38.06 0 top
RVGA10  100K_0402_5%  [R_0402]  315.3 37.11 0 top
RVGA11  75_0402_1%  [R_0402]  319.36 42.47 90 top
RVGA12  75_0402_1%  [R_0402]  318.07 42.47 90 top
RVGA13  75_0402_1%  [R_0402]  316.55 42.47 90 top
RVGA14  47_0402_5%  [R_0402]  370.55 119.08 270 top
RVGA15  47_0402_5%  [R_0402]  370.66 114.76 270 top
RVGA16  4.7K_0402_5%  [R_0402]  324.35 38.89 0 top
RW3  300_0402_5%  [R_0402]  282.6 8.6 0 top
RW4  0_0402_5%  [R0402_0OHM]  226.4 25.03 180 bottom
RZ26  0_0603_5%  [R0603_0OHM]  87.92 51.91 0 bottom
RZ32  100K_0402_5%  [R_0402]  135.17 26.5 90 bottom
RZ33  100K_0402_5%  [R_0402]  135.17 28.27 90 bottom
RZ34  0_0805_5%  [R0805_0OHM]  249.43 31.33 180 bottom
RZ35  0_0603_5%  [R0603_0OHM]  88.24 52.16 0 top
RZ36  0_0805_5%  [R0805_0OHM]  285.23 20.73 180 top
RZ37  0_0603_5%  [R0603_0OHM]  286.3 67.66 0 top
RZ40  100K_0402_5%  [R_0402]  89.78 57.43 180 top
RZ48  0_0603_5%  [R0603_0OHM]  186.22 103.47 0 bottom
RZ66  0_0603_5%  [R0603_0OHM]  183.49 100.93 180 top
RZ67  0_0603_5%  [R0603_0OHM]  225.46 53.84 180 top
RZ70  0_0805_5%  [R0805_0OHM]  285.54 46.54 270 top
RZ71  100K_0402_5%  [R_0402]  297.68 26.55 0 top
RZ96  100K_0402_5%  [R_0402]  276.77 36.6 180 top
RZ102  100K_0402_5%  [R_0402]  242.3 25.43 180 top
RZ108  150K_0402_5%  [R_0402]  277.23 65.81 180 top
RZ111  0_0402_5%  [R_0402]  217.45 54.41 0 top
RZ112  0_0402_5%  [R_0402]  220.16 54.41 180 top
SW5  SKRBAAE010_4P  [SW_SKRBAAE010_4P]  283.7 12.05 90 top
T2  PAD  [TPC12]  269.6 45.21 180 bottom
T3  PAD~D  [TPC12]  323.86 13.36 0 bottom
T6  PAD~D  [TPC12]  204.26 85.95 0 top
T7  PAD~D  [TPC12]  361.33 50.59 180 bottom
T8  PAD  [TPC12]  269.98 29.3 180 bottom
T9  PAD~D  [TPC12]  362.62 50.56 180 bottom
T10  PAD~D  [TPC12]  198.11 94.52 180 bottom
T11  PAD~D  [TPC12]  196.84 89.87 180 bottom
T12  PAD~D  [TPC12]  196.91 92.15 180 bottom
T13  PAD~D  [TPC12]  197.41 93.42 180 bottom
T17  PAD  [TPC12]  287.8 28.41 180 bottom
T25  PAD~D  [TPC12]  350.24 51.09 0 top
T26  PAD~D  [TPC12]  350.42 49.7 0 top
T62  PAD~D  [TPC12]  354.8 67.34 0 top
T63  PAD~D  [TPC12]  355.46 68.85 0 top
T65  PAD~D  [TPC12]  354.93 65.81 180 bottom
T91  PAD  [TPC12]  271.92 46.98 180 bottom
T92  PAD  [TPC12]  286.86 35.96 0 top
T94  PAD  [TPC12]  273.05 47.92 180 bottom
T121  PAD~D  [TPC12]  365.27 69.43 180 bottom
T182  PAD  [TPC12]  280.91 38.75 0 top
T944  PAD~D  [TPC12]  21.55 41 180 bottom
T4931  PAD  [TPC12]  292.86 14.89 0 top
T4936  PAD~D  [TPC12]  365.27 70.79 180 bottom
T4938  PAD  [TPC12]  291.2 29.45 0 top
T4939  PAD  [TPC12]  296.17 13.53 0 top
T4940  PAD  [TPC12]  297.47 12.16 0 top
T4941  PAD  [TPC12]  316.55 17.33 0 top
T4942  PAD  [TPC12]  315 6.06 0 top
TL2  MHPC_NS892407  [MHPC_NS892407_24P]  30.94 64.78 180 bottom
TR5807  MCM1012B900F06BP_4P  [INPAQ_MCM1012B900F06BP_4P]  221.87 30.73 0 bottom
U5603  -  [LNG2DMTR_LGA12_2X2]  265.87 8.39 0 top
UA1  -  [G9090-180T11U_SOT23-5]  336.41 7.97 90 top
UC1  74AUP1G07SE-7_SOT353  [74AUP1G07GW_TSSOP5]  136.74 87.57 270 bottom
UC16  74AUP1G07SE-7_SOT353  [74AUP1G07GW_TSSOP5]  182.04 78.5 90 top
UE1  MEC1416-NU-D0 VTQFP 128P_14X14  [MEC1404-NU-TR_VTQFP128_14X14]  299.17 21.39 0 top
UE3  -  [TCS40DLR_SOT23F3]  214.5 143.16 180 top
UE4  -  [SY6288D20AAC_SOT23-5]  131.87 29.04 0 bottom
UE6  -  [SN74LVC1G06DCKR_SC70-5]  312.7 25.57 0 top
UG1  H5GQ1H24AFR-T2L_BGA170  [H5GQ1H24AFR-T2L_BGA_170P]  229.33 142.38 180 bottom
UG2  H5GQ1H24AFR-T2L_BGA170  [H5GQ1H24AFR-T2L_BGA_170P]  200.26 129.58 0 bottom
UG3  H5GQ1H24AFR-T2L_BGA170  [H5GQ1H24AFR-T2L_BGA_170P]  264.83 109.57 90 bottom
UG4  H5GQ1H24AFR-T2L_BGA170  [H5GQ1H24AFR-T2L_BGA_170P]  234.93 129.58 0 bottom
UG5  H5GQ1H24AFR-T2L_BGA170  [H5GQ1H24AFR-T2L_BGA_170P]  262.8 74.71 90 bottom
UG6  H5GQ1H24AFR-T2L_BGA170  [H5GQ1H24AFR-T2L_BGA_170P]  250 103.95 270 bottom
UG9  N17E-G1_BGA2152~D  [N17E-G1_BGA_2152P]  235.75 79.65 90 bottom
UG10  -  [NL17SZ08DFT2G_SC70-5]  201.97 74.85 270 bottom
UG11  -  [INA3221AIRGVR_VQFN16_4X4]  226.83 72.34 180 bottom
UG12  AOZ1331_SON14_2X3  [TPS22966DPUR_SON14_2X3]  217.53 70.95 180 bottom
UG13  -  [W25Q80EWSSIG_SO8]  184.5 77.74 90 bottom
UG14  -  [TPS22961DNYR_WSON8]  208.02 63.48 180 top
UG22  -  [NL17SZ08DFT2G_SC70-5]  220.71 63.19 0 top
UG25  -  [74LVC1G32GW_TSSOP5]  209.45 62.13 0 top
UG26  -  [NL17SZ08DFT2G_SC70-5]  203.35 61.82 0 top
UG27  -  [74LVC1G32GW_TSSOP5]  210.87 79.79 180 top
UG29  -  [NL17SZ08DFT2G_SC70-5]  204.4 70.58 180 bottom
UG30  TC7SZ08FU_SSOP5  [TC7SH08FU_SSOP5]  201.41 64.1 180 top
UG31  -  [NL17SZ08DFT2G_SC70-5]  116.13 87.34 180 bottom
UH1  SKL-H_BGA1440  [SKL-H_BGA_1440P-T]  180.3 78.19 270 bottom
UH2  SKY-H-PCH_BGA837  [SKY-S-PCH_BGA_837P-T]  296.8 52.04 0 bottom
UH7  -  [MC74VHC1G08DFT2G_SC70-5]  286.47 17.7 0 top
UH8  MX25L12873FM2I-10G_SOP_8P  [W25Q128FVSIQ_SO8]  300.2 45.06 0 bottom
UH14  -  [MC74VHC1G08DFT2G_SC70-5]  310.95 30.38 180 top
UI3  PS8713BTQFN24GTR2-A1 TQFN  [SN65LVPE502ARGER_VQFN24_4X4-S]  11.49 50.62 270 bottom
UL1  RTL8111H-CG_QFN32_4X4  [RTL8111H-CG_QFN32_4X4-S]  24.93 47.39 270 bottom
UL2  -  [SY6288C20AAC_SOT23-5]  24.53 52.14 180 bottom
UP2  PS8409AQFN48GTR2-A0 QFN48P  [PS8409QFN48GTR2-A0_QFN48_6X6-S]  337.1 43.04 180 top
UR1  RTS5176E-GR_QFN24_4X4  [RTS5176E-GR_QFN24_4X4-S]  14.54 29.95 0 bottom
US1  TPS2544RTER_WQFN16_3X3  [TPS2544RTER_WQFN16_3X3-S]  10.83 37.72 270 bottom
US2  -  [SY6288D20AAC_SOT23-5]  351.52 36.19 0 bottom
UT1  ALPINE-RIDGE_BGA337  [ALPINE-RIDGE_BGA_337P]  359.87 59.25 180 bottom
UT2  -  [W25Q80DVSSIG_SO8]  347.76 40.29 90 bottom
UT4  SN1610042ZQZR BGA 96P_BGA96  [TPS65982DAZQZR-ES_BGA_96P]  358.94 67.78 0 bottom
UT5  -  [W25X20CLSNIG_SO8]  363.37 91.73 180 bottom
UTH1  -  [F75303M_MSOP10]  93.58 66.78 90 bottom
UTPM1  NPCT650VBBYX_QFN32_5X5  [NPCT650JB2YX_QFN32_5X5]  292.43 11.64 90 bottom
UV17  -  [AP2330W-7_SC59-3]  364.72 86.71 0 bottom
UVGA1  RTD2166-CG_QFN32_4X4  [RTD2166-CG_QFN32_4X4-S]  318.81 36.46 90 top
UZ1  -  [EM5209VF_DFN14_3X2]  260.05 31.81 0 top
UZ8  -  [SY6288C20AAC_SOT23-5]  88.24 53.88 0 top
UZ9  -  [TPS22961DNYR_WSON8]  184.83 104.9 90 bottom
UZ15  -  [TPS22961DNYR_WSON8]  185.27 110.26 270 bottom
UZ16  AOZ1336DI_DFN8_2X2  [APE8937GN2_DFN8_2X2]  225.96 50.05 0 top
UZ21  -  [MC74VHC1G08DFT2G_SC70-5]  299.37 29.97 180 top
Y1  32.768KHZ 9PF 20PPM 9H03280012  [Y_X1A000141000200_2P]  303.17 28.1 180 top
YG1  27MHZ 16PF +-30PPM 7M27070004F50Q5  [Y_5YEA27000163IF50Q5_4P]  195.33 85.07 270 bottom
YH1  32.768KHZ 9PF 20PPM 9H03280012  [Y_CM31532768DZFT_2P]  294.32 24.8 180 bottom
YH2  24MHZ_12PF_X3G024000DC1H  [Y_X3G024000DC1H_4P]  304.01 51.84 270 bottom
YL2  25MHZ_10PF_7V25000014  [Y_7V25000014_4P]  20.58 45.61 270 bottom
YT1  25MHZ 20PF +-10PPM 7M25000153  [Y_7V25000012_4P]  346.85 62.81 90 bottom

## Library data of the parts
C5235 CA4 CA7 CA60-CA62 CA66 CD97 CE2 CE17 CE18 CE99-CE102 CE104 CE105 CE107 CG40 CG47 CG48 CG51 CG53 CG54 CG56-CG61 CG64-CG66 CG75 CG76 CG78 CG79 CG83-CG91 CG100-CG106 CG113 CG114 CG118-CG126 CG135-CG141 CG148 CG149 CG153-CG161 CG170-CG176 CG192-CG215 CG230 CG233-CG238 CG240 CG291 CG292 CG295-CG300 CG308-CG310 CG313-CG318 CG322 CG323 CG325-CG343 CG345-CG363 CG365-CG386 CG391-CG403 CG407-CG419 CG423-CG435 CG442 CG482 CG487 CG504 CG509 CG512 CG517 CG520 CG522 CG523 CG525 CH185 CH205-CH215 CI3-CI8 CI24 CI25 CI28 CI29 CL32 CL43 CL44 CL49 CL52-CL57 CN7 CN19 CP3-CP7 CP9-CP27 CP47 CR4 CR6-CR9 CS25-CS28 CT37 CT38 CT50-CT53 CT88 CT94-CT97 CT101 CT103 CT104 CT114 CTH2-CTH5 CTPM1-CTPM3 CTPM5-CTPM7 CV922 CVGA3-CVGA13 CVGA15-CVGA24 CZ102 CZ108 PC1-PC8 PC10V5 PC10V7 PC12-PC18 PC18V03 PC18V08 PC18V09 PC18V10 PC19 PC20 PC25V00 PC114 PC115 PC201 PC205 PC212 PC213 PC215 PC216 PC711 PC719-PC725 PC812-PC814 PC4000 PC4001 PC4003 PC4004 PC4010-PC4012 PC5000-PC5002 PC5004-PC5040 PC5100 PC5101 PC5108-PC5111 PC5113 PC5114 PC5119-PC5122 PC5124 PC5125 PC5130-PC5133 PC5200 PC5201 PC5206-PC5208 PC5210-PC5212 PC5214 PC5215 PC5219 PC5220 PC5223 PC5224 PC5228-PC5231 PC5518-PC5538 PC5588-PC5610 PC6000 PC6002 PC6006-PC6009 PC6011 PC6014-PC6016 PC6108-PC6111 PC6117 PC6118 PC6122 PC6123 PC6131-PC6134 PC6500-PC6564 = C_0402
CA1 CA8 CA11 CA13 = C_0603: room: AUDIO_DC_DC
CA2 CA3 CA9 CA12 CA14 = C_0402: room: AUDIO_DC_DC
CA10 CA63-CA65 CE103 CG42 CG43 CG62 CG63 CG80-CG82 CG97-CG99 CG115-CG117 CG132-CG134 CG150-CG152 CG167-CG169 CG184-CG191 CG216-CG228 CG231 CG243 CG245 CG288-CG290 CG311 CG320 CG324 CG344 CG364 CG388-CG390 CG404-CG406 CG420-CG422 CG505 CG507 CG510 CG511 CG514 CG515 CG524 CI26 CN6 CN22 CP8 CP28 CP29 CR5 CR10 CT73-CT75 CT90-CT93 CT98-CT100 CT106 CT115 CT116 CVGA1 CVGA2 CVGA14 PC10V0-PC10V4 PC10V6 PC18V01 PC18V04 PC18V05 PC18V06 PC18V07 PC18V11 PC25V01 PC25V02 PC25V03 PC25V04 PC25V05 PC25V06 PC112 PC113 PC206 PC209 PC214 PC217-PC224 PC300 PC714 PC715 PC4005-PC4009 PC4013 PC4014 PC5003 PC5102 PC5112 PC5115 PC5123 PC5126 PC5134 PC5202 PC5209 PC5213 PC5221 PC5222 PC5232 PC5503-PC5517 PC5550-PC5587 PC6100-PC6102 PC6114-PC6116 PC6128-PC6130 PC6565-PC6579 PL10V01 = C_0603
CA15 CA18-CA20 CA22 CA25 CA27 = C_0603: room: AUDIO
CA16 CA17 CA23 CA24 CA26 CA28-CA30 CA36-CA43 = C_0402: room: AUDIO
CC4 CC298 CH45-CH48 CH50-CH53 CH70 CH80 CH82 CH173 CH176 CH179 CH180 CH183 CH184 CH186-CH192 CH200 CH203 = C_0402: room: PCH
CC27 = C_0402: room: RTC
CD1-CD4 CD12 CD16 CD17 CD69 CD74-CD79 CD96 CH101 = C_0402: room: DIMMA
CD5-CD10 CD13-CD15 CD70-CD73 = C_0603: room: DIMMA
CD19-CD22 CD29-CD32 CD34 CD35 CD80-CD83 CH100 = C_0402: room: DIMMB
CD23-CD28 CD84-CD90 = C_0603: room: DIMMB
CD33 = C_APXK2R5ARA331MF451: room: DIMMB
CD36 = C_0603: room: NGFF SSD
CD37-CD46 CD51 CD53 = C_0402: room: NGFF SSD
CE1 CE4 CE5 = C_0402: room: KB
CE6 = C_0603: room: KB
CE8 CE12 CE62-CE69 CE71 CE73 CE76 CE77 CE79 CE81 CE82 CE84-CE87 CE91 CE98 = C_0402: room: EC
CE9 CE10 CE80 = C_0402: room: TOUCH PAD
CE89 = C_0603: room: EC
CG25-CG36 CG246 CG293 CG294 CG301-CG307 CG438-CG440 CG483 CG488-CG503 CG506 CG513 CG516 CG518 CG519 CG526 CG527 CT1-CT16 CT18 CT21 CT23-CT36 CT39-CT49 CT54-CT72 CT77 CT78 CT86 CT102 CT108-CT113 CT117 CTH1 CTPM4 = C_0201
CG55 CG232 CG239 CG508 CG521 CI27 CI31 PC18V00 PC18V02 PC207 PC208 PC716-PC718 PC4002 PC5105-PC5107 PC5116-PC5118 PC5127-PC5129 PC5203-PC5205 PC5216-PC5218 PC5225 PC5226 PC5541-PC5549 PC6103-PC6105 PC6112 PC6113 PC6119 PC6124-PC6127 PC6135-PC6138 PC6141 PC6580-PC6586 = C_0805
CG242 = C_D2E
CG244 PC6107 PC6121 PC6140 PC6588 = C_D1
CG528 PC5500 PC5540 PC6587 PC6589 = C_D3
CH5-CH36 = C_0201: room: CPU
CH102-CH104 CH111-CH123 CH125-CH132 CH136 = C_0603: room: CPU_DECAP
CH106 CH110 CH124 CH133-CH135 CH204 = C_0402: room: CPU_DECAP
CH177 CH178 CH181 CH182 CH201 CH202 = C_0603: room: PCH
CH197 CZ47 CZ49 CZ57 CZ86 CZ88 = C_0402: room: CPU
CI9 CI10 CI13 = C_0402: room: USB2
CI11 = C_0805: room: USB2
CI12 = C_0603: room: USB2
CI16 CI19 CI20 CI23 = C_0402: room: USB1
CI17 = C_0805: room: USB1
CI18 = C_0603: room: USB1
CI21 CI30 = C_1206
CL15 CL19-CL22 CL24 CL30 CL31 CL34-CL37 CL39 CL42 = C_0402: room: LAN
CL33 = C_1206: room: LAN
CL41 = C_0402: room: FAN
CL47 CL48 = C_0402: signal model: C_0402_0.1U_0402_10V6K
CLP1-CLP4 = EMIST_SUL-12A2M_1P
CLRP1 = SHORTPADS: User Part Number: PART#; room: PCH
CN1 = C_0603: room: NGFF WLAN
CN2 CN9 CN20 CN21 = C_0402: room: NGFF WLAN
CS12-CS14 = C_0402: room: HDD
CS15 = C_0603: room: HDD
CT79 = C_0201: room: TOUCH PAD
CT80 CT83-CT85 = C_0201: room: THERMAL
CT81 CT82 = C_0402: room: THERMAL
CV576 CV579-CV581 CV585-CV592 = C_0402: room: EDP
CV577 CV578 = C_0603: room: EDP
CV582 CV583 CZ44 EC5205 EC5206 = C_0402: room: CAMERA
CV584 = C_0603: room: CAMERA
CV597 = C_0603: room: HDMI
CV598-CV601 = C_0402: room: HDMI
CZ4 CZ6 = C_0402: room: 3V_5V_DC_DC
CZ8 CZ9 CZ11 CZ12 = C_0603: room: 3V_5V_DC_DC
CZ28 CZ96 CZ97 = C_0402: room: CPU_DC_DC
CZ41 = C_0402: room: EDP_DC_DC
D1 = BAT54C-7-F_SOT23-3: room: AUDIO
D5223 DA5 = L03ESDL5V0CC3-2_SOT23-3
D5225 D5226 DA6 DT11 PD3 PD4 = TVNST52302AB0_SOT523-3
DA1 = AZC199-02SPR7G_SOT23-3: room: AUDIO
DA2 DA3 = AZ5125-02SPR7G_SOT23-3: room: AUDIO
DA4 = AZ5123-02SPR7G_SOT23-3
DC2 = BAT54CW-7-F_SOT323-3: room: RTC
DE4 = AZC099-04SPR7G_SOT23-6: room: TOUCH PAD
DE7 DE9 DG2-DG4 DG7 DG8 DG10 DT1 DV1 DZ1 DZ2 = AZ5125-01HPR7G_SOD523-2
DG9 = BAT54A-7-F_SOT23-3
DH1 = AZ5125-01HPR7G_SOD523-2: room: PCH
DI1 = AZ5125-01HPR7G_SOD523-2: room: EDP
DI3 = PESD5V0U2BT_SOT23-3: room: EDP
DI7 = TVWDF1004AD0_DFN9: room: USB2
DI8 = AZC199-02SPR7G_SOT23-3: room: USB2
DI9 = TVWDF1004AD0_DFN9: room: USB1
DI10 = AZC199-02SPR7G_SOT23-3: room: USB1
DI11 = AZC199-02SPR7G_SOT23-3
DI12 DT10 = TVWDF1004AD0_DFN9
DN1 DN2 = AZ5125-01HPR7G_SOD523-2: room: NGFF WLAN
DT2-DT9 DT13 DT14 = ESD8011MUT5G_X3DFN2-2
DT15 = PESD24VS2UT_SOT23-3
DV2 = BAT54CW-7-F_SOT323-3: room: EDP
DV3 = BAT54CW-7-F_SOT323-3: room: EDP_DC_DC
DV12 = PESD5V0U2BT_SOT23-3: room: CAMERA
DVGA1 = LRB551V-30T1G_SOD323-2
F1 = F_NANOSMDC050F-13P2-2: room: KB
F2 = F_SMD1812P110TF-24
FD1-FD4 = FIDUCIAL_C40M80
FVGA1 = F_SPR-P110
H1-H4 H7 H8 H15 H16 = H_2P8-G
H5 H13 = H_3P3: room: ETY-ROOM
H9 H21 = H_2P8N
H10 H11 H17 = H_2P8-G: room: ETY-ROOM
H14 = H_2P8X3P4-G
H18 H19 = H_3P0-G
H20 H22 = H_2P8X3P4N
H23 = H_4P5N
HCPU1 HCPU2 HGPU1 HGPU2 = H_4P0-G
HCPU3 HCPU4 = H_3P7-G
HDA1 = ALC3246-CG_MQFN48_6X6-S: room: AUDIO
HT1 RT5 = R_0402: room: THERMAL
JBL1 = ACES_51575-00401-001_4P-T: room: KB
JCAM1 = ACES_50228-0067N-001_6P: room: CAMERA
JCRT1 = C-K_80454-5K1-152_15P
JDEG1 = JXT_FP241AH-010GAAM_10P: room: EC
JDIMM1 = DEREN_40-42271-26001RHF_260P-T: room: DIMMA
JDIMM2 = DEREN_40-42271-26001RHF_260P-T: room: DIMMB
JEDP1 = ACES_59003-04006-001_40P: room: EDP
JESPI1 = JXT_FP241AH-010GAAM_10P
JFAN1 JFAN2 = ACES_50278-0040N-001_4P: room: FAN
JHDD1 = ACES_51625-01201-001_12P: room: HDD
JHDMI1 = CONCR_099A3AC19JBLCNF_19P: room: HDMI
JHP1 = SINGA_2SJ3095-106111F_6P: room: AUDIO
JKB1 = ACES_50699-03001-P01_30P: room: KB
JLAN = SANTA_130460-N_8P: room: LAN
JLED = ACES_51575-00401-001_4P-T: room: ETY-ROOM
JNGFF1 = CONCR_213EAAA32FA_67P: room: NGFF WLAN
JNGFF2 = BELLW_SD-80159-4221_67P-T: room: NGFF SSD
JPW = ACES_51530-01001-P01_10P-T: room: ETY-ROOM
JPZ1 JPZ2 PJP12 PJP31-PJP34 PJP201 PJP202 PJP801 PJP802 PJP4001 = JUMP_43X118
JREAD1 = T-SOL_156-1001902607_11P
JRTC = ACES_50273-0020N-001_2P-T: room: RTC
JSPK1 = ACES_50278-0040N-001_4P: room: AUDIO
JTP = ACES_51524-0080N-001_8P: room: TOUCH PAD
JUSB1 = ACON_TCRA2-9R1394_9P: room: USB1
JUSB2 = ACON_TCRA2-9R1394_9P: room: USB2
JUSB3 = ACON_TCRA2-9R1394_9P
JUSBC1 = JAE_DX07S024JJ7R1200_24P-T
JXDP1 = SAMTE_BSH-030-01-L-D-A-TR_60P
LA1 = MURAT_BLM15PX471SN1D_2P: room: AUDIO
LA19 LA22 LVGA1-LVGA3 = MURAT_BLM15BD601SN1D_2P
LA20 LA21 = MURAT_BLM15AX700SN1D_2P
LA23-LA26 = MURAT_BLM15PX181SN1D_2P
LED3 = LED_HT-F196BP5_2P
LG4-LG9 LT4 = CHILI_PBY160808T-300Y-N_2P
LH1 LH2 = MURAT_BLM15PX221SN1D_2P: room: PCH
LI1 = INPAQ_MCM1012B900F06BP_4P: room: EDP
LI2 = INPAQ_MCM1012B900F06BP_4P: room: USB1
LI5 = INPAQ_MCM1012B900F06BP_4P: room: USB2
LI8 LT2 LT3 TR5807 = INPAQ_MCM1012B900F06BP_4P
LT1 = MAG_MND-04ABIR60M-XGL_2P
LV22 = INPAQ_MCM1012B900F06BP_4P: room: CAMERA
PBATT1 = ACES_50458-01001-P01_10P-T
PC100-PC102 PC105 PC107 PC108 = C_0402: room: DC_CON
PC103 PC104 = C_0805: room: DC_CON
PC106 = C_0603: room: DC_CON
PC109-PC111 = C_0603: room: BAT_CON
PC200 PC204 = C_0402: room: PROCHOT#
PC202 PC203 = C_0805: room: PROCHOT#
PC301 PC302 PC307 PC308 = C_0805: room: CHARGER
PC303-PC306 PC309 PC310 PC313 PC314 PC316 = C_0402: room: CHARGER
PC311 PC312 = C_APXK6R3ARA221MF451: room: CHARGER
PC315 = C_0603: room: CHARGER
PC700-PC702 PC704 PC705 PC708 PC709 PC712 PC713 = C_0402: room: VCCIO
PC703 PC710 = C_0603: room: VCCIO
PC706 PC707 = C_0805: room: VCCIO
PC800-PC802 PC806 PC807 = C_0402: room: +1.05VSDGPU
PC803-PC805 = C_0805: room: +1.05VSDGPU
PC808 PC809 = C_0603: room: +1.05VSDGPU
PC810 = C_D2: room: +1.05VSDGPU
PC811 PC5539 = C_D2
PC5103 PC6106 = C_ECST250ADA101MF611
PC5501 PC5502 = C_EEFSS0D221R
PD1 = L30ESD24VC3-2_SOT23-3
PD700 = BAT54CW_SOT323-3
PH5000-PH5004 PH6000 PR1-PR5 PR8 PR10 PR10V1-PR10V3 PR10V5 PR10V6 PR12 PR13 PR15 PR16 PR18V02 PR18V04 PR18V05 PR18V06 PR20-PR23 PR25V01 PR25V02 PR25V03 PR25V04 PR26-PR33 PR35 PR108 PR109 PR314 PR702 PR713-PR715 PR718-PR720 PR722 PR724-PR726 PR728 PR729 PR734 PR800 PR811-PR813 PR815 PR4001 PR4004-PR4006 PR4008 PR4009 PR4011 PR5001-PR5004 PR5007 PR5010 PR5012-PR5019 PR5021 PR5022 PR5024-PR5027 PR5029-PR5051 PR5100 PR5101 PR5103 PR5108-PR5113 PR5115 PR5116 PR5120 PR5122-PR5125 PR5127 PR5128 PR5133-PR5136 PR5200 PR5201 PR5203 PR5208-PR5212 PR5214 PR5216 PR5220-PR5222 PR5228-PR5231 PR6000 PR6002-PR6004 PR6006-PR6013 PR6017 PR6020 PR6022-PR6025 PR6027-PR6030 PR6033 PR6034 PR6036 PR6038-PR6040 PR6042-PR6044 PR6046-PR6048 PR6050 PR6052 PR6054 PR6056-PR6059 PR6061-PR6064 PR6102-PR6105 PR6107 PR6109-PR6112 PR6114 PR6116-PR6119 PR6121 R1 R3-R5 RA2 RD62 RE81-RE84 RE100 RE101 RE106 RE113 RE114 RE118-RE129 RE132 RE139-RE141 RE143-RE152 RG17-RG20 RG23 RG37 RG47-RG62 RG64-RG71 RG74-RG95 RG98 RG99 RG101-RG134 RG156 RG159 RG167 RG509-RG515 RG523-RG528 RG543-RG546 RG549 RG550 RG557 RG562 RG571 RG573 RG575-RG578 RG580 RG582-RG584 RH1 RH125 RH496 RH497 RH504-RH506 RH515-RH526 RH528 RH529 RH531 RH540-RH542 RH545-RH554 RH557-RH562 RH567 RH568 RH571-RH582 RI3 RI11 RI12 RI15-RI25 RI46-RI48 RI51 RI53-RI58 RL1 RL42 RM3 RM4 RN2 RN4-RN7 RP9-RP11 RP24 RP25 RP32-RP46 RP48 RP49 RS1 RS39-RS41 RT19 RT25 RT48-RT51 RT75 RT118 RT119 RTH1-RTH6 RTPM1-RTPM5 RTPM7-RTPM10 RTPM12-RTPM15 RV570 RV609-RV616 RVGA3-RVGA8 RVGA10-RVGA16 RW3 RZ33 RZ102 RZ108 RZ111 RZ112 = R_0402
PJP10V0 PJP18V1 PJP200 PJP203 PJP4000 = JUMP_43X39
PJP10V1 PJP11 PJP18V2 PJP25V1 PJP25V2 = JUMP_43X79
PJP1302 PJP1303 = JUMP_43X39: room: PCH
PJP1304 = JUMP_43X39: room: RTC
PJPDC1 = ACES_51202-00901-001_9P-T
PL1 PL2 PL4-PL9 = TAI-T_HCB2012KF-121T50_2P
PL3 = MURAT_BLM15HG601SN1D_2P
PL10V0 = TOKO_1239AS-H-1R0M-P2_2P
PL18V00 PL4000 = CYNTE_PCMB042T-1R0MS_2P
PL100 = CYNTE_PCMB063T-1R0MS_2P: room: DC_CON
PL200 PL303 = L_7X7X3_M_2P
PL300 PL301 = TAI-T_HCB2012KF-121T50_2P: room: CHARGER
PL302 = L_7X7X3_M_2P: room: CHARGER
PL700 = KC_FBMA-L11-322513151LMA50T_2P: room: VCCIO
PL701 = MAG_MMD-10DZ-4R7M-X2_2P: room: VCCIO
PL800 = KC_FBMA-L11-453215800LMA90T_2P: room: +1.05VSDGPU
PL801 = CYNTE_PCMC104T-R88MN_2P
PL5100 PL6100 = KC_FBMA-L11-453215800LMA90T_2P
PL5101-PL5103 PL5201 PL5202 = CYNTE_PCME064T-R15MS0R667_2P
PL5203 = MAG_MMD05CZR47M_4P
PL6101-PL6103 = L_7X7X4_M
PQ1 = FDV301N_NL_SOT23-3
PQ2 = RHU002N06_SOT323-3
PQ5 PQ8 PQ9 PQ700 PQ706 PQ708 = SSM3K7002FU_SC70-3
PQ6 PQ7 QC5 QE20 QE21 QE23 QE24 QG8 QG23 QTH3 QZ13 = DMN65D8LDW-7_SOT363-6
PQ201 = AON7408L_DFN8-5: room: PROCHOT#
PQ202 = AON7506_DFN33-8-5: room: PROCHOT#
PQ301 PQ303 = AON7380_DFN3X3-8-5: room: CHARGER
PQ302 PQ304 = AON6796_DFN5X6-8-5: room: CHARGER
PQ305 = L2N7002WT1G_SC70-3
PQ701-PQ703 = AON6366E_DFN5X6-8-5
PQ704 = AON7506_DFN33-8-5
PQ705 = AON6380_DFN5X6-8-5
PQ707 = AON7380_DFN3X3-8-5
PQ800 PQ801 = AON6992_DFN5X6D-8-7
PQ802 = BSS138W_SOT323-3
PQ6000 QG6 QG7 QG502-QG505 QG509 QG513 = 2N7002DW-7-F_SOT363-6
PR10V0 PR18V01 PR18V03 PR712 PR4000 PR5105 PR5107 PR5118 PR5119 PR5130 PR5132 PR5205 PR5207 PR5217 PR5219 PR5225 PR5227 PR6037 PR6106 PR6108 PR6113 PR6115 PR6120 PR6122 RA58 RI67 RP31 RT95 RT124 = R_0603
PR10V4 PR18V00 PR18V07 PR24 PR25 PR25V00 PR34 PR315 PR721 PR723 PR727 PR730-PR733 PR814 PR4003 PR4007 PR4010 PR5000 PR5005 PR5006 PR5008 PR5009 PR5011 PR5020 PR5023 PR5028 PR5102 PR5104 PR5114 PR5117 PR5126 PR5129 PR5202 PR5204 PR5213 PR5215 PR5223 PR5224 PR6018 PR6021 PR6026 PR6035 PR6041 PR6045 PR6051 PR6053 PR6060 PR6069 PR6070 RE109-RE112 RE116 RE130 RE131 RE133-RE135 RE138 RH502 RH503 RH513 RH514 RH530 RH532-RH539 RH543 RH544 RL2 RL43 RN8 RT53 RT97 RT120 RTPM6 RTPM11 RV566 RVGA9 RW4 = R0402_0OHM
PR101 PR103 = R0402_0OHM: room: DC_CON
PR102 = R_0402: room: DC_CON
PR104 = R_1206: room: DC_CON
PR106 PR107 RA11 RA17 RA18 RA22-RA24 RA27 RA30 RA32 RA33 RA42-RA44 RA46 RA48 RA49 RA51 RA53 = R_0402: room: AUDIO
PR200 PR203 = R_0603: room: PROCHOT#
PR201 PR205-PR208 PR210 = R_0402: room: PROCHOT#
PR202 = R_1206: room: PROCHOT#
PR204 = R_0603: room: ETY-ROOM
PR209 = R0402_0OHM: room: PROCHOT#
PR211 = R0402_0OHM: room: ETY-ROOM
PR300-PR306 PR313 = R_0402: room: CHARGER
PR307 PR308 = R_0603: room: CHARGER
PR309 PR310 = R_1206: room: CHARGER
PR311 PR312 = R0402_0OHM: room: CHARGER
PR700 PR701 PR704 PR707 PR708 = R_0402: room: VCCIO
PR703 = R_1206_4P-D: room: VCCIO
PR705 PR706 = R0402_0OHM: room: VCCIO
PR709 PR710 = R_0603: room: VCCIO
PR711 = R_1206: room: VCCIO
PR716 = R_1206_4P-D
PR717 PR4002 PR5106 PR5121 PR5131 PR5206 PR5218 PR5226 = R_1206
PR801 = R_0603: room: +1.05VSDGPU
PR802-PR804 PR807 PR809 PR810 = R_0402: room: +1.05VSDGPU
PR805 = R_1206: room: +1.05VSDGPU
PR6100 PR6101 = RL-3264-9W-R005-FNH_2512_2512
PU10V0 = RT8061AZQW_WDFN10_3X3
PU18V00 PU100 PU4000 = SY8286RAC_QFN20_3X3
PU25V00 = RT9059GSP_SO8
PU200 = RT8207PGQW_WQFN20_3X3-S
PU300 = TPS51285BRUKR_QFN20_3X3: room: CHARGER
PU700 = BQ24780RUYR_WQFN28_4X4-S: room: VCCIO
PU800 = TPS51212DSCR_SON10_3X3: room: +1.05VSDGPU
PU5000 = ISL95855HRTZ-T_TQFN48_6X6-S
PU5101-PU5103 PU5201 PU5202 PU6100-PU6102 = SIC632CDT1GE3_POWERPAK31_5X5
PU5203 = SIC531CDT1GE3_POWERPAK22_4X3
PU6000 = UP9511PQGJ_VQFN40_5X5
Q12 Q13 QH6 = 2N7002K_SOT23-3
QA1 QZ2 = LN2306LT1G_SOT23-3
QE3 QE5 = L2N7002WT1G_SC-70-3: room: KB
QE4 = DMG2301U-7_SOT23-3: room: KB
QE13 = L2N7002WT1G_SC-70-3: room: TOUCH PAD
QE19 = DMN65D8LDW-7_SOT363-6: room: TOUCH PAD
QG2-QG4 QG510 QG511 = MESS138W-G_SOT323-3
QG9 = BSS138W-7-F_SOT323-3
QH4 = DMN65D8LDW-7_SOT363-6: room: PCH
QP1 QTH1 QTH2 = MMST3904-7-F_SOT323-3
QTPM1 = LP2301ALT1G_SOT23-3
QV2 = L2N7002WT1G_SC-70-3
QV11 = SI3457BDV-T1-E3_TSOP6
R2 = R_0805
R126 R127 RI1 RI2 RI65 RI66 RV545 RV547 = R_0402-NPM
RA1 RA5 = R0402_0OHM: room: AUDIO_DC_DC
RA7 RA10 = R0805_0OHM: room: AUDIO_DC_DC
RA8 = R0603_0OHM: room: AUDIO
RA9 RA12-RA15 RA19 RA56 = R0402_0OHM: room: AUDIO
RA16 = R0805_0OHM: room: AUDIO
RA57 RE104 RE105 RH493 RI52 RI59 RM22 RP28 RVGA1 RVGA2 RZ35 = R0603_0OHM
RC11 = R_0402: room: RTC
RD7-RD9 = R_0402: room: NGFF SSD
RD31 = R0402_0OHM: room: DIMMA
RD35 RH45 RH206 RH209 RH211 = R_0402: room: DIMMA
RD58 RD59 = R0402_0OHM: room: NGFF SSD
RE1-RE4 = R_0402: room: KB
RE7 RE9 RE87 RZ32 = R_0402: room: TOUCH PAD
RE12 RE15 RE16 RE67 = R0603_0OHM: room: EC
RE13 RE14 RE17 RE20-RE25 RE27 RE29-RE31 RE33-RE36 RE38 RE39 RE43-RE47 RE52 RE53 RE55 RE60 RE63-RE65 = R_0402: room: EC
RE57 RE58 RE61 RE62 RE66 RE68 RE73 = R0402_0OHM: room: EC
RE71 RH20 RH24 RH29 RH30 RH33 RH41 RH56-RH61 RH89 RH93 RH95 RH97 RH98 RH100 RH107 RH144 RH145 RH148-RH156 RH158 RH163-RH167 RH183-RH188 RH192 RH197 RH201 RH203 RZ71 = R_0402: room: CPU
RE93 = R0603_0OHM: room: TOUCH PAD
RE115 RZ36 RZ70 = R0805_0OHM
RG16 RG21 RG22 RG24 RG26 RG157 RG160-RG166 RG168 RG502 RG504-RG506 RG516 RG518 RG522 RG529 RG537 RG551 RG553 RG554 RG566 RG572 RG579 RH569 RH570 RT8 RT9 RT11 RT17 RT18 RT20 RT21 RT24 RT26-RT47 RT57 RT58 RT61-RT63 RT66-RT73 RT76-RT80 RT86 RT94 RT101 RT102 RT111-RT117 RT122 RT123 RT125-RT128 = R_0201
RH9 RH11 RH101 RH103 RH105 RH114 = R0402_0OHM: room: PCH
RH10 RH13 RH17 RH18 RH21 RH22 RH26 RH27 RH62-RH72 RH74 RH77 RH79-RH84 RH86 RH91 RH92 RH94 RH108 RH109 RH112 RH113 RH119 RH120 RH127-RH130 RH138 RH141 RH143 RH146 RH147 RH159 RH160 RH168 RH179-RH181 RH189 RH191 RH193 RH196 = R_0402: room: PCH
RH28 RH31 RH32 RH38 RH190 RH198 RH202 RH204 = R0402_0OHM: room: CPU
RH46 RH207 RH210 RH212 = R_0402: room: DIMMB
RH121-RH124 RH137 = R0603_0OHM: room: PCH
RI9 RI10 RI30 RI45 RI49 = R_0402: room: USB1
RL19 RL20 RL27 RL30 RL31 RL33 RL39-RL41 = R_0402: room: LAN
RN1 = R_0402: room: NGFF WLAN
RP3 RP16 RPT1 = RP_0804_8P4R
RP8 RP15 = RP_0804_8P4R: room: PCH
RPE2-RPE7 = RP_0804_8P4R: room: EC
RT1 = R0201_0OHM: room: THERMAL
RT2 RT10 RT13 RT16 RT59 RT60 RT74 RT83 RT108 RT110 RT121 = R0201_0OHM
RT3 RT4 RT6 RT7 = R_0201: room: THERMAL
RV535-RV537 RV551 = R_0402: room: EDP
RV538 = R0402_0OHM: room: EDP
RV554 RV557 RV562 RV565 = R_0402: room: HDMI
RZ26 = R0603_0OHM: room: EDP
RZ34 = R0805_0OHM: room: HDD
RZ37 = R0603_0OHM: room: CAMERA
RZ40 = R_0402: room: EDP_DC_DC
RZ48 RZ67 = R0603_0OHM: room: CPU
RZ66 = R0603_0OHM: room: CPU_DC_DC
RZ96 = R_0402: room: CAMERA
SW5 = SW_SKRBAAE010_4P
T2 T8 T17 T91 T92 T94 T182 = TPC12: room: PCH
T3 T6 T7 T9-T13 T25 T26 T62 T63 T65 T121 T4936 T4938-T4942 = TPC12
T944 = TPC12: room: LAN
T4931 = TPC12: room: EC
TL2 = MHPC_NS892407_24P: room: LAN
