# Allegro board Dell_Inspiron_15_7577_Compal_CKA50_CKF50_LA_E992P_Rev_1_0_BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_MA13: length 99.3
  IN5 w0.076: 172.42,69.58 170.22,71.78 169.73,71.78 166.02,75.5 166.02,78.23 165.13,79.12 164.28,79.12 163.72,79.68 163.72,80.28 163.04,80.96 163.04,83.33 162.65,83.72 v2(162.55,83.72)
  IN5 w0.145: 172.42,69.58 173.11,68.9 173.35,68.9 173.68,69.23 173.92,69.23 174.09,69.06 174.09,68.82 173.76,68.49 173.76,68.25 173.93,68.08 174.17,68.08 174.5,68.41 174.74,68.41 174.91,68.24 174.91,68 174.58,67.67 174.58,67.43 175.07,66.93 175.46,66.93 175.63,67.1 175.63,67.55 175.8,67.72 176.04,67.72 176.21,67.55 176.21,67.1 176.38,66.93 178.56,66.93 185.17,60.32 188.63,60.32 189.18,59.78 197.33,59.78 197.56,60.01 209.84,60.01 210.61,59.24 211.49,59.24 212.63,58.11 212.79,58.11 224.81,46.08 224.81,41.23 223.46,39.88 223.46,37.49 223.29,37.32 v2(222.53,37.32)
  BOTTOM w0.076: UH1.AF9 v2(162.55,83.72)
  BOTTOM w0.213: v2(222.53,37.32) 222.3,37.32 220.58,35.6 JDIMM2.158
DDR_B_ODT0: length 97.9
  IN5 w0.076: v2(162.55,82.45) 162.87,82.12 162.87,80.89 163.55,80.21 163.55,79.61 164.21,78.96 165.06,78.96 165.83,78.18 165.83,75.45 171.71,69.58
  IN5 w0.145: 171.71,69.58 174.8,66.48 178.37,66.48 184.99,59.87 187.46,59.87 189.07,58.26 211.84,58.26 212.09,58.01 212.09,56.9 215.06,53.92 215.3,53.92 215.7,54.32 215.94,54.32 216.11,54.15 216.11,53.91 215.71,53.51 215.71,53.28 215.88,53.11 216.12,53.11 216.52,53.5 216.76,53.5 216.93,53.33 216.93,53.09 216.53,52.7 216.53,52.46 216.7,52.29 216.94,52.29 217.34,52.68 217.58,52.68 217.75,52.51 217.75,52.27 217.35,51.88 217.35,51.64 217.52,51.47 217.76,51.47 218.16,51.86 218.4,51.86 218.57,51.69 218.57,51.45 218.17,51.06 218.17,50.82 218.34,50.65 218.58,50.65 218.97,51.04 219.21,51.04 219.38,50.87 219.38,50.63 218.99,50.24 218.99,50 223.67,45.32 223.67,42.47 222.64,41.45 222.64,40.03 v2(222.54,39.93)
  BOTTOM w0.076: UH1.AF7 v2(162.55,82.45)
  BOTTOM w0.213: v2(222.54,39.93) 221.61,40.87 220.69,40.87 219.83,41.74 JDIMM2.155
DDR_B_ODT1: length 98.8
  IN5 w0.076: 172.27,72.67 169.45,72.67 166.35,75.77 166.35,79.67 164.99,81.03 164.47,81.03 163.87,81.63 163.87,82.03 v2(163.46,82.44)
  IN5 w0.145: v2(224.08,37.65) 225.59,39.16 225.59,40.24 226.53,41.18 226.53,41.54 226.84,41.86 226.84,45.32 213.16,59.01 213,59.01 211.87,60.14 210.98,60.14 210.22,60.9 198.37,60.9 198.1,61.18 191.81,61.18 191.17,61.81 189.6,61.81 189.01,61.22 185.67,61.22 174.22,72.67 172.27,72.67
  BOTTOM w0.076: v2(163.46,82.44) 163.15,82.75 UH1.AE8
  BOTTOM w0.213: JDIMM2.161 221.32,42.01 221.69,41.64 222.55,41.64 223.98,40.22 224.34,40.22 224.75,39.8 224.75,38.32 v2(224.08,37.65)
DDR_B_PAR: length 95.8
  IN5 w0.076: v2(159.81,82.42) 159.81,82.08 160.31,81.59 160.31,78.58 163.31,75.58 163.31,74.76 166.53,71.54 166.54,71.54 167.36,70.72 167.36,69.58
  IN5 w0.145: 167.36,69.58 167.36,65.74 170.73,62.37 173.34,62.37 178.4,57.31 178.4,57.07 177.76,56.43 177.76,56.19 177.93,56.02 178.17,56.02 178.81,56.66 179.05,56.66 179.22,56.49 179.22,56.25 178.58,55.61 178.58,55.37 178.75,55.2 178.99,55.2 179.63,55.84 179.87,55.84 180.04,55.67 180.04,55.43 179.4,54.79 179.4,54.55 179.57,54.38 179.81,54.38 180.45,55.02 180.69,55.02 181.06,54.66 181.06,54.42 180.63,53.99 180.63,53.78 180.83,53.58 181.04,53.58 181.47,54.01 181.71,54.01 182.17,53.54 184.52,53.54 184.54,53.52 209.42,53.52 209.51,53.43 209.54,53.43 217.1,45.86 217.11,45.84 217.11,45.21 217.1,45.21 217.1,40.44 v2(216.96,40.29)
  BOTTOM w0.089: UH1.AJ7 159.33,82.12 159.33,82.35 159.46,82.47 159.76,82.47 v2(159.81,82.42)
  BOTTOM w0.213: JDIMM2.143 214.83,41.99 216.33,40.48 216.76,40.48 v2(216.96,40.29)
DDR_B_RAS#: length 97.9
  IN5 w0.076: v2(160.72,84.37) 160.72,84.23 161.08,83.87 161.08,83.82 161.08,83.81 161.08,83.07 161.29,82.87 161.29,81.49 161.41,81.36 161.91,81.36 162.08,81.19 162.08,80.64 162.89,79.83 162.89,79.34 163.93,78.3 164.78,78.3 165.17,77.91 165.17,75.17 169.61,70.74 169.61,69.58
  IN5 w0.145: v2(220.64,37.62) 219.96,38.3 219.96,43.25 220.4,43.69 220.4,45.87 209.94,56.34 187.02,56.34 186.85,56.51 186.85,57.09 186.68,57.26 186.44,57.26 186.27,57.09 186.27,56.51 186.1,56.34 185.86,56.34 185.69,56.51 185.69,57.09 185.52,57.26 185.28,57.26 185.11,57.09 185.11,56.51 184.95,56.34 184.02,56.34 175.77,64.58 175.77,64.58 175.67,64.69 171.72,64.69 169.61,66.8 169.61,69.58
  BOTTOM w0.076: v2(160.72,84.37) 160.4,84.05 UH1.AH10
  BOTTOM w0.213: v2(220.64,37.62) 219.57,37.62 219.29,37.34 219.29,35.82 219.07,35.6 JDIMM2.152
DDR_B_WE#: length 93.5
  IN5 w0.076: 161.22,84.52 161.25,84.49 161.25,83.37 161.86,82.75 161.86,82.16 161.94,82.09 161.94,82.08 162.25,81.77 162.25,80.71 163.06,79.9 163.06,79.41 164,78.46 164.85,78.46 165.34,77.98 165.34,75.24 170.06,70.52 170.06,69.58
  IN5 w0.145: 161.22,84.52 v2(160.72,85.02) ; v2(220.64,40.23) 220.51,40.36 220.51,42.69 220.85,43.04 220.85,46.08 210.15,56.79 187.82,56.79 186.79,57.81 183.18,57.81 175.96,65.03 175.85,65.14 173.3,65.14 173.13,65.31 173.13,65.54 172.99,65.69 172.7,65.69 172.55,65.54 172.55,65.31 172.38,65.14 171.91,65.14 170.06,66.98 170.06,69.58
  BOTTOM w0.076: v2(160.72,85.02) 160.65,85.02 160.32,84.7 UH1.AH11
  BOTTOM w0.213: JDIMM2.151 218.83,41.59 219.11,41.3 219.11,40.6 219.67,40.05 220.46,40.05 v2(220.64,40.23)
DDR_RCOMP0: length 8.5
  BOTTOM w0.305: UH1.G1 176.85,78.05 176.85,77.35 177.01,77.18 177.01,77.15 177.29,76.88 177.32,76.88 177.46,76.74
  BOTTOM w0.508: 177.46,76.74 177.51,76.69 177.51,74.57 v2(176.06,73.12) 176.06,72.67 174.91,71.52 RH148.2
DDR_RCOMP1: length 5.8
  BOTTOM w0.254: 176.1,76.16 176.1,76.72 175.72,77.1 175.72,78.05 UH1.H1
  BOTTOM w0.381: 174.47,73.4 RH149.2
  BOTTOM w0.508: 174.47,73.4 174.47,73.89 v2(175.15,74.56) 176.1,75.52 176.1,76.16
DDR_RCOMP2: length 8.2
  BOTTOM w0.305: 176.8,76.48 176.8,76.7 176.28,77.22 v2(176.28,77.63) 176.28,78.32 175.96,78.64 175.75,78.64 UH1.J2
  BOTTOM w0.508: 176.8,76.48 176.8,74.82 175.2,73.22 175.2,72.86 174.74,72.4 RH150.2
DDR_VTT_PG_CTRL: length 5.9
  BOTTOM w0.14: UH1.BT13 138.97,86.92 UC1.2 136.01,86.92 135.85,86.76 v1(135.85,84.99)
DEBUG_CTL1: length 9.9
  IN3 w0.124: v2(352.98,66.89) 353.15,66.73 358.15,66.73 358.6,67.17 358.6,68.1 v2(359.98,69.48)
  BOTTOM w0.102: v2(359.98,69.48) 360.28,69.78 UT4.E4
  BOTTOM w0.14: v2(352.98,66.89) 353,66.91 RT66.2
DEBUG_CTL2: length 10.5
  IN3 w0.124: v2(360.6,68.92) 360.6,68.86 358.24,66.5 353.21,66.5 352.98,66.27 v2(352.64,66.27)
  BOTTOM w0.076: UT4.D5 360.94,69.18 360.68,68.92 v2(360.6,68.92)
  BOTTOM w0.14: RT67.2 v2(352.64,66.27)
DGPU_HOLD_RST#: length 112.1
  IN3 w0.124: v2(278.98,36.66) 278.54,36.22 277.79,36.22 277.77,36.24 276.57,36.24 275.28,37.53 273.28,37.53 272.96,37.85 272.96,40.16 272.01,41.11 272.01,45.71 271.68,46.04 271.68,52.33 271.19,52.82 271.19,59.3 265.63,64.87 236.14,64.87 235.74,65.27 230.45,65.27 228.39,67.33 223.57,67.33 222.2,68.7 221.27,68.7 217.27,72.7 213.34,72.7 210.8,75.24 210.05,75.24 208.91,76.38 205.02,76.38 204.01,75.38 203.19,75.38 202.54,74.72 v2(202.54,73.94)
  BOTTOM w0.089: v2(278.98,36.66) 279.36,37.04 UH2.AL36
  BOTTOM w0.14: RG165.2 202.25,71.31 202.4,71.17 202.75,71.17 202.79,71.21 202.79,71.21 203,71.42 203,71.8 202.43,72.38 202.43,73.83 v2(202.54,73.94) 202.6,74.01 202.6,74.21 UG10.1
DGPU_PEX_RST#: length 109.3
  TOP w0.089: RG584.1 206.58,82.78 206.1,82.3 206.1,82.21 v2(206,82.11)
  TOP w0.14: v2(196.06,64.09) 198.21,64.09 198.67,64.54 199.29,64.54 199.43,64.4 199.43,63.85 199.87,63.4 200.57,63.4 200.76,63.59 UG30.2 ; UG22.1 221.24,63.72 222.82,63.72 RG160.2 222.54,64.2 v2(222.54,65.71)
  IN1 w0.097: v2(206,82.11) 206,82.04 206.69,81.35 206.69,80.57 206.93,80.33 206.93,79.56 206.76,79.38 206.76,74.58 v2(207.84,73.5)
  IN3 w0.124: v2(199.16,71.85) 199.16,72.27 199.65,72.77 202.35,72.77 203.28,73.69 207.64,73.69 v2(207.84,73.5) 207.86,73.48 209.48,73.48 209.64,73.32 210.57,73.32 213.12,70.77 215.55,70.77 219.81,66.51 221.74,66.51 v2(222.54,65.71)
  IN4 w0.089: v2(198.83,95.25) 198.83,95.49 198.55,95.78
  IN4 w0.137: 200.32,77.09 200.32,76.62 199.85,76.15 196.59,76.15 195.3,74.86 v2(195.3,74.55) 195.7,74.15 195.7,71.59 196.43,70.86 196.43,70.17 197.26,69.34 197.26,66.13 196.06,64.94 v2(196.06,64.09) ; 200.32,77.09 200.32,77.12 199.87,77.56 198.54,77.56 197.82,78.28 197.82,87.43 198.32,87.93 198.32,93.84 197.56,94.59 197.56,95.58 197.93,95.95 198.38,95.95 198.55,95.78 ; 200.32,77.09 v2(200.31,77.09)
  BOTTOM w0.089: 199.12,95.64 199.12,95.71 199.62,96.21 199.67,96.21 200.08,96.61 200.4,96.61 200.58,96.8 201.1,96.8 UG9.BK26
  BOTTOM w0.127: v2(207.84,73.5) 206.93,73.5 v1(206.81,73.62)
  BOTTOM w0.14: 199.12,95.64 198.83,95.35 v2(198.83,95.25) ; 208.86,71.74 208.34,71.74 207.84,72.24 v2(207.84,73.5) ; 208.86,71.74 209.15,72.03 QG7.5 ; 208.86,71.74 208.86,71.72 209.15,71.43 QG7.2 ; QG6.5 199.25,70.89 198.92,71.22 198.92,71.61 v2(199.16,71.85) 199.25,71.94 QG6.2 199.25,72.96 199.3,73.01 199.3,73.24 199.62,73.56 199.62,73.71 199.85,73.95 200,73.95 200.52,74.46 200.52,75.01 200.51,75.02 200.51,75.09 200.27,75.33 RG562.1 200.14,76.1 200.14,76.94 200.32,77.12 200.32,77.09 v2(200.31,77.09) ; DG9.1 194.98,74.24 v2(195.3,74.55) 195.39,74.65 195.92,74.65 196.23,74.96 RG161.2
DGPU_PWR_EN: length 121.4
  TOP w0.14: v2(211.38,61.64) 210.99,61.24 RG551.1 ; RH129.1 273.19,37.73 273.66,37.73 274.04,38.12 274.99,38.12 275.78,37.33 277.58,37.33 277.99,37.73 v2(277.99,37.78) v1(278.6,37.18) 280.09,37.18 RH127.1
  IN3 w0.124: v2(277.99,37.78) 277.99,37.74 277.52,37.28 275.86,37.28 275.16,37.97 274.25,37.97 273.28,38.94 273.28,40.16 272.53,40.91 272.53,41.78 272.94,42.19 272.94,42.9 272.24,43.6 272.24,45.8 271.91,46.13 271.91,52.43 271.42,52.91 271.42,59.4 265.72,65.09 236.24,65.09 235.83,65.5 230.54,65.5 228.48,67.56 223.66,67.56 222.29,68.93 221.36,68.93 216.73,73.56 216.73,73.98 216.23,74.48 213.76,74.48 212.58,75.66 v2(210.22,75.66)
  IN4 w0.137: v2(210.22,75.66) 210.65,75.23 210.65,71.19 209.7,70.24 209.7,67.03 210.22,66.51 210.22,65.94 210.43,65.73 210.44,65.73 210.63,65.54 211.07,65.54 211.3,65.31 211.3,64.37 210.9,63.96 210.9,62.12 v2(211.38,61.64)
  BOTTOM w0.076: v2(277.99,37.78) 277.81,37.96 UH2.AJ39
DGPU_PWROK: length 147.9
  TOP w0.14: v2(278.68,37.81) 278.23,38.26 275.46,38.26 275.14,38.58 273.75,38.58 273.32,39.02 RH86.2 ; v2(213.84,59.44) 213.03,60.25 210.34,60.25 209.45,61.14 UG25.1
  TOP w0.254: v2(234.74,61.81) 235,61.55 v1(235,60.58) PR800.2 235,57.8 236.08,56.72 PU800.1
  IN1 w0.097: v2(234.74,61.81) 234.74,62.82 235.16,63.24 263.26,63.24 265.83,60.67 273.83,60.67 276.08,58.42 276.08,57.8 275.84,57.55 275.56,57.55 275.32,57.32 275.32,54.59 273.82,53.09 273.82,48.15 276.73,45.24 276.73,42.36 277.22,41.87 277.66,41.87 277.93,41.6 277.93,40.69 277.78,40.54 277.78,39.5 278.21,39.07 278.21,38.28 v2(278.68,37.81)
  IN3 w0.124: v2(213.84,59.44) 214.39,59.98 215.88,59.98 216.73,60.84 219.48,60.84 220.2,60.11 v2(222.48,60.11) ; v2(234.74,61.81) 233.92,62.63 228.59,62.63 227.28,63.95 218.34,63.95 216.26,66.03 216.26,66.57 214,68.83 213.1,68.83 212.5,69.43 210.52,69.43 210.16,69.79 210.16,70.46 209.16,71.45 204.62,71.45 v2(204.48,71.59)
  IN5 w0.097: v2(222.48,60.11) 222.48,61.22 223.13,61.86 229.07,61.86 230.14,62.93 234.29,62.93 234.74,62.49 v2(234.74,61.81)
  BOTTOM w0.076: UH2.AJ38 278.57,37.91 v2(278.68,37.81)
  BOTTOM w0.14: v2(204.48,71.59) 204.4,71.51 UG29.1
DGPU_ROM_SCLK: length 2
  BOTTOM w0.14: UG13.6 192.92,80.28 193.1,80.1 RG75.1
DGPU_ROM_SI: length 2.1
  BOTTOM w0.14: RG77.1 193.14,81.55 UG13.5
DGPU_ROM_SO_R: length 8.3
  BOTTOM w0.14: RG76.2 v2(190.22,82.25) 190.22,81.37 187.86,79.01 UG13.2
DISPOFF#: length 8.6
  TOP w0.14: v2(92.74,49.25) 92.76,49.23 RV566.2 v1(93.51,48.12)
  BOTTOM w0.14: JEDP1.17 v2(92.74,49.25) 91.44,49.25 90.88,49.81 RV536.1
DMI_CRX_PTX_N0: length 148.4
  IN4 w0.104: 178.5,82.2 178.49,82.21 178.49,82.24 178.41,82.31 178.39,82.31 178.16,82.54 178.16,82.77 v2(178.02,82.9)
  IN4 w0.147: v2(285.31,53.8) 285.12,53.99 284.98,53.99 284.76,54.21 284.76,55.22 284.69,55.29 284.69,58.7 283.85,59.55 280.53,59.55 272.82,67.25 271.6,67.25 268.3,70.56 249.54,70.56 248.89,71.21 235.8,71.21 230.65,66.06 230.65,63.28 226.83,59.46 226.42,59.46 222.24,55.27 222.24,54.93 221.38,54.07 203.2,54.07 202.16,55.11 199.44,55.11 197.9,56.65 194.32,56.65 191.54,59.44 191.54,64.1 190.79,64.84 190.79,66.38 189.75,67.43 188.92,67.43 185.14,71.2 185.14,73.75 180.8,78.08 180.8,79.81 179.69,80.92 179.69,80.96 179.41,81.24 179.41,81.43 178.5,82.2
  BOTTOM w0.076: v2(285.31,53.8) 285.11,54 285.01,54 284.92,53.91 284.92,52.54 284.51,52.14 284.51,51.6 284.2,51.28 UH2.C27 ; UH1.E8 177.7,82.57 v2(178.02,82.9)
DMI_CRX_PTX_N1: length 145.5
  IN4 w0.102: v2(177.42,82.11) 177.42,81.62 177.38,81.58 177.38,81.03 177.36,81.01 177.36,80.98 177.31,80.93 177.31,80.92
  IN4 w0.147: 177.31,80.92 177.31,80.17 179.28,78.21 179.28,77.55 183.69,73.15 183.69,70.6 189.31,64.97 189.31,59.41 189.76,58.96 189.76,56.29 191.6,54.45 198.04,54.45 198.84,53.66 201.56,53.66 202.6,52.62 223.75,52.62 229.4,58.26 229.4,59.65 232.1,62.36 232.1,63.08 238.58,69.55 248.44,69.55 249.03,68.96 267.84,68.96 271,65.8 271.68,65.8 282.79,54.69 282.79,54.08 283.06,53.81 284.24,53.81 v2(284.26,53.79)
  BOTTOM w0.076: UH2.B28 283.62,51.53 284,51.91 284,52.02 283.99,52.03 283.99,52.36 283.86,52.48 283.86,53.39 v2(284.26,53.79) ; UH1.F6 v2(177.42,82.11)
DMI_CRX_PTX_N2: length 145.5
  IN4 w0.102: v2(178.01,81.33) 178.01,81.17 178.26,80.92
  IN4 w0.147: v2(283.04,55.63) 283.01,55.63 272.11,66.53 271.3,66.53 268.14,69.69 268.02,69.69 268.02,69.69 249.33,69.69 248.64,70.38 237.4,70.38 231.38,64.36 231.38,62.98 224.34,55.94 224.34,54.68 223,53.34 202.9,53.34 201.86,54.38 199.14,54.38 198.35,55.18 191.9,55.18 190.81,56.27 190.81,58.94 190.04,59.71 190.04,66.11 189.45,66.7 188.61,66.7 184.41,70.9 184.41,73.45 180.04,77.82 180.04,79.14 178.26,80.92
  BOTTOM w0.076: v2(178.01,81.33) 178.01,81.24 UH1.E5 ; UH2.B29 283.1,51.51 282.98,51.38 282.82,51.38 282.73,51.47 282.73,51.64 283,51.91 283.16,51.91 283.22,51.97 283.22,54.41 283.62,54.81 283.62,55.02 283.6,55.03 283.6,55.04
  BOTTOM w0.14: v2(283.04,55.63) 283.04,55.7 283.12,55.78 283.42,55.78 283.58,55.63 283.58,55.15 283.6,55.15 283.6,55.04
DMI_CRX_PTX_N3: length 147.7
  IN4 w0.102: v2(176.01,83.71) 176.01,83.52 176.06,83.47 176.38,83.47 176.95,82.9 176.95,82.77 177.01,82.71 177.01,81.75 176.74,81.48 176.74,81.21 176.76,81.19 176.76,80.05 177.33,79.48
  IN4 w0.147: v2(281.25,55.05) 281.09,54.89 280.84,54.89 279.95,55.79 279.95,56.9 271.66,65.18 270.98,65.18 267.65,68.51 238.17,68.51 232.56,62.89 232.56,62.04 230.84,60.33 230.84,58.37 224.63,52.16 202.41,52.16 201.37,53.21 198.65,53.21 197.87,53.99 191.42,53.99 188.86,56.55 188.86,64.79 183.22,70.42 183.22,72.86 178.73,77.36 178.73,78.08 177.33,79.48
  BOTTOM w0.076: v2(176.01,83.71) 175.7,83.4 UH1.J9 ; UH2.B30 282.49,51.64 283.06,52.21 283.06,54.63 282.82,54.87 282.11,54.87 281.98,54.99 281.31,54.99 v2(281.25,55.05)
DMI_CRX_PTX_P0: length 148.5
  IN4 w0.104: 178.66,82.39 178.54,82.51 178.47,82.51 178.41,82.58 178.41,82.9 178.54,83.02 178.62,83.02 178.67,82.97 v2(178.67,82.9)
  IN4 w0.147: v2(285.31,54.38) 285.31,54.38 285.31,54.35 285.22,54.26 285.09,54.26 285.03,54.32 285.03,55.33 284.96,55.4 284.96,58.82 283.96,59.82 280.65,59.82 272.94,67.53 271.71,67.53 268.41,70.83 249.66,70.83 249,71.49 235.69,71.49 230.38,66.17 230.38,63.39 226.72,59.73 226.31,59.73 221.96,55.39 221.96,55.04 221.26,54.34 203.32,54.34 202.27,55.39 199.56,55.39 198.02,56.92 194.44,56.92 191.81,59.55 191.81,64.21 191.07,64.96 191.07,66.5 189.86,67.7 189.03,67.7 185.41,71.32 185.41,73.86 181.08,78.2 181.08,79.92 179.66,81.35 179.66,81.55 178.66,82.39
  BOTTOM w0.076: UH1.D8 178.35,82.57 v2(178.67,82.9) ; 284.81,54.1 284.75,54.04 284.75,52.61 284.34,52.2 284.34,51.66 284.21,51.53 284.14,51.53 284.1,51.56 UH2.B27
  BOTTOM w0.102: v2(285.31,54.38) 285.31,54.35 285.15,54.19 284.9,54.19 284.81,54.1
DMI_CRX_PTX_P1: length 145.6
  IN4 w0.102: 177.59,80.92 177.59,80.94 177.59,80.95 177.59,81.5 177.62,81.54 177.62,81.78 177.8,81.95 177.8,82.1 177.88,82.17 177.96,82.17 v2(178.02,82.11)
  IN4 w0.147: 177.59,80.92 177.59,80.29 179.55,78.32 179.55,77.67 183.96,73.26 183.96,70.72 189.59,65.09 189.59,59.53 190.04,59.08 190.04,56.41 191.72,54.73 198.16,54.73 198.95,53.93 201.67,53.93 202.71,52.89 223.64,52.89 229.12,58.38 229.12,59.76 231.83,62.47 231.83,63.2 238.46,69.83 248.55,69.83 249.15,69.24 267.95,69.24 271.11,66.08 271.79,66.08 283.07,54.8 283.07,54.22 283.21,54.09 283.56,54.09 283.95,54.48 284.16,54.48 v2(284.26,54.38)
  BOTTOM w0.076: v2(178.02,82.11) 178.02,82.04 UH1.E6 ; UH2.A28 283.76,52.04 283.82,52.1 283.82,52.29 283.69,52.42 283.69,53.5 283.88,53.69 283.88,53.94 284.14,54.19 284.2,54.19
  BOTTOM w0.102: 284.2,54.19 284.27,54.19 284.33,54.26 284.33,54.31 v2(284.26,54.38)
DMI_CRX_PTX_P2: length 145.4
  IN4 w0.102: 178.65,80.92 178.47,81.09 178.47,81.37 178.54,81.44 178.62,81.44 178.66,81.39 v2(178.66,81.33)
  IN4 w0.147: v2(283.04,56.21) 283.13,56.3 283.13,56.51 282.89,56.75 282.28,56.75 272.23,66.8 271.41,66.8 268.25,69.96 267.91,69.96 249.45,69.96 248.75,70.65 237.28,70.65 231.1,64.48 231.1,63.09 224.07,56.06 224.07,54.8 222.89,53.62 203.02,53.62 201.97,54.66 199.25,54.66 198.46,55.45 192.02,55.45 191.08,56.39 191.08,59.06 190.31,59.83 190.31,66.22 189.56,66.98 188.73,66.98 184.69,71.02 184.69,73.56 180.32,77.93 180.32,79.25 178.65,80.92
  BOTTOM w0.076: v2(178.66,81.33) 178.66,81.32 178.35,81.01 UH1.D5 ; 283.83,55.04 283.83,54.94 283.79,54.89 283.79,54.74 283.39,54.34 283.39,51.54 283.1,51.25 UH2.C29
  BOTTOM w0.14: v2(283.04,56.21) 283.22,56.04 283.53,56.04 283.83,55.73 283.83,55.04
DMI_CRX_PTX_P3: length 147.7
  IN4 w0.102: v2(176.07,82.9) 176.07,83.07 176.22,83.22 176.34,83.22 176.75,82.81 176.75,82.68 176.81,82.62 176.81,81.84 176.53,81.56 176.53,81.15 176.53,81.15 176.53,80.94 176.57,80.9 176.57,79.89 177.24,79.22 177.24,79.19 177.25,79.18
  IN4 w0.147: 177.25,79.18 178.45,77.97 178.45,77.24 182.95,72.75 182.95,70.31 188.59,64.67 188.59,56.44 191.31,53.72 197.75,53.72 198.54,52.93 201.26,52.93 202.3,51.89 224.75,51.89 231.12,58.26 231.12,60.22 232.83,61.93 232.83,62.78 238.28,68.23 267.53,68.23 270.86,64.9 271.55,64.9 279.67,56.78 279.67,55.67 280.73,54.62 281.1,54.62 v2(281.25,54.47)
  BOTTOM w0.076: UH2.A30 282.65,52.04 282.89,52.28 282.89,54.56 282.75,54.7 282.04,54.7 281.92,54.83 281.66,54.83 281.6,54.77 281.6,54.64 281.66,54.57 281.66,54.38 281.53,54.26 281.34,54.26 281.25,54.35 v2(281.25,54.47) ; UH1.J8 175.75,82.9 v2(176.07,82.9)
DMI_CTX_PRX_N0: length 164.7
  IN4 w0.147: v2(185.98,62.68) 185.16,62.68 185,62.51 185,62.51 184.62,62.13 184.62,61.3 185.64,60.28 185.64,55.28 190.24,50.67 196.69,50.67 197.52,49.84 200.24,49.84 201.09,48.98 203.97,48.98 204.29,48.66 225.64,48.66 232.15,55.17 233.11,55.17 234.47,56.53 234.47,57.49 235.75,58.77 235.75,59.69 241.3,65.24 266.42,65.24 273.32,58.34 273.32,54.5 272.93,54.11 272.93,49.3 274.9,47.33 278.74,47.33 278.97,47.1 278.97,46.46 280.34,45.1 284.39,45.1 285.15,45.86 285.15,47 284.89,47.26 283.98,47.26 283.76,47.49 v2(283.75,47.49)
  BOTTOM w0.076: v2(283.75,47.49) 284.12,47.12 UH2.L27 ; UH1.A8 180.23,82.44 180.01,82.44 179.94,82.51 179.94,82.73 180.01,82.81 181.32,82.81 181.33,82.79 181.38,82.79
  BOTTOM w0.14: v2(185.98,62.68) 185.98,62.93 186.08,63.03 186.4,63.03 186.54,62.89 186.54,62.51 186.67,62.39 187.05,62.39 187.17,62.51 187.17,68.14 183.19,72.13 183.19,73.74 183.18,73.75 183.18,74.42 183.19,74.42 183.19,79.01 182.52,79.68 182.52,82.45 182.19,82.79 181.82,82.79 181.8,82.76 181.72,82.76 181.69,82.79 181.38,82.79
DMI_CTX_PRX_N1: length 150.8
  IN4 w0.147: v2(185.33,66.69) 185.35,66.69 185.66,66.38 186.06,66.38 188.14,64.3 188.14,56.25 191.12,53.26 197.57,53.26 198.35,52.48 201.07,52.48 202.11,51.44 224.95,51.44 233.28,59.77 233.28,62.2 238.77,67.69 267.44,67.69 270.68,64.45 271.21,64.45 277.26,58.4 277.26,54.64 278.38,53.53 278.38,52.57 278.8,52.15 280.89,52.15 281.14,51.91 283.31,51.91 284.52,50.7 284.52,49.88 284.72,49.67 v2(284.87,49.73)
  BOTTOM w0.076: v2(284.87,49.73) 285.3,50.17 UH2.E24 ; 181.97,80.83 181.97,81.03 181.49,81.51 181.38,81.51 181.34,81.47 181.23,81.47 181.12,81.58 181.12,81.69 181.16,81.73 181.16,81.83 180.96,82.04 179.45,82.04 179.28,81.86 179.28,81.59 179.35,81.51 179.62,81.51 179.68,81.57 179.68,81.68 UH1.B6
  BOTTOM w0.14: 181.97,80.83 181.97,79.28 182.06,79.18 182.37,78.87 182.37,78.83 182.39,78.82 182.39,71.65 185.78,68.26 185.78,66.72 185.64,66.58 185.44,66.58 v2(185.33,66.69)
DMI_CTX_PRX_N2: length 148.7
  IN4 w0.147: v2(283.78,49.58) 283.63,49.74 283.12,49.74 282.56,50.3 279.3,50.3 278.97,49.97 278.13,49.97 277.86,50.24 277.06,50.24 276.63,50.67 276.63,53.47 276.24,53.85 276.24,58 270.79,63.45 270.26,63.45 267.02,66.69 240.7,66.69 234.28,60.28 234.28,59.36 225.36,50.44 201.7,50.44 200.74,51.39 198.02,51.39 197.15,52.26 190.71,52.26 187.13,55.84 187.13,63.88 185.84,65.18 184.69,65.18 183.91,65.96 v2(183.91,67.51)
  BOTTOM w0.076: UH1.A5 180.18,81.08 180.18,81.19 180.26,81.27 180.65,81.27 180.72,81.21 180.72,81.16 180.72,81.15 ; v2(283.78,49.58) 283.83,49.63 284.09,49.63 284.22,49.51 UH2.G27
  BOTTOM w0.14: v2(183.91,67.51) 183.75,67.51 183.58,67.68 183.58,67.94 183.69,68.05 184.09,68.05 184.24,68.21 184.24,68.79 181.69,71.35 181.69,76.85 181.71,76.85 181.71,78.32 181.36,78.67 181.36,80.52 180.72,81.15
DMI_CTX_PRX_N3: length 155
  IN4 w0.147: v2(185.41,64.51) 184.98,64.51 184.58,64.1 184.58,63.66 185.05,63.19 186.26,63.19 186.41,63.04 186.41,56.14 186.41,55.54 190.54,51.4 196.99,51.4 197.73,50.66 200.45,50.66 201.4,49.71 225.66,49.71 235.01,59.06 235.01,59.66 235.01,59.66 235.01,59.97 241,65.96 266.72,65.96 269.96,62.73 270.49,62.73 274.85,58.37 274.85,54.82 273.66,53.63 273.66,49.87 275.19,48.33 276.57,48.33 276.82,48.59 277.71,48.59 278.22,49.09 279.62,49.09 280,49.47 281.65,49.47 281.87,49.25 281.87,47.64 282.4,47.12 v2(282.41,47.12)
  BOTTOM w0.076: 181.01,80.17 181.01,80.17 180.98,80.21 180.98,80.25 180.95,80.28 180.95,80.37 180.68,80.64 180.05,80.64 179.76,80.35 179.64,80.35 179.42,80.57 179.09,80.57 178.97,80.45 178.97,80.3 179.06,80.22 UH1.B4 ; v2(282.41,47.12) 282.51,47.02 282.94,47.02 UH2.L29
  BOTTOM w0.14: 181.01,80.17 181.01,75.86 180.86,75.71 v3(180.86,74.03) 180.86,70.73 181.32,70.27 181.32,69.21 184.15,66.37 184.15,66.02 184.89,65.28 184.89,64.47 185.03,64.33 185.23,64.33 v2(185.41,64.51)
DMI_CTX_PRX_P0: length 164.7
  IN4 w0.147: v2(185.98,62.09) 185.96,62.07 185.96,61.71 185.84,61.6 185.64,61.6 185.51,61.72 185.51,62.21 185.4,62.31 185.19,62.31 184.9,62.01 184.9,61.41 185.91,60.4 185.91,55.39 190.36,50.95 196.8,50.95 197.64,50.11 200.35,50.11 201.21,49.26 204.09,49.26 204.41,48.94 225.53,48.94 232.04,55.45 233,55.45 234.19,56.64 234.19,57.6 235.48,58.88 235.48,59.8 241.19,65.51 266.54,65.51 273.6,58.45 273.6,54.38 273.2,53.99 273.2,49.42 275.02,47.6 278.86,47.6 279.25,47.21 279.25,46.57 280.45,45.37 284.28,45.37 284.88,45.97 284.88,46.85 284.75,46.99 284.54,46.99 284.4,46.85 284.4,46.48 284.25,46.33 283.89,46.33 283.76,46.46 v2(283.76,46.89)
  BOTTOM w0.076: v2(283.76,46.89) 284.22,46.44 UH2.N27 ; 181.38,83.05 181.37,83.05 181.32,82.99 181.3,82.99 181.28,82.97 179.94,82.97 179.77,82.8 179.77,82.63 UH1.B8
  BOTTOM w0.14: 181.38,83.05 181.79,83.05 181.82,83.02 182.32,83.02 182.77,82.56 182.77,79.78 183.44,79.11 v3(183.44,74.06) 183.44,72.23 187.43,68.24 187.43,62.41 187.11,62.09 v2(185.98,62.09)
DMI_CTX_PRX_P1: length 150.9
  IN4 w0.147: v2(284.87,49.1) 284.87,49.12 284.33,49.67 284.33,49.68 284.24,49.76 284.24,50.59 283.2,51.63 281.02,51.63 280.78,51.87 278.69,51.87 278.11,52.46 278.11,53.36 276.99,54.48 276.99,58.28 271.09,64.18 270.56,64.18 267.33,67.42 238.88,67.42 233.56,62.09 233.56,59.66 225.06,51.16 202,51.16 200.96,52.21 198.24,52.21 197.45,52.99 191.01,52.99 187.86,56.14 187.86,64.19 185.94,66.1 v2(185.33,66.1)
  BOTTOM w0.076: 182.22,81.01 181.03,82.2 179.52,82.2 179.38,82.2 179.11,81.93 179.11,81.83 UH1.C6 ; UH2.G24 285.01,49.1 v2(284.87,49.1)
  BOTTOM w0.14: v2(185.33,66.1) 185.55,66.32 185.74,66.32 186.03,66.61 186.03,68.36 182.64,71.75 182.64,78.93 182.22,79.35 182.22,81.01
DMI_CTX_PRX_P2: length 148.7
  IN4 w0.147: v2(283.71,50.31) 283.71,50.13 283.59,50.01 283.23,50.01 282.67,50.57 279.19,50.57 278.86,50.25 278.24,50.25 277.98,50.51 277.18,50.51 276.9,50.78 276.9,53.58 276.52,53.97 276.52,58.11 270.91,63.73 270.38,63.73 267.14,66.96 240.58,66.96 234.01,60.39 234.01,59.47 225.25,50.71 201.81,50.71 200.86,51.67 198.14,51.67 197.26,52.54 190.82,52.54 187.41,55.95 187.41,64 185.95,65.45 184.8,65.45 184.19,66.07 184.19,66.27 184.39,66.47 184.39,66.77 184.19,66.97 184.19,67.17 184.29,67.27 184.42,67.27 184.5,67.35 v2(184.5,67.51)
  BOTTOM w0.076: v2(283.71,50.31) 283.9,50.11 UH2.E26 ; UH1.B5 179.68,80.93 180.19,81.44 180.76,81.44 180.88,81.32
  BOTTOM w0.14: 180.88,81.32 181.59,80.62 181.59,78.77 181.94,78.41 181.94,71.45 184.5,68.9 v2(184.5,67.51)
DMI_CTX_PRX_P3: length 154.9
  IN4 w0.147: v2(185.41,63.92) 185.2,64.13 185,64.13 184.85,63.99 184.85,63.78 185.16,63.46 186.37,63.46 186.68,63.16 186.68,56.02 186.68,55.65 190.66,51.67 197.1,51.67 197.84,50.93 200.56,50.93 201.51,49.98 225.55,49.98 234.74,59.17 234.74,59.55 234.74,60.09 240.88,66.24 266.84,66.24 270.07,63 270.6,63 275.12,58.48 275.12,54.7 273.93,53.51 273.93,49.99 275.31,48.61 276.46,48.61 276.71,48.86 277.6,48.86 278.11,49.37 279.5,49.37 279.88,49.75 281.76,49.75 282.15,49.36 282.15,48.82 282.3,48.67 282.42,48.67 282.43,48.66 282.68,48.66 282.82,48.52 282.82,48.31 282.66,48.15 282.25,48.15 282.15,48.04 282.15,47.86 282.3,47.72 v2(282.41,47.72)
  BOTTOM w0.076: UH2.K29 282.87,47.72 v2(282.41,47.72) ; 180.79,80.17 180.79,80.3 180.61,80.47 180.12,80.47 179.54,79.9 178.83,79.9 UH1.D4
  BOTTOM w0.14: 180.79,80.17 180.79,75.98 180.61,75.81 180.61,74.32 180.6,74.32 180.6,73.79 180.61,73.78 180.61,70.62 181.06,70.17 181.06,69.1 183.9,66.27 183.9,65.91 184.63,65.18 184.63,64.36 184.92,64.08 185.25,64.08 v2(185.41,63.92)
DMIC_CLK: length 103
  TOP w0.14: v2(335.2,22.88) 335.4,22.68 335.4,22.38 335.7,22.07 336.1,22.07 336.35,21.82 CA30.1 337.19,21.43 LA1.1
  IN2 w0.097: v2(335.2,22.88) 335.02,22.7 327.46,22.7 320,30.16 313.5,30.16 312.24,31.43 312.24,37.01 308.34,40.91 308.34,43.98 312.25,47.89 312.25,51.61 312.19,51.67 307.37,56.49 304.31,56.49 302.55,58.25 298.5,58.25 293.92,62.83 292.14,62.83 v2(292.01,62.7)
  BOTTOM w0.14: v2(292.01,62.7) 292.01,62.52 291.87,62.39 289.57,62.39 287.83,64.12 v3(287.31,64.12) 285.75,64.12 285.15,63.53 285.15,62.86 286.17,61.84 EC5206.1 286.45,61.12 288.23,61.12 289.02,60.32 289.02,59.53 288.88,59.4 288.88,58.77 288.58,58.47 288.58,58.32 288.86,58.05 DA1.3 289.38,58.53 289.58,58.53 290.04,58.07 291.29,58.07 294.04,60.82 294.56,60.82 JCAM1.2
DMIC_CLK_R: length 3.8
  TOP w0.14: HDA1.3 340.83,21.46 340.44,21.86 v1(338.99,21.86) 338.37,21.86 LA1.2
DMIC_DAT: length 101.2
  TOP w0.14: RA27.1 337.21,22.46 336.75,22 336.54,22 336.21,22.34 335.81,22.34 335.66,22.49 335.66,22.75 v2(335.79,22.88)
  IN2 w0.097: v2(292.58,62.39) 292.8,62.61 293.83,62.61 298.41,58.03 302.46,58.03 304.22,56.26 307.28,56.26 312.03,51.51 312.03,47.98 308.12,44.07 308.12,40.82 312.01,36.92 312.01,31.33 313.41,29.94 319.9,29.94 327.37,22.47 335.37,22.47 335.77,22.88 v2(335.79,22.88)
  BOTTOM w0.14: JCAM1.3 293.85,61.53 293.85,61.01 291.17,58.33 290.15,58.33 289.76,58.73 289.76,58.93 290.24,59.41 ; 290.24,59.41 290,59.65 289.43,59.65 289.29,59.79 289.29,60.43 288.34,61.38 286.95,61.38 286.81,61.52 286.81,61.64 EC5205.1 286.36,62.03 v3(285.8,62.59) 285.42,62.97 285.42,63.42 285.86,63.86 287.72,63.86 289.46,62.12 291.98,62.12 292.14,62.28 292.19,62.28 292.29,62.38 292.32,62.38 292.33,62.39 v2(292.58,62.39) ; 290.24,59.41 DA1.2
DMIC_DATA_R: length 5.4
  TOP w0.127: HDA1.2 340.93,21.86 340.79,22
  TOP w0.14: 340.79,22 340.6,22.19 338.38,22.19 338.14,22.43 338.14,22.47 RA27.2 CA62.1 v1(339.07,23.4)
DP_CRT_B: length 116
  TOP w0.14: UVGA1.21 320.01,41.4 319.57,41.85 319.57,42.25 319.37,42.45 319.37,42.47 RVGA11.1 319.04,42.47 v2(318.73,42.17) ; LVGA3.1 CVGA18.1 v1(368.16,116.26) 367.41,116.26 v2(367.13,115.98)
  IN2 w0.097: v2(367.13,115.98) 367.13,115.46 361.02,109.35 361.02,84.38 362.05,83.35 362.05,78.46 359.14,75.55 356.73,75.55 354.09,72.9 354.09,71.96 353.73,71.6 352.98,71.6 350.48,69.1 350.48,62.55 349.27,61.34 348.19,61.34 347.98,61.14 345.13,61.14 342.3,58.31 336.43,58.31 334.52,56.4 331.24,56.4 328.97,54.13 326.43,54.13 322.3,50 322.3,47.08 321.31,46.09 321.31,45.95 321.8,45.45 321.8,45.31 321.67,45.18 321.53,45.18 321.03,45.68 320.9,45.68 320.76,45.54 320.76,45.4 321.26,44.91 321.26,44.77 321.12,44.63 320.99,44.63 320.49,45.13 320.35,45.13 318.73,43.51 v2(318.73,42.17)
DP_CRT_G: length 117.6
  TOP w0.14: LVGA2.1 CVGA17.1 367.99,120.48 v1(367.55,120.04) v2(366.67,119.15) ; v2(317.39,42.75) 317.79,42.75 RVGA12.1 318.07,41.99 318.42,41.65 319.14,41.65 319.61,41.18 UVGA1.22
  IN2 w0.097: v2(317.39,42.75) 321.9,47.26 321.9,51.09 325.34,54.53 328.73,54.53 331,56.8 334.35,56.8 336.27,58.71 342.06,58.71 344.89,61.54 347.82,61.54 348.16,61.87 349.24,61.87 350.07,62.71 350.07,69.46 356.62,76 359.02,76 361.65,78.63 361.65,83.18 360.62,84.22 360.62,109.59 366.67,115.64 366.67,119.15 v2(366.67,119.15)
DP_CRT_HSYNC_CON: length 111.8
  TOP w0.14: v2(323.06,46) 322.17,45.11 322.17,43.87 322.18,43.86 322.18,42.76 321.62,42.21 321.62,41.88 321.42,41.68 321.34,41.68 320.81,41.15 UVGA1.19 ; RVGA14.2 v1(369.01,118.16) v2(367.83,118.16)
  IN2 w0.097: v2(323.06,46) 323.19,46.13 323.19,47.78 323.58,48.18 323.58,50.71 326.6,53.73 329.14,53.73 331.4,56 334.68,56 336.6,57.91 342.47,57.91 345.29,60.73 348.15,60.73 348.36,60.94 349.44,60.94 350.88,62.38 350.88,68.93 353.15,71.2 353.97,71.2 355.41,72.64 355.41,73.65 356.9,75.15 359.31,75.15 362.45,78.29 362.45,83.51 361.42,84.55 361.42,109.18 367.83,115.59 v2(367.83,118.16)
DP_CRT_R: length 119.4
  TOP w0.14: LVGA1.1 CVGA16.1 370.24,123.17 369.27,122.2 v1(367.4,122.2) v2(366.31,122.2) ; UVGA1.23 319.21,40.92 318.93,41.2 317.82,41.2 RVGA13.1 316.55,42.52 v2(317.39,43.36)
  IN2 w0.097: v2(366.31,122.2) 366.26,122.16 366.26,115.8 360.22,109.75 360.22,84.05 361.25,83.02 361.25,78.79 358.86,76.4 356.45,76.4 345.12,65.07 345.12,62.34 341.9,59.11 336.1,59.11 334.19,57.2 330.83,57.2 328.57,54.93 325.17,54.93 321.5,51.26 321.5,47.47 v2(317.39,43.36)
DP_CRT_VSYNC_CON: length 109.4
  TOP w0.14: v2(323.19,45.39) 322.75,44.94 322.75,42.7 322.07,42.02 322.07,41.7 321.61,41.24 321.29,41.24 321.21,41.16 UVGA1.18 ; v2(368.97,115.28) v1(369.49,114.76) 370.41,113.85 RVGA15.2
  IN2 w0.097: v2(368.97,115.28) 368.15,115.28 361.82,108.95 361.82,84.72 362.86,83.68 362.86,78.13 359.47,74.74 357.07,74.74 355.81,73.48 355.81,72.47 354.14,70.8 353.31,70.8 351.28,68.77 351.28,62.21 349.6,60.54 348.52,60.54 348.32,60.33 345.46,60.33 342.63,57.51 336.76,57.51 334.85,55.59 331.57,55.59 329.3,53.33 326.76,53.33 323.98,50.55 323.98,48.01 323.7,47.72 323.7,45.77 323.31,45.39 v2(323.19,45.39)
DP_N0: length 1.9
  TOP w0.14: UVGA1.6 320.81,36 320.71,35.91 320.71,35.09 CVGA11.2
DP_N1: length 4.7
  TOP w0.14: UVGA1.8 321.61,36.04 321.53,35.96 321.53,35.77 321.7,35.6 321.96,35.6 322.59,34.98 v3(322.59,33.51) 322.59,32.84 CVGA13.2
DP_P0: length 1.9
  TOP w0.14: UVGA1.5 320.41,35.98 320.46,35.93 320.46,35.04 320.4,34.98 320.4,34.97 CVGA10.2
DP_P1: length 4.7
  TOP w0.14: UVGA1.7 321.21,36.05 321.28,35.98 321.28,35.67 321.6,35.35 321.85,35.35 v3(322.09,35.1) 322.33,34.86 322.33,33.75 322.33,33.75 322.33,33.22 322.33,33.21 322.33,32.84 CVGA12.2
DPSNK1_DDC_CLK: length 14.4
  TOP w0.14: v2(359.26,40.99) 358.69,41.56 358.38,41.56 358.23,41.71 RPT1.1
  IN4 w0.137: v2(357.74,50.62) 359.58,48.78 359.58,46.84 359.71,46.7 360.53,46.7 361.04,46.19 361.04,44.73 359.83,43.53 359.83,41.56 v2(359.26,40.99)
  BOTTOM w0.14: v2(357.74,50.62) UT1.Y5
DPSNK1_DDC_DATA: length 14.9
  TOP w0.14: RPT1.2 357.73,42.4 357.99,42.66 v2(357.99,43.08) 357.76,43.08 v1(357.32,43.53)
  IN4 w0.137: v2(357.99,43.08) 357.42,43.65 357.42,44.1 358.62,45.3 358.62,45.68 357.99,46.32 357.99,48.26 358,48.27 358,48.63 357.99,48.63 357.99,48.8 356.72,50.07 356.67,50.07 356.67,50.97 357.9,52.2 357.9,52.74 v2(358.38,53.22)
  BOTTOM w0.14: v2(358.38,53.22) 358.39,53.22 UT1.R4
DPSNK2_DDC_CLK: length 16.8
  TOP w0.14: v2(356.91,42.83) 357.23,42.51 RPT1.3
  IN4 w0.137: v2(355.77,51.91) 356.19,51.49 356.19,49.11 356.8,48.51 356.8,47.56 355.97,46.74 355.97,44.51 355.15,43.69 355.15,42.86 355.45,42.56 355.45,42 355.7,41.75 356.66,41.75 356.91,42 v2(356.91,42.83)
  BOTTOM w0.089: UT1.Y8 356.46,50.59 356.46,51.72 356.27,51.91 v2(355.77,51.91)
DPSNK2_DDC_DATA: length 14.8
  TOP w0.14: v2(356.15,42.2) 356.27,42.07 RPT1.4
  IN4 w0.137: v2(356.15,42.2) 355.39,42.96 355.39,43.59 356.21,44.41 356.21,46.64 357.04,47.46 357.04,48.61 356.43,49.21 356.43,51.07 357.61,52.25 357.61,53.09 v2(358.39,53.87)
  BOTTOM w0.14: UT1.N4 v2(358.39,53.87)
DPSNK_RBIAS: length 1.6
  TOP w0.14: v2(352.54,50.62) 352.54,49.81 RT19.1
  BOTTOM w0.089: UT1.Y18 v2(352.54,50.62)
DPSRC_RBIAS: length 1.3
  TOP w0.14: v2(357.09,53.22) 357.44,52.86 RT5.1
  BOTTOM w0.14: v2(357.09,53.22) UT1.N6
DSBL_GPU_PH1: length 2.5
  TOP w0.127: v2(173.19,128.6) v4(173.19,127.9)
  TOP w0.254: PR6103.1 v2(173.19,128.6)
  BOTTOM w0.254: v2(173.19,128.6) 173.61,128.6 173.8,128.8 PU6100.26
DSBL_GPU_PH2:
  vias: v1(172.17,136.81)
DSBL_GPU_PH3: length 1.2
  BOTTOM w0.14: PR6117.1 173.23,115.29 v1(172.98,115.04)
E51_TX2: length 5.5
  TOP w0.14: v2(340.97,41.87) RN4.1 RN5.2
  BOTTOM w0.14: v2(340.97,41.87) 338.85,41.87 338.18,42.55 JNGFF1.30
EAP: length 2.2
  TOP w0.203: PR6018.2 154.91,136.74 PU6000.29
EC_AC_BAT#: length 434.4
  TOP w0.089: v2(204.55,82.75) 205,82.3 205,82.06 204.78,81.83 204.78,79.36 v2(204.35,78.94) 205.09,78.19
  TOP w0.14: PR34.1 67.3,23.43 69.05,25.18 v2(69.05,29.02) ; v1(306.62,42.03) 306.46,42.18 DG8.2 306.93,43.32 v2(307.19,43.58) ; 205.09,78.19 205.18,78.1 RG16.1
  IN1 w0.097: v2(307.7,12.53) 306.56,13.66 304.95,13.66 302.73,15.89 301.31,15.89 301.04,15.62 292.73,15.62 292.28,15.17 285.87,15.17 284.77,14.07 284.25,14.07 283.39,14.94 281.55,14.94 280.49,13.87 277.94,13.87 277.27,14.54 274.03,14.54 273.72,14.22 271.4,14.22 268.84,16.78 264.63,16.78 256.73,24.68 253.59,24.68 252.57,25.7 240.35,25.7 237.97,28.08 171.91,28.08 171.45,28.54 163.6,28.54 162.78,27.72 143.16,27.72 141.16,29.72 122.34,29.72 121.25,28.64 107.84,28.64 106.3,30.18 99.98,30.18 99.56,29.76 v2(99.56,29.73)
  IN2 w0.097: v2(307.7,12.53) 307.62,12.6 307.62,15.87 307.15,16.34 307.15,18.8 307.68,19.33 307.68,24.86 307.43,25.11 307.43,26.19 308.9,27.66 308.9,29.75 309.17,30.01 309.17,31.07 307.98,32.26 307.98,38.85 307.19,39.64 v2(307.19,43.58)
  IN3 w0.124: v2(204.35,78.94) 205.64,78.94 206.8,77.78 206.8,77.37 207.18,76.99 210.77,76.99 212.36,78.58 217.55,78.58 222.61,73.53 222.61,72.33 223.53,71.4 225.21,71.4 225.65,70.96 228.23,70.96 231.69,67.5 236.66,67.5 237.07,67.09 266.61,67.09 273.42,60.28 273.42,53.74 273.91,53.25 273.91,48.67 275.7,46.87 275.7,44.23 276.75,43.18 282.09,43.18 284.02,45.11 286.6,45.11 287.85,43.87 287.85,43.36 288.48,42.72 289.32,42.72 290.49,43.89 294.78,43.89 295.29,44.4 296.84,44.4 297.2,44.77 306,44.77 v2(307.19,43.58)
  IN5 w0.097: v2(69.05,29.02) 69.22,28.86 82.74,28.86 84.63,30.75 98.54,30.75 v2(99.56,29.73)
  BOTTOM w0.1: UG9.BE6 v2(204.55,82.75)
EC_AGND: length 19.1
  TOP w0.14: CE81.2 305.96,28.81 v1(305.96,29.02)
  TOP w0.203: v2(308.2,21.17) 307.73,21.17 307.2,21.71 UE1.112 v2(307.2,24.22)
  TOP w0.254: v2(307.2,24.22) 307.2,25.6 CE98.2 RE14.1 306.69,27.05 CE81.2
  IN3 w0.508: v2(308.2,21.17) 307.6,21.17 307.2,21.57 v2(307.2,24.22)
  BOTTOM w0.381: v2(307.2,24.22) 307.2,24.22 CE87.2 307.02,25.94 306.12,26.84 CE107.2
  BOTTOM w0.406: v2(307.2,24.22) 307.67,23.75 CE104.2 RE124.1
  BOTTOM w0.457: RE67.2 307.76,20.73 v2(308.2,21.17)
EC_MUTE#: length 53.9
  TOP w0.127: 342.11,23.78 342.37,23.78 342.65,23.49 HDA1.47
  TOP w0.14: v2(336.53,24.86) 336.53,25.23 336.67,25.36 RA23.2 ; v2(331.26,27.27) v1(330.68,27.27) ; 342.11,23.78 341.85,23.78 341.54,23.47 v2(341.54,23.14)
  IN2 w0.097: v2(336.53,24.86) 336.53,26.3 335.4,27.43 331.42,27.43 v2(331.26,27.27)
  IN4 w0.137: v2(331.26,27.27) 327.13,27.27 327.12,27.27 310.1,27.27 308.56,25.73 308.56,23.56 307.11,22.11 307.11,20.38 308.01,19.48 v2(308.01,17.94) ; v2(341.54,23.14) 339.83,24.86 v2(336.53,24.86)
  BOTTOM w0.14: v2(308.01,17.94) 307.34,18.61 304.86,18.61 304.2,19.27 RE58.1
EDP_AUXN: length 165.3
  IN1 w0.102: v2(181.16,97.1) 181.01,97.25 181.01,97.4 181.21,97.6 181.36,97.6 181.48,97.48 181.67,97.48 181.76,97.57
  IN1 w0.104: v2(84.75,53.82) 84.75,53.81 84.37,53.43 84.04,53.43 83.86,53.61 83.86,55.44 85.4,56.98 85.4,63.08 86.26,63.94 101.94,63.94 103.08,65.08 104.79,65.08 104.99,64.89 109.37,64.89 110.36,65.88 111.8,65.88 113.91,67.99 118.75,67.99 120.22,69.46 120.22,80.86 135.17,95.81 135.17,100.46 135.64,100.94 135.64,105.88 140.79,111.03 159.63,111.03 159.78,111.18 175.53,111.18 176.51,110.2 183.04,110.2 185.08,108.16 185.08,105.44 182.98,103.34 182.98,98.66 181.89,97.57 181.76,97.57
  BOTTOM w0.076: UH1.B26 179.33,96.68 179.27,96.62 179.27,96.43 179.37,96.33 179.42,96.33 179.49,96.4 179.81,96.4 179.88,96.33 180.06,96.33 180.12,96.4 180.45,96.4 180.51,96.33 181.51,96.33 181.61,96.43 181.61,96.71 181.37,96.95 181.37,97.01 181.27,97.12 181.17,97.12 v2(181.16,97.1)
  BOTTOM w0.14: v2(84.75,53.82) 84.91,53.65 87.56,53.65 CV591.1
EDP_AUXN_C: length 6.7
  BOTTOM w0.14: JEDP1.26 94.66,53.75 94.53,53.62 89.2,53.62 CV591.2
EDP_AUXP: length 165.3
  IN1 w0.102: v2(181.74,97.1) 181.74,97.15 181.76,97.17
  IN1 w0.104: v2(84.75,53.23) 83.96,53.23 83.81,53.38 83.67,53.53 83.67,55.52 85.21,57.06 85.21,63.16 86.18,64.13 101.86,64.13 103,65.27 104.87,65.27 105.07,65.08 109.29,65.08 110.28,66.07 111.72,66.07 113.83,68.18 118.67,68.18 120.02,69.54 120.02,80.94 134.97,95.89 134.97,100.54 135.45,101.02 135.45,105.96 140.71,111.22 159.55,111.22 159.7,111.37 175.61,111.37 176.59,110.39 183.12,110.39 185.27,108.24 185.27,105.36 183.17,103.26 183.17,98.58 181.76,97.17
  BOTTOM w0.076: v2(181.74,97.1) 181.74,96.84 181.78,96.8 181.78,96.36 181.77,96.36 181.58,96.17 180.44,96.17 180.38,96.23 180.19,96.23 180.13,96.17 179.81,96.17 179.74,96.23 179.55,96.23 179.49,96.17 179.3,96.17 179.11,96.36 179.11,96.57 UH1.C26
  BOTTOM w0.14: v2(84.75,53.23) 84.91,53.4 87.56,53.4 CV592.1
EDP_AUXP_C: length 6.7
  BOTTOM w0.14: JEDP1.25 94.77,53.25 94.65,53.37 89.14,53.37 CV592.2
EDP_COMP: length 3
  TOP w0.127: v1(179.44,104.29) v2(178.4,104.29)
  TOP w0.508: RH30.1 177.59,103.72 178.15,104.29 v2(178.4,104.29)
  BOTTOM w0.305: UH1.D37 178.4,103.87 v2(178.4,104.29)
EDP_DISP_UTIL: length 161.9
  TOP w0.14: RH20.1 278.8,43.85 278.47,44.18 276.92,44.18 276.54,44.55 v1(271.6,44.55) 271.02,44.55 270.6,44.97 269.27,44.97 268.75,44.46 268.75,37.94 269.14,37.56 v2(269.41,37.56)
  IN1 w0.097: v2(184.09,102.31) 184.09,99.14 183.69,98.75 183.69,96.71 186.86,93.54 186.86,79.27 184.84,77.25 184.84,70.26 188.51,66.59 189.59,66.59 191.21,64.97 191.21,64.97 195.62,60.56 208.79,60.56 209.31,60.05 212.27,60.05 212.82,60.6 214.05,60.6 214.71,61.26 219.47,61.26 219.75,61.53 222.67,61.53 222.91,61.77 224.67,61.77 225.1,61.34 231.97,61.34 233.53,59.78 233.53,58.98 237.69,54.82 237.69,53.8 243.95,47.54 246.09,47.54 250.38,43.25 250.38,39.31 251.64,38.05 251.64,37.58 253.21,36.01 258.86,36.01 261.11,38.26 268.44,38.26 269.14,37.56 v2(269.41,37.56)
  BOTTOM w0.14: UH1.A33 180.33,101.88 183.66,101.88 v2(184.09,102.31)
EDP_HPD: length 239.6
  TOP w0.14: v2(92.23,49.85) v1(91.63,49.85)
  IN3 w0.124: v2(101.58,29.62) 102.3,30.35 108.34,30.35 109.34,29.35 113.5,29.35 114.66,30.51 136.32,30.51 137.36,29.46 155.57,29.46 155.96,29.85 190.85,29.85 191.51,29.2 210.06,29.2 210.49,28.77 221.8,28.77 223.07,30.04 244.92,30.04 245.6,30.71 253.45,30.71 254.65,29.52 256.5,29.52 260.29,25.73 264.75,25.73 265.84,24.64 283.36,24.64 283.68,24.96 287.06,24.96 290.39,28.29 290.81,28.29 292.45,29.93 v2(293.61,29.93)
  IN4 w0.137: v2(101.58,29.62) 100.84,30.36 98.12,30.36 96.11,32.36 96.11,32.6 95.76,32.96 94.66,32.96 90.44,37.18 90.44,43.52 88.11,45.85 88.11,48.23 89.2,49.32 91.7,49.32 v2(92.23,49.85)
  BOTTOM w0.076: UH2.BD7 293.63,30.62 293.63,30.04 293.61,30.03 v2(293.61,29.93)
  BOTTOM w0.14: RV551.1 91.31,50.76 v2(92.23,49.85) 92.33,49.75 JEDP1.18
EDP_TXN0: length 139.8
  IN1 w0.102: 177.06,103.54 177.06,103.54 177.06,103.52 177.64,102.94 177.64,102.28 177.38,102.03 177.38,101.78 177.38,101.78 177.38,101.35 177.64,101.1 177.64,99.15 177.57,99.09 177.27,99.09 177.2,99.02 177.2,98.77 177.33,98.65 v2(177.41,98.65)
  IN1 w0.104: v2(86.95,56.05) 86.95,56.11 86.88,56.18 86.56,56.18 86.5,56.11 86.5,55.73 86.43,55.66 86.22,55.66 86.06,55.82 86.06,56.29 86.43,56.67 105.02,56.67 109.38,61.02 110.84,61.02 110.9,61.09 111.1,61.09 111.5,61.49 115.18,65.17 119.55,65.17 122.78,68.4 122.78,79.85 128.18,85.25 131.17,85.25 132.05,86.13 132.78,86.13 136.64,90 136.64,91.11 138.98,93.44 138.98,96.2 139.49,96.71 139.49,99.72 138.18,101.03 138.18,104.45 141.27,107.54 174.84,107.54 176,106.39 176,104.61 177.06,103.54
  BOTTOM w0.076: UH1.E29 177.7,98.93 v2(177.41,98.65)
  BOTTOM w0.14: CV581.1 87.58,55.89 87.1,55.89 v2(86.95,56.05)
EDP_TXN0_C: length 7.1
  BOTTOM w0.14: JEDP1.29 94.57,55.25 94.44,55.12 92.98,55.12 92.81,54.96 90.44,54.96 89.62,55.78 89.27,55.78 CV581.2
EDP_TXN1: length 138.3
  IN1 w0.102: v2(178.03,97.84) 178.21,98.02 178.35,98.02 178.66,98.33 178.66,98.87 178.28,99.25 178.28,99.58 178.28,99.66 179.56,100.94 179.56,103.6
  IN1 w0.104: v2(87.16,58.13) 87.35,57.94 87.46,57.94 87.66,58.13 105.19,58.13 109.35,62.29 111.07,62.29 114.74,65.97 119.06,65.97 121.99,68.89 121.99,80.18 133.6,91.79 134.47,91.79 137.84,95.15 137.84,100.08 137.38,100.54 137.38,104.78 140.97,108.36 159.36,108.36 160.22,109.22 160.91,109.22 161.21,108.92 174.65,108.92 177.03,106.55 177.03,105.49 177.55,104.97 178.95,104.97 179.56,104.36 179.56,103.6
  BOTTOM w0.076: UH1.E28 177.7,98.15 178.01,97.84 v2(178.03,97.84)
  BOTTOM w0.14: CV586.1 87.56,58.04 87.25,58.04 v2(87.16,58.13)
EDP_TXN1_C: length 7.9
  BOTTOM w0.14: CV586.2 89.27,57.94 89.6,57.94 90.36,58.7 91.94,58.7 94.01,56.63 94.44,56.63 94.56,56.75 JEDP1.32
EDP_TXN2: length 141.4
  IN1 w0.102: v2(180.01,99.44) 180.01,99.23 179.91,99.13 179.66,99.13 179.57,99.23 179.57,99.86 180,100.3 181.24,100.3 181.76,100.82
  IN1 w0.104: v2(86.95,60.23) 87.11,60.06 87.85,60.06 87.94,59.97 106.08,59.97 106.08,59.99 110.96,64.86 112.22,64.86 113.92,66.57 118.76,66.57 121.39,69.2 121.39,80.59 135.74,94.95 136.73,94.95 137.2,95.42 137.2,99.83 136.78,100.25 136.78,105.03 140.75,109 159.03,109 160.2,110.17 175.03,110.17 176.17,109.03 178.89,109.03 181.86,106.05 181.86,100.91 181.76,100.82
  BOTTOM w0.076: v2(180.01,99.44) 180.01,99.31 179.74,99.04 UH1.B29
  BOTTOM w0.14: CV588.1 87.56,60.13 87.04,60.13 v2(86.95,60.23)
EDP_TXN2_C: length 7.5
  BOTTOM w0.14: JEDP1.35 94.56,58.25 94.44,58.13 94.02,58.13 92.11,60.04 89.27,60.04 CV588.2
EDP_TXN3: length 148.8
  IN1 w0.102: v2(179.99,97.86) 179.93,97.81 179.93,97.75 180,97.69 180.72,97.69 181.56,98.53 181.56,98.68 181.76,98.89
  IN1 w0.104: v2(86.95,62.32) 87.2,62.32 87.31,62.44 87.31,62.75 87.17,62.89 86.79,62.89 86.51,62.61 86.51,62 86.44,61.93 86.25,61.93 86.12,62.05 86.12,62.86 86.59,63.34 101.81,63.34 104.1,61.05 106.57,61.05 110.79,65.27 112.05,65.27 113.75,66.98 118.59,66.98 120.82,69.21 120.82,80.61 135.58,95.36 136.39,95.36 136.69,95.66 136.69,99.34 136.37,99.66 136.37,105.75 140.25,109.63 159.08,109.63 160.03,110.58 175.24,110.58 176.38,109.44 179.31,109.44 182.89,105.86 182.89,104.42 182.35,103.87 182.35,99.47 182.2,99.32 182.2,99.31 181.96,99.07 181.95,99.07 181.76,98.89
  BOTTOM w0.102: UH1.B28 179.65,98.1 179.88,97.86 v2(179.99,97.86)
  BOTTOM w0.14: CV590.1 87.56,62.16 87.1,62.16 v2(86.95,62.32)
EDP_TXN3_C: length 7.7
  BOTTOM w0.14: JEDP1.38 94.56,59.75 94.44,59.63 93.97,59.63 91.47,62.13 89.21,62.13 CV590.2
EDP_TXP0: length 139.8
  IN1 w0.102: v2(178.03,98.65) 178.03,98.89 177.9,99.02 177.84,99.09 177.84,101.18 177.59,101.44 177.59,101.86 177.58,101.95 177.84,102.2 177.84,103.03 177.31,103.55 177.28,103.6
  IN1 w0.104: v2(86.95,55.47) 86.14,55.47 85.86,55.74 85.86,56.37 86.35,56.86 104.94,56.86 109.3,61.22 110.76,61.22 110.82,61.28 111.02,61.28 111.42,61.69 115.1,65.37 119.47,65.37 122.59,68.48 122.59,68.49 122.58,68.5 122.58,68.63 122.59,68.64 122.59,79.93 128.1,85.44 131.09,85.44 131.97,86.32 132.7,86.32 136.45,90.08 136.45,91.19 138.78,93.52 138.78,96.28 139.29,96.79 139.29,99.64 137.98,100.95 137.98,104.53 141.19,107.73 174.92,107.73 176.19,106.47 176.19,104.69 177.27,103.61 177.28,103.6
  BOTTOM w0.076: v2(178.03,98.65) 178.03,98.72 178.35,99.04 UH1.D29
  BOTTOM w0.14: v2(86.95,55.47) 87.12,55.64 87.55,55.64 CV580.1
EDP_TXP0_C: length 7.1
  BOTTOM w0.14: CV580.2 89.08,55.53 89.51,55.53 90.34,54.7 92.92,54.7 93.09,54.87 94.44,54.87 94.56,54.75 JEDP1.28
EDP_TXP1: length 138.4
  IN1 w0.102: v2(177.44,97.86) 177.44,97.86 177.79,98.22 178.27,98.22 178.46,98.41 178.46,98.78 178.08,99.16 178.08,99.49 178.08,99.74 179.36,101.02 179.36,103.6
  IN1 w0.104: v2(87.16,57.55) 87.35,57.74 87.54,57.74 87.74,57.94 105.27,57.94 109.43,62.09 111.15,62.09 114.82,65.77 119.14,65.77 122.18,68.81 122.18,80.1 133.68,91.59 134.55,91.59 138.03,95.07 138.03,100.16 137.57,100.62 137.57,104.7 141.05,108.17 159.44,108.17 160.3,109.03 160.83,109.03 161.13,108.73 174.57,108.73 176.84,106.47 176.84,105.41 177.47,104.78 178.87,104.78 179.36,104.29 179.36,103.6
  BOTTOM w0.076: UH1.F28 177.44,97.86 v2(177.44,97.86)
  BOTTOM w0.14: v2(87.16,57.55) 87.38,57.77 87.58,57.77 CV585.1
EDP_TXP1_C: length 7.8
  BOTTOM w0.14: CV585.2 89.08,57.69 89.7,57.69 90.46,58.45 91.83,58.45 93.9,56.38 94.44,56.38 94.57,56.25 JEDP1.31
EDP_TXP2: length 141.4
  IN1 w0.102: 181.67,101.03 181.14,100.5 179.91,100.5 179.36,99.95 179.36,99.14 179.58,98.93 179.88,98.93 179.99,98.83 v2(179.99,98.63)
  IN1 w0.104: v2(86.95,59.64) 87.17,59.87 87.77,59.87 87.86,59.78 106.21,59.78 106.27,59.85 106.27,59.91 111.04,64.67 112.3,64.67 114,66.38 118.84,66.38 121.58,69.12 121.58,80.51 135.82,94.76 136.81,94.76 137.39,95.34 137.39,99.91 136.97,100.33 136.97,104.95 140.83,108.8 159.11,108.8 160.28,109.97 174.95,109.97 176.09,108.83 178.81,108.83 181.67,105.97 181.67,101.03
  BOTTOM w0.076: UH1.A29 180.3,98.96 179.99,98.65 v2(179.99,98.63)
  BOTTOM w0.14: v2(86.95,59.64) 87.15,59.85 87.59,59.85 CV587.1
EDP_TXP2_C: length 7.4
  BOTTOM w0.14: JEDP1.34 94.59,57.75 94.46,57.88 93.91,57.88 92.01,59.78 89.08,59.78 CV587.2
EDP_TXP3: length 148.8
  IN1 w0.102: v2(179.35,97.86) 179.35,97.83 179.7,97.48 180.8,97.48 181.76,98.44 181.76,98.6
  IN1 w0.104: 181.76,98.6 181.85,98.69 181.84,98.69 182.03,98.87 182.04,98.87 182.39,99.23 182.39,99.24 182.54,99.39 182.54,103.79 183.09,104.34 183.09,105.94 179.39,109.63 176.46,109.63 175.32,110.77 159.95,110.77 159,109.82 140.17,109.82 136.18,105.83 136.18,99.58 136.5,99.26 136.5,95.74 136.31,95.56 135.5,95.56 120.63,80.69 120.63,69.29 118.51,67.17 113.67,67.17 111.97,65.47 110.71,65.47 106.49,61.24 104.18,61.24 101.89,63.53 86.51,63.53 85.93,62.94 85.93,61.97 86.17,61.73 86.72,61.73 86.72,61.74 v2(86.95,61.74)
  BOTTOM w0.102: v2(179.35,97.86) 179.35,97.9 UH1.C28
  BOTTOM w0.14: v2(86.95,61.74) 87.12,61.91 87.56,61.91 CV589.1
EDP_TXP3_C: length 7.7
  BOTTOM w0.14: JEDP1.37 94.55,59.25 94.42,59.38 93.87,59.38 91.37,61.88 89.14,61.88 CV589.2
EN_0.6VSP: length 5
  TOP w0.14: v1(114.78,62.87) PC216.1
  TOP w0.203: PU200.7 113.83,66.78 114.13,66.49
  TOP w0.254: PC216.1 114.78,63.99 PR210.2 PR211.2 114.73,65.89 114.13,66.49
EN_1.0VS_VGAP: length 2.3
  BOTTOM w0.14: PR10V6.2 122.09,93.56 122.57,94.05 123.84,94.05 v1(124.05,93.83)
EN_1.2V: length 2.7
  TOP w0.203: PU200.8 114,67.18
  TOP w0.254: PC215.1 114.77,66.85 PR209.2 114.34,66.84 114,67.18
EN_1V: length 6
  TOP w0.14: PR103.2 249.34,38.12 248.84,38.61 v1(248.31,38.61)
  TOP w0.254: PR103.2 PR102.1 PC107.1 251.12,37.3 250.02,38.4 PU100.11
EN_2.5V: length 6.5
  TOP w0.14: v2(173.78,30.72) v4(175.02,30.72)
  BOTTOM w0.254: PU25V00.2 173.43,29.08 173.78,29.43 v2(173.78,30.72) 173.78,31 PR25V01.1 175.03,31.38 PC25V00.1 175.06,31.38 PR25V00.2
EN_+1.35V: length 4.9
  TOP w0.14: v1(232.96,56.61) 233.24,56.33 234.52,56.33 PR803.2
  TOP w0.254: PR803.2 234.99,55.83 PC800.1 235.05,54.96 235.81,55.72 PU800.3
EN_VCCIO: length 5.3
  BOTTOM w0.127: v1(129.17,105.67) PR4003.2
  BOTTOM w0.254: PR4003.2 128.2,105.62 PR4005.1 127.3,105.63 PC4011.1 126.42,105.23 126.72,104.93 126.72,103.91 126.49,103.69 PU4000.11
ENVDD: length 5.2
  TOP w0.14: v1(91.4,54.09) 91.67,54.36 DV3.1 91.1,55.84 90.97,55.72 90.34,55.72 90.14,55.91 UZ8.4 90.14,57.07 RZ40.1
ENVDD_PCH: length 219.8
  TOP w0.14: v2(92.85,55.97) 92.85,56.26 93.08,56.49 DV3.3 ; v2(99.29,51.54) 99.62,51.21 100.28,51.21 v1(100.76,51.69)
  IN4 w0.137: v2(276.25,42.47) 276.24,42.47 275.63,43.08 275.63,43.8 274.39,45.04 273.95,45.04 270.93,48.06 270.93,51.24 270.07,52.1 270.07,58.28 265.8,62.55 248,62.55 247.42,61.98 247.42,60.71 245.69,58.98 245.69,53.14 237.96,45.42 206.06,45.42 205.62,44.97 198.57,44.97 197.99,45.55 174.03,45.55 171.1,48.48 130.36,48.48 128.34,50.51 101.17,50.51 100.14,51.54 v2(99.29,51.54)
  IN5 w0.097: v2(99.29,51.54) 99.29,55.15 98.46,55.97 96.24,55.97 95.73,56.48 93.36,56.48 v2(92.85,55.97)
  BOTTOM w0.089: UH2.W42 276.25,42.68 v2(276.25,42.47)
ESPI_ALERT#: length 60.2
  TOP w0.14: UE1.55 309.6,6.25 311.06,4.8 v1(312.92,4.8) 313.48,4.8 313.86,5.17 313.86,7.39 v2(313.92,7.46)
  IN5 w0.097: v2(313.92,7.46) 313.92,9.87 317.61,13.55 317.61,15.33 315.44,17.49 313.09,17.49 312.52,16.92 307.82,16.92 304.78,19.97 304.78,22.82 304.46,23.14 304.46,24.86 304.2,25.11 302.68,25.11 301.6,24.03 300.19,24.03 300.02,24.2 300.02,25.69 299.43,26.28 297.32,26.28 296.84,26.76 296.84,27.52 295.82,28.54 294.41,28.54 292.32,30.64 291.38,30.64 290.58,31.43 v2(289.36,31.43)
  BOTTOM w0.076: v2(289.36,31.43) 289.09,31.7 289.09,32.14 UH2.BA17
  BOTTOM w0.14: RH578.1 313.09,7.65 313.28,7.46 v2(313.92,7.46)
ESPI_CLK: length 70.4
  TOP w0.14: v2(310.4,8.96) UE1.57
  IN1 w0.097: v2(293.97,9.93) 295.66,11.63 298.64,11.63 299.33,10.94 304.31,10.94 304.55,10.7 306.02,10.7 306.68,10.04 306.68,9.87 307.21,9.34 310.01,9.34 v2(310.4,8.96)
  IN5 w0.097: v2(289.08,20.61) 290.24,19.46 292.65,19.46 293.28,18.82 293.28,16.16 293.38,16.06 294.33,16.06 294.43,15.97 294.43,15.77 294.33,15.68 293.38,15.68 293.28,15.58 293.28,15.39 293.38,15.29 294.33,15.29 294.43,15.2 294.43,15 294.33,14.91 293.38,14.91 293.28,14.81 293.28,14.62 293.38,14.52 294.33,14.52 294.43,14.42 294.43,14.23 294.33,14.13 293.38,14.13 293.28,14.04 293.28,13.84 293.38,13.75 294.33,13.75 294.43,13.65 294.43,13.46 294.33,13.36 293.38,13.36 293.28,13.26 293.28,12.9 293.38,12.8 294.46,12.8 294.55,12.7 294.55,12.51 294.46,12.41 293.38,12.41 293.28,12.32 293.28,12.09 293.41,11.97 305.16,11.97 306.43,10.7 309.03,10.7 310.4,9.33 v2(310.4,8.96)
  BOTTOM w0.14: JESPI1.10 295.26,7.59 293.97,8.88 v2(293.97,9.93) ; v2(289.08,20.61) 289.08,21.37 CC4.2 288.81,21.76 288.81,23.16 287.85,24.13 287.85,25.05 288.04,25.24 288.04,25.94 RH168.2
