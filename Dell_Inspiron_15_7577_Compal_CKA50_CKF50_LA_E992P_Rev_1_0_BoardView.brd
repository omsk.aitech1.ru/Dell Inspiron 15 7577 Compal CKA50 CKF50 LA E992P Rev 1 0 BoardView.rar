# Allegro board Dell_Inspiron_15_7577_Compal_CKA50_CKF50_LA_E992P_Rev_1_0_BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_CS#0: length 65.3
  IN1 w0.076: 158.69,66.3 158.69,69.91 161.24,72.46 161.24,77.79 162.23,78.78 162.23,79.49 163.2,80.46 v2(164.21,80.46)
  IN1 w0.145: 158.69,66.3 158.69,57.15 158.33,56.78 158.33,56.78 158.17,56.62 157.94,56.62 157.76,56.81 157.53,56.81 157.37,56.64 157.37,56.42 157.55,56.23 157.55,56 157.39,55.84 157.16,55.84 156.98,56.03 156.75,56.03 156.59,55.86 156.59,55.64 156.77,55.45 156.77,55.22 156.61,55.06 156.38,55.06 156.2,55.25 155.97,55.25 155.81,55.08 155.81,54.86 155.99,54.67 155.99,54.44 155.83,54.28 155.6,54.28 155.42,54.47 155.19,54.47 155.03,54.3 155.03,54.08 155.21,53.89 155.21,53.66 155.05,53.5 154.82,53.5 154.64,53.69 154.41,53.69 154.25,53.52 154.25,53.3 154.43,53.11 154.43,52.88 154.27,52.72 154.04,52.72 153.86,52.91 153.63,52.91 153.47,52.75 153.47,52.52 153.65,52.33 153.65,52.1 149.45,47.9 149.45,47.67 149.63,47.49 149.63,47.26 149.47,47.1 149.24,47.1 149.06,47.28 148.83,47.28 148.67,47.12 148.67,46.9 148.85,46.71 148.85,46.48 148.69,46.32 148.46,46.32 148.28,46.51 148.05,46.51 147.89,46.34 147.89,46.12 148.07,45.93 148.07,45.7 147.91,45.54 147.68,45.54 147.5,45.73 147.27,45.73 147.11,45.56 147.11,45.34 147.3,45.15 147.3,44.92 147.13,44.76 146.91,44.76 146.72,44.95 146.49,44.95 144.77,43.23 144.77,40.45 145.66,39.56 v2(145.66,39.53)
  BOTTOM w0.076: UH1.AD5 163.88,80.79 v2(164.21,80.46)
  BOTTOM w0.213: JDIMM1.149 141.82,42.06 141.57,41.8 141.57,40.62 141.89,40.29 143.6,40.29 144.37,39.53 v2(145.66,39.53)
DDR_A_CS#1: length 68.8
  IN1 w0.076: 159.77,66.3 159.77,69.65 161.84,71.72 161.84,74.55 163.45,76.16 163.45,77.39 162.8,78.03 v2(162.58,78.03)
  IN1 w0.145: v2(145.62,38.26) 145.62,38.29 146.34,39.01 146.34,40.22 151.11,44.99 151.11,47.46 151.32,47.68 151.32,47.91 151.14,48.09 151.14,48.32 151.3,48.48 151.53,48.48 151.71,48.3 151.94,48.3 152.1,48.46 152.1,48.69 151.92,48.87 151.92,49.1 152.08,49.26 152.31,49.26 152.49,49.08 152.72,49.08 152.88,49.24 152.88,49.47 152.7,49.65 152.7,49.88 152.86,50.04 153.09,50.04 153.27,49.86 153.5,49.86 153.66,50.02 153.66,50.25 153.48,50.43 153.48,50.66 153.64,50.82 153.87,50.82 154.05,50.64 154.28,50.64 154.44,50.8 154.44,51.03 154.26,51.21 154.26,51.44 154.42,51.6 154.65,51.6 154.83,51.42 155.06,51.42 155.22,51.58 155.22,51.81 155.04,51.99 155.04,52.22 155.2,52.38 155.43,52.38 155.61,52.2 155.84,52.2 156,52.36 156,52.59 155.82,52.77 155.82,53 155.98,53.16 156.21,53.16 156.39,52.98 156.62,52.98 156.98,53.34 156.98,53.57 156.8,53.75 156.8,53.98 156.96,54.14 157.19,54.14 157.37,53.96 157.6,53.96 157.76,54.12 157.76,54.35 157.58,54.53 157.58,54.76 157.74,54.92 157.97,54.92 158.15,54.74 158.38,54.74 158.54,54.9 158.54,55.13 158.36,55.31 158.36,55.54 158.52,55.7 158.75,55.7 158.93,55.52 159.16,55.52 159.77,56.12 159.77,58.95 159.93,59.12 160.15,59.12 160.31,59.28 160.31,59.51 160.15,59.67 159.93,59.67 159.77,59.83 159.77,60.06 159.93,60.22 160.15,60.22 160.31,60.38 160.31,60.61 160.15,60.77 159.93,60.77 159.77,60.93 159.77,61.28 159.93,61.44 160.28,61.44 160.44,61.6 160.44,61.83 160.28,61.99 159.93,61.99 159.77,62.16 159.77,62.38 159.93,62.55 160.28,62.55 160.44,62.71 160.44,62.94 160.28,63.1 159.93,63.1 159.77,63.26 159.77,63.49 159.93,63.65 160.28,63.65 160.44,63.81 160.44,64.04 160.28,64.2 159.93,64.2 159.77,64.36 159.77,64.59 159.93,64.75 160.28,64.75 160.44,64.91 160.44,65.14 160.28,65.3 159.93,65.3 159.77,65.46 159.77,66.3
  BOTTOM w0.076: UH1.AE2 162.71,78.52 162.71,78.16 v2(162.58,78.03)
  BOTTOM w0.213: JDIMM1.157 143.82,41.94 144.46,41.3 144.88,41.3 145.02,41.44 145.83,41.44 146.22,41.05 146.22,39.94 146.3,39.86 146.3,38.77 145.85,38.33 145.69,38.33 v2(145.62,38.26)
DDR_A_D0: length 71.9
  IN1 w0.097: v2(103.73,39.74) 103.73,39.85 102.82,40.77 102.82,44.96 102.89,45.03 102.89,46.8 103.56,47.47 103.57,47.48 116.05,59.96 116.66,59.96 118.13,61.44 120.87,61.44 122.4,62.96 122.56,62.96 122.86,62.66 123.02,62.66 123.14,62.77 123.14,62.93 122.83,63.24 122.83,63.4 122.94,63.51 123.1,63.51 123.41,63.2 123.57,63.2 123.68,63.32 123.68,63.48 123.38,63.78 123.38,63.94 123.49,64.05 123.65,64.05 123.96,63.75 124.12,63.75 124.23,63.86 124.23,64.02 123.92,64.33 123.92,64.49 126.01,66.57 126.01,74.59 128.26,76.84 132.53,76.84 136.07,80.37 137.15,80.37 v2(137.42,80.11)
  BOTTOM w0.076: UH1.BR6 140.24,81.47 139.4,81.47 139.35,81.42 138.93,81.42 138.73,81.62 138.1,81.62 137.1,80.62 137.1,80.25 137.22,80.13 137.4,80.13 v2(137.42,80.11)
  BOTTOM w0.14: JDIMM1.7 104.33,41.82 104.26,41.75 104.26,40.06 103.94,39.74 v2(103.73,39.74)
DDR_A_D1: length 71.5
  IN1 w0.097: v2(139.15,81.78) 138.91,81.54 137.94,81.54 137.37,80.97 135.82,80.97 132.73,77.88 131.92,77.88 131.8,77.99 131.8,78.34 131.69,78.45 131.53,78.45 131.42,78.34 131.42,77.99 131.31,77.88 130.98,77.88 130.87,77.77 130.87,77.61 130.76,77.5 130.6,77.5 130.48,77.61 130.48,77.77 130.37,77.88 130.21,77.88 130.1,77.77 130.1,77.61 129.98,77.5 129.82,77.5 129.71,77.61 129.71,77.77 129.6,77.88 129.44,77.88 129.32,77.77 129.32,77.61 129.15,77.44 128.01,77.44 125.41,74.84 125.41,66.84 120.61,62.04 117.89,62.04 116.41,60.56 115.79,60.56 102.21,46.99 102.21,44.42 102.21,44.41 102.21,40.43 102.91,39.73 102.91,37.81 v2(103.73,36.99)
  BOTTOM w0.076: UH1.BT6 v2(139.15,81.78)
  BOTTOM w0.14: v2(103.73,36.99) 103.58,36.83 JDIMM1.4
DDR_A_D2: length 71.4
  IN1 w0.097: v2(138.58,78.75) 138.58,78.07 137.48,76.96 137.1,76.96 136.95,77.11 136.42,77.11 136.09,76.79 136.09,67.34 133.93,65.18 132.04,65.18 130.2,63.35 130.2,63.17 130.38,62.98 130.38,62.82 130.27,62.71 130.11,62.71 129.93,62.89 129.77,62.89 129.66,62.78 129.66,62.62 129.84,62.44 129.84,62.28 129.72,62.17 129.56,62.17 129.38,62.35 129.22,62.35 129.11,62.23 129.11,62.07 129.29,61.89 129.29,61.73 129.18,61.62 129.02,61.62 128.84,61.8 128.68,61.8 128.56,61.69 128.56,61.53 128.75,61.35 128.75,61.19 128.63,61.07 128.47,61.07 128.29,61.25 128.13,61.25 128.02,61.14 128.02,60.98 128.2,60.8 128.2,60.64 128.09,60.53 127.93,60.53 127.74,60.71 127.58,60.71 127.47,60.6 127.47,60.44 127.65,60.25 127.65,60.09 127.54,59.98 127.38,59.98 127.2,60.16 127.04,60.16 126.93,60.05 126.93,59.89 127.11,59.71 127.11,59.55 126.99,59.43 126.83,59.43 126.65,59.62 126.49,59.62 125.77,58.89 119.2,58.89 107.55,47.23 107.55,38.39 v2(107.1,37.94)
  BOTTOM w0.076: 138.58,79.41 138.58,79.42 138.91,79.75 139.3,79.75 139.43,79.88 140.18,79.88 140.23,79.93 140.7,79.93 140.96,79.67 UH1.BP3
  BOTTOM w0.14: v2(107.1,37.94) 107.16,37.94 107.49,37.62 107.49,37.57 107.61,37.45 107.61,35.59 107.58,35.56 JDIMM1.20 ; 138.58,79.41 v2(138.58,78.75)
DDR_A_D3: length 71.8
  IN1 w0.097: v2(107.1,39.27) 106.29,40.08 106.29,46.84 118.94,59.49 124.27,59.49 124.92,60.14 125.08,60.14 125.46,59.76 125.62,59.76 125.73,59.87 125.73,60.03 125.35,60.41 125.35,60.57 125.47,60.68 125.63,60.68 126,60.3 126.16,60.3 126.28,60.42 126.28,60.58 125.9,60.96 125.9,61.12 126.01,61.23 126.17,61.23 126.55,60.85 126.71,60.85 126.82,60.96 126.82,61.12 126.44,61.5 126.44,61.66 126.56,61.78 126.72,61.78 127.1,61.4 127.26,61.4 127.37,61.51 127.37,61.67 126.99,62.05 126.99,62.21 127.1,62.32 127.26,62.32 127.64,61.94 127.8,61.94 127.92,62.06 127.92,62.22 127.54,62.6 127.54,62.86 127.96,63.28 127.96,64 129.74,65.78 133.68,65.78 135.35,67.45 135.35,68.05 135.34,68.05 135.34,76.89 136.17,77.72 137,77.72 137.1,77.82 137.11,77.82 137.57,78.29 138.12,78.29 v2(138.15,78.25)
  BOTTOM w0.076: UH1.BR3 140.32,79.57 140.22,79.57 139.75,79.1 139.49,79.1 139.09,78.71 139.09,78.6
  BOTTOM w0.14: v2(138.15,78.25) 138.74,78.25 139.09,78.6 ; JDIMM1.21 107.83,42.03 107.71,41.91 107.71,39.88 v2(107.1,39.27)
DDR_A_D4: length 72.1
  IN1 w0.097: v2(103.71,41.04) 103.19,41.55 103.19,46.68 103.84,47.33 103.84,47.34 116.17,59.66 116.79,59.66 118.26,61.14 121.93,61.14 124.76,63.97 124.92,63.97 125.03,64.08 125.03,64.24 124.69,64.58 124.69,64.74 124.8,64.85 124.96,64.85 125.3,64.51 125.46,64.51 125.58,64.62 125.58,64.78 125.24,65.12 125.24,65.28 125.35,65.4 125.51,65.4 125.85,65.06 126.01,65.06 126.12,65.17 126.12,65.33 125.78,65.67 125.78,65.83 125.9,65.94 126.06,65.94 126.39,65.6 126.56,65.6 127.17,66.22 127.17,66.38 126.89,66.65 126.89,66.81 127.01,66.92 127.17,66.92 127.44,66.65 127.6,66.65 128.38,67.43 132.67,67.43 133.67,68.43 133.67,77.55 135.7,79.58 v2(136.54,79.58)
  BOTTOM w0.076: 136.78,80.54 138.13,81.88 138.52,81.88 138.85,82.21 139.65,82.21 139.88,81.98 140.92,81.98 141.3,81.6 141.3,81.49 UH1.BN5
  BOTTOM w0.14: v2(136.54,79.58) 136.54,80.29 136.78,80.54 ; v2(103.71,41.04) 103.35,41.04 103.24,41.15 103.24,41.91 103.33,42 JDIMM1.3
DDR_A_D5: length 71.6
  IN1 w0.097: v2(103.76,38.37) 103.29,38.84 103.29,39.78 102.51,40.56 102.51,46.86 115.91,60.26 116.54,60.26 118.01,61.74 120.74,61.74 125.71,66.7 125.71,74.71 128.13,77.14 131.29,77.14 131.41,77.25 131.41,77.45 131.52,77.56 131.68,77.56 131.79,77.45 131.79,77.25 131.9,77.14 132.41,77.14 135.94,80.67 v2(137.9,80.67)
  BOTTOM w0.076: UH1.BP6 141.01,81.48 140.62,81.09 140.22,81.09 140.14,81.17 140.09,81.17 139.95,81.31 139.53,81.31 139.47,81.26 138.8,81.26 138.65,81.42 138.31,81.42 137.9,81 v2(137.9,80.67)
  BOTTOM w0.14: v2(103.76,38.37) 104.58,37.55 JDIMM1.8
DDR_A_D6: length 72.2
  IN1 w0.097: v2(107.1,36.67) 107.1,36.72 107.85,37.47 107.85,47.11 119.34,58.59 126.57,58.59 127.42,59.44 127.58,59.44 127.63,59.39 127.79,59.39 127.9,59.5 127.9,59.66 127.85,59.71 127.85,59.87 127.97,59.98 128.13,59.98 128.17,59.93 128.33,59.93 128.45,60.05 128.45,60.21 128.4,60.25 128.4,60.41 128.51,60.53 128.67,60.53 128.72,60.48 128.88,60.48 128.99,60.59 128.99,60.75 128.95,60.8 128.95,60.96 129.06,61.07 129.22,61.07 129.27,61.03 129.43,61.03 129.54,61.14 129.54,61.3 129.49,61.35 129.49,61.51 129.6,61.62 129.76,61.62 129.81,61.57 129.97,61.57 130.09,61.68 130.09,61.84 130.04,61.89 130.04,62.05 130.15,62.17 130.31,62.17 130.36,62.12 130.52,62.12 130.63,62.23 130.63,62.39 130.58,62.44 130.58,62.6 131.15,63.17 131.31,63.17 131.71,62.76 131.87,62.76 131.98,62.88 131.98,63.04 131.3,63.72 131.3,63.86 131.44,63.99 131.58,63.99 132.26,63.31 132.42,63.31 132.53,63.42 132.53,63.58 131.94,64.18 131.94,64.31 132.08,64.45 132.21,64.45 132.8,63.86 132.96,63.86 133.08,63.97 133.08,64.13 132.68,64.53 132.68,64.69 132.87,64.88 134.05,64.88 136.39,67.22 136.39,67.47 136.39,75.69 136.41,75.71 136.41,76.33 v2(136.79,76.71)
  BOTTOM w0.076: UH1.BP2 141.02,78.79 140.57,78.34 140.57,78.05 140.37,77.86 140.21,77.86 139.55,77.2 139.16,77.2 139,77.04
  BOTTOM w0.14: 139,77.04 138.67,76.71 v2(136.79,76.71) ; JDIMM1.16 106.58,36.19 107.06,36.67 v2(107.1,36.67)
DDR_A_D7: length 71.5
  IN1 w0.097: v2(137.27,77.42) 136.3,77.42 135.75,76.87 135.75,67.43 133.8,65.48 131.91,65.48 130.65,64.22 130.49,64.22 129.8,64.92 129.61,64.92 129.5,64.81 129.5,64.67 130.22,63.95 130.22,63.79 130.11,63.68 129.95,63.68 129.23,64.4 129.07,64.4 128.96,64.28 128.96,64.12 129.68,63.4 129.68,63.27 129.58,63.17 129.44,63.17 128.8,63.81 128.64,63.81 128.53,63.7 128.53,63.54 129.13,62.94 129.13,62.7 129.02,62.58 128.86,62.58 128.46,62.99 128.3,62.99 128.18,62.87 128.18,62.71 128.58,62.31 128.58,62.15 125.62,59.19 119.07,59.19 106.59,46.71 106.59,43.35 106.71,43.24 106.99,43.24 107.1,43.12 107.1,42.96 106.99,42.85 106.71,42.85 106.59,42.74 106.59,41.22 v2(107.12,40.7)
  BOTTOM w0.076: 139.09,77.97 139.43,77.97 140.01,78.56 140.01,78.66 140.01,79.01 140.03,79.04 140.23,79.24 140.29,79.24 141.54,79.49 UH1.BN3
  BOTTOM w0.14: v2(137.27,77.42) 138.14,77.42 138.69,77.97 139.09,77.97 ; v2(107.12,40.7) 106.92,40.7 106.67,40.95 106.67,41.7 106.83,41.85 JDIMM1.17
DDR_A_D8: length 66.7
  IN1 w0.076: 139.09,76.34 139.2,76.44 139.2,76.47 139.31,76.58 139.33,76.58 141.81,79.06 142.55,79.06 v2(143.3,79.81)
  IN1 w0.097: v2(108.36,38.95) 109.2,39.79 109.2,46.55 119.91,57.26 128.31,57.26 128.7,57.65 128.7,57.81 128.52,57.99 128.52,58.15 128.64,58.27 128.8,58.27 128.98,58.08 129.14,58.08 134.09,63.04 134.09,63.04 137.79,66.74 137.79,75.05 137.97,75.23 139.08,76.34 139.09,76.34
  BOTTOM w0.076: v2(143.3,79.81) 142.98,80.14 UH1.BL4
  BOTTOM w0.14: JDIMM1.28 109.58,37.79 108.41,38.95 v2(108.36,38.95)
DDR_A_D9: length 66.7
  IN1 w0.076: 139.38,76.4 141.88,78.9 142.89,78.9 143.66,79.66 143.66,80.04 143.3,80.39 v2(143.3,80.46)
  IN1 w0.097: 139.38,76.4 139.38,76.22 138.09,74.93 138.09,66.61 128.42,56.94 120.03,56.94 109.54,46.46 109.54,38.86 v2(108.36,37.68)
  BOTTOM w0.076: UH1.BL5 142.98,80.79 v2(143.3,80.46)
  BOTTOM w0.14: JDIMM1.24 108.58,37.54 108.43,37.68 v2(108.36,37.68)
DDR_A_D10: length 67.1
  IN1 w0.076: v2(141.26,76.98) 141.26,76.98 141.26,75.97 139.87,74.58 139.87,72.48 140.54,71.81 140.54,70.99
  IN1 w0.097: 140.54,70.99 140.54,65.79 129.44,54.69 120.98,54.69 120.51,54.22 120.51,53.98 120.65,53.84 120.65,53.71 120.51,53.57 120.37,53.57 120.23,53.71 120.07,53.71 119.96,53.59 119.96,53.43 120.31,53.09 120.31,52.93 120.2,52.81 120.04,52.81 119.69,53.16 119.53,53.16 119.42,53.05 119.42,52.89 119.76,52.54 119.76,52.38 113.63,46.25 112.66,46.25 111.96,45.55 111.96,39.8 111.28,39.12 v2(110.95,39.12)
  BOTTOM w0.076: UH1.BL2 142.86,78.1 141.74,76.98 v2(141.26,76.98)
  BOTTOM w0.14: JDIMM1.38 112.07,35.71 112.5,36.13 112.5,38.09 111.47,39.12 v2(110.95,39.12)
DDR_A_D11: length 66.5
  IN1 w0.076: 140.84,70.99 140.84,71.96 140.18,72.61 140.18,74.64 141.67,76.13 v2(141.67,77.41)
  IN1 w0.097: 140.84,70.99 140.84,65.66 129.56,54.38 122.55,54.38 122.55,54.38 122.27,54.38 121.8,53.91 121.64,53.91 121.37,54.18 121.21,54.18 121.1,54.07 121.1,53.91 121.37,53.64 121.37,53.48 113.02,45.13 112.86,45.13 112.78,45.2 112.65,45.2 112.51,45.06 112.51,44.93 112.59,44.85 112.59,44.69 112.27,44.38 112.27,38.98 112.16,38.87 111.79,38.87 111.68,38.76 111.68,38.6 111.79,38.48 112.16,38.48 112.27,38.37 112.27,38.21 112.16,38.1 111.79,38.1 111.68,37.98 111.68,37.82 111.79,37.71 112.16,37.71 112.27,37.6 112.27,37.44 112.16,37.32 111.79,37.32 111.7,37.23 111.7,36.95 111.79,36.86 112.8,36.86 v2(113.71,35.95)
  BOTTOM w0.076: v2(141.67,77.41) 141.68,77.56 142.36,78.19 UH1.BM1
  BOTTOM w0.14: v2(113.71,35.95) 113.28,35.95 113.07,35.75 JDIMM1.42
DDR_A_D12: length 66.3
  IN1 w0.076: 139.49,77.07 141.82,79.4 142.05,79.4 142.76,80.11 142.76,80.44 143.13,80.82 143.52,80.82 143.66,80.67 143.66,80.36 144.09,79.93 v2(144.09,79.81)
  IN1 w0.097: v2(108.28,40.15) 108.8,40.15 108.89,40.24 108.89,46.68 119.78,57.56 127.48,57.56 128.69,58.76 129.39,58.76 133.97,63.34 137.49,66.86 137.49,75.18 139.38,77.07 139.49,77.07
  BOTTOM w0.076: UH1.BK4 v2(144.09,79.81)
  BOTTOM w0.14: v2(108.28,40.15) 108.74,40.15 109.83,41.23 JDIMM1.29
DDR_A_D13: length 66.5
  IN1 w0.076: 139.09,77.36 142.05,80.32 142.05,80.47 142.56,80.98 143.69,80.98 143.7,80.99 143.71,80.99 144.09,80.61 v2(144.09,80.46)
  IN1 w0.097: 139.09,77.36 137.12,75.39 137.12,67.52 137.12,67.52 137.12,66.92 133.84,63.64 131.88,61.68 131.72,61.68 131.5,61.9 131.34,61.9 131.23,61.79 131.23,61.63 131.45,61.41 131.45,61.25 131.34,61.13 131.18,61.13 130.95,61.36 130.79,61.36 130.68,61.25 130.68,61.09 130.91,60.86 130.91,60.7 130.68,60.48 130.52,60.48 130.32,60.68 130.16,60.68 130.05,60.57 130.05,60.41 130.25,60.21 130.25,60.05 130.14,59.93 129.98,59.93 129.77,60.13 129.61,60.13 129.5,60.02 129.5,59.86 129.7,59.66 129.7,59.5 129.59,59.39 129.43,59.39 129.23,59.59 129.07,59.59 127.34,57.86 119.65,57.86 108.59,46.8 108.59,41.64 v2(108.27,41.32)
  BOTTOM w0.076: UH1.BK5 v2(144.09,80.46)
  BOTTOM w0.14: JDIMM1.25 108.83,41.5 108.64,41.32 v2(108.27,41.32)
DDR_A_D14: length 66.9
  IN1 w0.076: v2(140.85,76.56) 140.85,75.85 139.63,74.63 139.63,72.21 140.24,71.6 140.24,70.99
  IN1 w0.097: 140.24,70.99 140.24,65.92 129.31,54.99 122.25,54.99 122.24,54.99 120.85,54.99 118.87,53.01 118.87,52.85 119.26,52.46 119.26,52.3 119.15,52.19 118.99,52.19 118.6,52.57 118.44,52.57 118.33,52.46 118.33,52.3 118.71,51.91 118.71,51.75 118.6,51.64 118.44,51.64 118.05,52.03 117.89,52.03 117.78,51.91 117.78,51.75 118.17,51.37 118.17,51.21 118.05,51.09 117.89,51.09 117.51,51.48 117.35,51.48 117.23,51.37 117.23,51.21 117.62,50.82 117.62,50.66 117.51,50.55 117.35,50.55 116.96,50.93 116.8,50.93 116.69,50.82 116.69,50.66 117.07,50.27 117.07,50.11 113.51,46.55 112.53,46.55 111.66,45.68 111.66,44.41 111.66,44.4 111.66,40.66 111.39,40.39 v2(110.99,40.39)
  BOTTOM w0.076: 141.7,76.7 142.7,77.71 142.98,77.71 143.26,77.99 UH1.BK1
  BOTTOM w0.14: JDIMM1.41 112.83,41.85 111.37,40.39 v2(110.99,40.39) ; v2(140.85,76.56) 141.55,76.56 141.7,76.7
DDR_A_D15: length 67.1
  IN1 w0.076: 139.09,74.15 139.36,73.89 139.36,71.97 139.74,71.59 139.74,71.38
  IN1 w0.097: 139.74,71.38 139.74,65.85 129.18,55.3 120.74,55.3 116.03,50.59 116.03,50.43 116.42,50.05 116.42,49.89 116.31,49.77 116.15,49.77 115.76,50.16 115.6,50.16 115.44,50 115.44,49.84 115.82,49.46 115.82,49.3 115.71,49.19 115.55,49.19 115.17,49.57 115.01,49.57 114.9,49.45 114.9,49.29 115.27,48.92 115.27,48.76 115.16,48.64 115,48.64 114.62,49.02 114.46,49.02 114.35,48.91 114.35,48.75 114.73,48.37 114.73,48.21 114.61,48.1 114.45,48.1 114.08,48.48 113.92,48.48 113.8,48.36 113.8,48.2 114.18,47.83 114.18,47.67 114.07,47.55 113.91,47.55 113.53,47.93 113.37,47.93 113.26,47.82 113.26,47.66 113.64,47.28 113.64,47.12 113.52,47.01 113.36,47.01 112.99,47.38 112.83,47.38 111.35,45.91 111.35,41.67 111.24,41.56 v2(111.04,41.56) ; v2(138.98,74.26) 139.09,74.15
  BOTTOM w0.076: UH1.BK2 143.7,78.65 143.93,78.42 143.93,77.82 143.07,76.95 143.07,76.58 143.04,76.56
  BOTTOM w0.14: JDIMM1.37 111.83,42.01 111.37,41.56 v2(111.04,41.56) ; 143.04,76.56 140.74,74.26 v1(139.93,74.26) v2(138.98,74.26)
DDR_A_D16: length 67.8
  IN5 w0.076: v2(137.1,84.18) 137.1,83.5 136.63,83.04 136.21,83.04 135.95,83.29 135.73,83.29
  IN5 w0.097: 135.73,83.29 135.3,83.29 132.7,80.7 132.7,77.42 133.89,76.24 133.89,57.53 145.62,45.8 145.62,45.64 145.49,45.52 145.49,45.36 145.6,45.24 145.76,45.24 145.89,45.37 146.05,45.37 146.16,45.26 146.16,45.1 146.04,44.97 146.04,44.81 146.15,44.7 146.31,44.7 146.44,44.82 146.6,44.82 146.71,44.71 146.71,44.55 146.58,44.42 146.58,44.26 146.69,44.15 146.85,44.15 146.98,44.28 147.14,44.28 147.25,44.17 147.25,44.01 147.13,43.88 147.13,43.72 147.24,43.6 147.4,43.6 147.53,43.73 147.69,43.73 147.8,43.62 147.8,43.46 147.67,43.33 147.67,43.17 147.79,43.06 147.95,43.06 148.07,43.19 148.23,43.19 148.35,43.07 148.35,42.91 148.22,42.79 148.22,42.63 148.33,42.51 148.49,42.51 148.62,42.64 148.78,42.64 149.1,42.32 149.1,39.31 150.44,37.97 150.56,37.97 v2(150.59,37.94)
  BOTTOM w0.089: UH1.BT11 139.57,84.74 138.9,84.74 138.77,84.86 138.45,84.86 138.29,84.7 137.62,84.7 137.31,84.39
  BOTTOM w0.14: 137.31,84.39 v2(137.1,84.18) ; v2(150.59,37.94) 150.56,37.97 149.77,37.97 149.48,37.68 149.48,36.77 148.54,35.83 148.36,35.83 148.08,35.54 JDIMM1.174
DDR_A_D17: length 68
  IN5 w0.076: 135.73,83.95 135.77,84 136.29,84 v2(136.47,84.18)
  IN5 w0.097: 135.73,83.95 135.54,83.95 132.4,80.82 132.4,77.15 133.59,75.97 133.59,57.41 140.61,50.38 140.61,50.38 141.16,49.83 141.16,49.67 141.03,49.55 141.03,49.39 141.15,49.27 141.31,49.27 141.43,49.4 141.59,49.4 141.71,49.29 141.71,49.13 141.58,49 141.58,48.84 141.69,48.73 141.85,48.73 141.98,48.86 142.14,48.86 142.25,48.74 142.25,48.58 142.13,48.45 142.13,48.29 142.24,48.18 142.4,48.18 142.53,48.31 142.69,48.31 142.8,48.2 142.8,48.04 142.67,47.91 142.67,47.75 142.78,47.64 142.94,47.64 143.07,47.76 143.23,47.76 143.34,47.65 143.34,47.49 143.22,47.36 143.22,47.2 143.33,47.09 143.49,47.09 143.62,47.22 143.78,47.22 143.89,47.1 143.89,46.94 143.76,46.82 143.76,46.66 143.88,46.54 144.04,46.54 144.16,46.67 144.32,46.67 144.44,46.56 144.44,46.4 144.31,46.27 144.31,46.11 144.42,46 144.58,46 144.71,46.12 144.87,46.12 144.98,46.01 144.98,45.85 144.86,45.72 144.86,45.56 148.8,41.62 148.8,37.35 148.39,36.94 v2(148.39,36.91)
  BOTTOM w0.089: UH1.BR11 140.09,84.64 139.8,84.34 139.36,84.34 139.14,84.55 138.4,84.55 138.1,84.26 138.1,83.94 137.88,83.72 137.31,83.72
  BOTTOM w0.14: JDIMM1.170 147.08,35.94 148.08,36.94 148.36,36.94 v2(148.39,36.91) ; 137.31,83.72 136.92,83.72 v2(136.47,84.18)
DDR_A_D18: length 68.5
  IN5 w0.097: v2(136.89,81.75) 136.89,81.69 135.84,80.63 135.84,76.55 136.17,76.22 136.35,76.04 136.35,71.91 136.69,71.57 136.69,64.25 136.58,64.14 136.04,64.14 135.93,64.02 135.93,63.86 136.04,63.75 136.58,63.75 136.69,63.64 136.69,63.48 136.58,63.36 136.04,63.36 135.93,63.25 135.93,63.09 136.04,62.98 136.58,62.98 136.69,62.86 136.69,62.7 136.58,62.59 136.04,62.59 135.93,62.48 135.93,62.32 136.04,62.21 136.58,62.21 136.69,62.09 136.69,61.93 136.58,61.82 136.04,61.82 135.93,61.71 135.93,61.55 136.04,61.43 136.58,61.43 136.69,61.32 136.69,61.16 136.58,61.05 136.04,61.05 135.93,60.93 135.93,60.77 136.04,60.66 136.58,60.66 136.69,60.55 136.69,60.39 136.58,60.28 136.04,60.28 135.93,60.16 135.93,60 136.04,59.89 136.58,59.89 136.69,59.78 136.69,59.55 136.58,59.44 136.04,59.44 135.93,59.33 135.93,59.17 136.04,59.05 136.58,59.05 136.69,58.94 136.69,57.69 136.87,57.51 137.03,57.51 137.21,57.69 137.37,57.69 137.49,57.57 137.49,57.41 137.3,57.23 137.3,57.07 137.42,56.96 137.58,56.96 137.76,57.14 137.92,57.14 138.03,57.03 138.03,56.87 137.85,56.69 137.85,56.53 137.96,56.41 138.12,56.41 138.3,56.6 138.46,56.6 138.58,56.48 138.58,56.32 138.4,56.14 138.4,55.98 138.51,55.87 138.67,55.87 138.85,56.05 139.01,56.05 139.12,55.94 139.12,55.78 138.94,55.59 138.94,55.43 139.1,55.28 139.26,55.28 139.44,55.46 139.6,55.46 139.72,55.34 139.72,55.18 139.53,55 139.53,54.84 139.65,54.73 139.81,54.73 139.99,54.91 140.15,54.91 140.26,54.8 140.26,54.64 140.08,54.46 140.08,54.3 151.32,43.06 151.32,40.41 v2(151.68,40.06)
  BOTTOM w0.089: UH1.BT8 139.58,82.74 138.64,82.74 138.41,82.51 138.11,82.51 137.38,81.79 136.93,81.79
  BOTTOM w0.102: 136.93,81.79 v2(136.89,81.75)
  BOTTOM w0.14: JDIMM1.183 150.33,41.97 150.93,41.37 150.93,40.63 151.5,40.06 v2(151.68,40.06)
DDR_A_D19: length 67.8
  IN5 w0.097: 137.32,82.06 137.32,81.56 136.14,80.37 136.14,76.68 136.3,76.52 136.65,76.17 136.65,72.04 137.01,71.68 137.01,71.28 137.12,71.16 137.25,71.16 137.36,71.05 137.36,70.89 137.25,70.78 137.12,70.78 137.01,70.66 137.01,70.5 137.12,70.39 137.25,70.39 137.36,70.28 137.36,70.12 137.25,70.01 137.12,70.01 137.01,69.89 137.01,69.73 137.12,69.62 137.25,69.62 137.36,69.51 137.36,69.35 137.25,69.23 137.12,69.23 136.99,69.1 136.99,58.49 140.79,54.69 140.79,54.53 140.61,54.35 140.61,54.19 140.72,54.08 140.88,54.08 141.06,54.26 141.23,54.26 141.34,54.15 141.34,53.99 141.16,53.81 141.16,53.65 141.27,53.53 141.43,53.53 141.61,53.71 141.77,53.71 141.88,53.6 141.88,53.44 141.7,53.26 141.7,53.1 141.82,52.99 141.98,52.99 142.16,53.17 142.32,53.17 142.43,53.05 142.43,52.89 142.25,52.71 142.25,52.55 142.36,52.44 142.52,52.44 142.7,52.62 142.86,52.62 142.98,52.51 142.98,52.35 142.8,52.17 142.8,52.01 142.91,51.89 143.07,51.89 143.25,52.07 143.41,52.07 143.52,51.96 143.52,51.8 143.34,51.62 143.34,51.46 143.45,51.35 143.61,51.35 143.8,51.53 143.96,51.53 144.07,51.42 144.07,51.26 143.89,51.07 143.89,50.91 144,50.8 144.16,50.8 144.34,50.98 144.5,50.98 144.61,50.87 144.61,50.71 144.43,50.53 144.43,50.37 144.55,50.26 144.71,50.26 144.89,50.44 145.05,50.44 145.16,50.32 145.16,50.16 144.98,49.98 144.98,49.82 145.09,49.71 145.25,49.71 145.43,49.89 145.59,49.89 145.71,49.78 145.71,49.62 145.53,49.44 145.53,49.28 145.64,49.16 145.8,49.16 145.98,49.34 146.14,49.34 146.25,49.23 146.25,49.07 146.07,48.89 146.07,48.73 146.18,48.62 146.34,48.62 146.53,48.8 146.69,48.8 146.8,48.69 146.8,48.53 146.62,48.34 146.62,48.18 146.73,48.07 146.89,48.07 147.07,48.25 147.23,48.25 147.35,48.14 147.35,47.98 147.16,47.8 147.16,47.64 147.28,47.52 147.44,47.52 147.62,47.71 147.78,47.71 147.89,47.59 147.89,47.43 147.71,47.25 147.71,47.09 147.82,46.98 147.98,46.98 148.16,47.16 148.32,47.16 148.44,47.05 148.44,46.89 148.26,46.71 148.26,46.55 148.37,46.43 148.53,46.43 148.71,46.61 148.87,46.61 148.98,46.5 148.98,46.34 148.8,46.16 148.8,46 148.92,45.89 149.08,45.89 149.26,46.07 149.42,46.07 149.53,45.95 149.53,45.79 149.35,45.61 149.35,45.45 149.46,45.34 149.62,45.34 149.8,45.52 149.96,45.52 150.08,45.41 150.08,45.25 149.89,45.07 149.89,44.91 150.11,44.69 150.27,44.69 150.45,44.87 150.61,44.87 150.72,44.76 150.72,44.6 150.54,44.42 150.54,44.26 150.66,44.15 150.82,44.15 151,44.33 151.16,44.33 151.27,44.21 151.27,44.05 151.09,43.87 151.09,43.71 151.73,43.08 v2(151.73,41.37)
  IN5 w0.102: 137.32,82.06 137.23,82.15 v2(137.23,82.27)
  BOTTOM w0.089: v2(137.23,82.27) 137.62,82.27 138.05,82.71 138.25,82.71 138.47,82.93 138.77,82.93 138.97,83.13 140.26,83.13 UH1.BR8
  BOTTOM w0.14: v2(151.73,41.37) 151.73,41.51 151.33,41.91 JDIMM1.187
DDR_A_D20: length 68.4
  IN5 w0.076: v2(137.5,85.1) 136.93,84.53 135.9,84.53
  IN5 w0.097: v2(148.38,40.66) 148.38,41.61 147.67,42.33 147.51,42.33 147.41,42.23 147.25,42.23 147.14,42.35 147.14,42.51 147.24,42.6 147.24,42.76 147.12,42.87 146.96,42.87 146.87,42.78 146.71,42.78 146.6,42.89 146.6,43.05 146.69,43.15 146.69,43.31 140.51,49.48 140.51,49.64 140.64,49.77 140.64,49.93 140.53,50.04 140.37,50.04 140.24,49.92 140.08,49.92 139.97,50.03 139.97,50.19 140.09,50.32 140.09,50.48 139.98,50.59 139.82,50.59 139.69,50.46 139.53,50.46 139.42,50.58 139.42,50.74 139.55,50.86 139.55,51.02 139.43,51.14 139.27,51.14 139.15,51.01 138.99,51.01 138.87,51.12 138.87,51.28 139,51.41 139,51.57 138.89,51.68 138.73,51.68 138.6,51.55 138.44,51.55 138.33,51.67 138.33,51.83 138.46,51.95 138.46,52.11 138.34,52.23 138.18,52.23 138.06,52.1 137.9,52.1 137.78,52.21 137.78,52.37 137.91,52.5 137.91,52.66 137.8,52.77 137.64,52.77 137.51,52.65 137.35,52.65 137.24,52.76 137.24,52.92 137.36,53.05 137.36,53.21 137.25,53.32 137.09,53.32 136.96,53.19 136.8,53.19 136.69,53.31 136.69,53.47 136.82,53.59 136.82,53.75 136.7,53.87 136.54,53.87 136.42,53.74 136.26,53.74 136.14,53.85 136.14,54.01 136.27,54.14 136.27,54.3 136.16,54.41 136,54.41 135.87,54.29 135.71,54.29 135.6,54.4 135.6,54.56 135.72,54.69 135.72,54.85 135.61,54.96 135.45,54.96 135.32,54.83 135.16,54.83 135.05,54.94 135.05,55.1 135.18,55.23 135.18,55.39 135.07,55.5 134.91,55.5 134.78,55.38 134.62,55.38 134.51,55.49 134.51,55.65 134.63,55.78 134.63,55.94 134.52,56.05 134.36,56.05 134.23,55.92 134.07,55.92 133.96,56.04 133.96,56.2 134.09,56.32 134.09,56.49 133.29,57.28 133.29,75.84 132.1,77.03 132.1,80.95 132.28,81.12 135.69,84.53 135.9,84.53
  BOTTOM w0.089: 137.96,85.1 138.8,85.1 138.94,84.96 140.65,84.96 UH1.BP11
  BOTTOM w0.14: v2(148.38,40.66) 148.13,40.66 147.54,41.25 147.54,41.45 146.82,42.16 JDIMM1.169 ; 137.96,85.1 v2(137.5,85.1)
DDR_A_D21: length 68.6
  IN5 w0.089: 136.51,85.14 v2(136.88,85.14)
  IN5 w0.097: v2(148.39,38.18) 148.13,38.45 148.12,38.45 147.97,38.6 147.97,41.52 147.55,41.94 147.54,41.93 147.13,41.93 145.92,43.15 145.92,43.31 146.01,43.4 146.01,43.56 145.9,43.67 145.74,43.67 145.64,43.58 145.48,43.58 145.37,43.69 145.37,43.85 145.47,43.95 145.47,44.11 145.35,44.22 145.19,44.22 145.1,44.13 144.94,44.13 144.25,44.81 143.84,44.81 143.61,45.05 143.61,45.88 132.93,56.55 132.93,75.77 131.8,76.9 131.8,81.07 135.88,85.14 136.51,85.14
  BOTTOM w0.089: UH1.BN11 141.12,85.14 139.02,85.14 138.78,85.37 138.23,85.37
  BOTTOM w0.14: v2(136.88,85.14) 137.26,85.53 137.81,85.53 137.96,85.37 138.23,85.37 ; JDIMM1.173 147.82,41.85 148.88,40.8 148.88,38.64 148.43,38.18 v2(148.39,38.18)
DDR_A_D22: length 68.2
  IN5 w0.076: 136.36,82.06 137.5,83.2 137.82,83.2
  IN5 w0.097: 136.36,82.06 136.36,81.71 135.54,80.89 135.54,76.43 136.05,75.92 136.05,71.79 136.37,71.46 136.37,69.37 136.26,69.25 135.74,69.25 135.63,69.14 135.63,68.98 135.74,68.87 136.26,68.87 136.37,68.75 136.37,68.59 136.26,68.48 135.74,68.48 135.63,68.37 135.63,68.21 135.74,68.09 136.26,68.09 136.37,67.98 136.37,67.82 136.26,67.71 135.74,67.71 135.63,67.6 135.63,67.44 135.74,67.32 136.26,67.32 136.37,67.21 136.37,67.05 136.26,66.94 135.74,66.94 135.63,66.82 135.63,66.66 135.74,66.55 136.26,66.55 136.37,66.44 136.37,66.28 136.26,66.16 135.74,66.16 135.63,66.05 135.63,65.89 135.74,65.78 136.26,65.78 136.37,65.67 136.37,65.51 136.26,65.39 135.74,65.39 135.63,65.28 135.63,65.12 135.74,65.01 136.26,65.01 136.37,64.89 136.37,64.73 136.26,64.62 135.74,64.62 135.63,64.51 135.63,58.24 151.02,42.85 151.02,40.16 151.17,40.01 151.17,36.66 v2(150.58,36.08)
  IN5 w0.102: v2(138.06,83.19) 137.83,83.19 137.82,83.2
  BOTTOM w0.089: v2(138.06,83.19) 138.13,83.12 138.58,83.12 138.82,83.35 140.68,83.35 UH1.BP8
  BOTTOM w0.14: JDIMM1.182 150.08,35.57 v2(150.58,36.08)
DDR_A_D23: length 68.1
  IN5 w0.097: 139.55,81.82 139.55,78.71 139.31,78.46 139.31,78.3 139.35,78.26 139.35,78.1 139.24,77.98 139.08,77.98 139.03,78.03 138.87,78.03 138.76,77.92 138.76,77.76 138.81,77.71 138.81,77.55 138.69,77.44 138.53,77.44 138.49,77.48 138.33,77.48 138.21,77.37 138.21,77.21 138.26,77.16 138.26,77 138.15,76.89 137.99,76.89 137.94,76.94 137.78,76.94 137.67,76.82 137.67,76.66 137.71,76.62 137.71,76.46 137.6,76.34 137.44,76.34 137.39,76.39 137.23,76.39 136.95,76.11 136.95,72.16 137.66,71.45 137.66,68.76 137.55,68.65 137.4,68.65 137.29,68.54 137.29,68.38 137.4,68.26 137.55,68.26 137.66,68.15 137.66,67.99 137.55,67.88 137.4,67.88 137.29,67.76 137.29,67.6 137.4,67.49 137.55,67.49 137.66,67.38 137.66,67.22 137.55,67.1 137.4,67.1 137.29,66.99 137.29,66.83 137.4,66.72 137.55,66.72 137.66,66.61 137.66,66.45 137.55,66.33 137.4,66.33 137.29,66.22 137.29,66.06 137.4,65.95 137.55,65.95 137.66,65.83 137.66,65.67 137.55,65.56 137.4,65.56 137.29,65.45 137.29,65.29 137.4,65.17 137.55,65.17 137.66,65.06 137.66,64.9 137.55,64.79 137.4,64.79 137.29,64.67 137.29,64.51 137.4,64.4 137.55,64.4 137.66,64.29 137.66,64.13 137.55,64.02 137.4,64.02 137.29,63.9 137.29,63.74 137.4,63.63 137.55,63.63 137.66,63.52 137.66,63.36 137.55,63.24 137.4,63.24 137.29,63.13 137.29,62.97 137.4,62.86 137.55,62.86 137.66,62.74 137.66,62.58 137.55,62.47 137.4,62.47 137.29,62.36 137.29,62.2 137.4,62.09 137.55,62.09 137.66,61.97 137.66,61.81 137.55,61.7 137.4,61.7 137.29,61.59 137.29,61.43 137.4,61.31 137.55,61.31 137.66,61.2 137.66,61.04 137.55,60.93 137.4,60.93 137.29,60.81 137.29,60.65 137.4,60.54 137.55,60.54 137.66,60.43 137.66,60.27 137.55,60.15 137.4,60.15 137.29,60.04 137.29,59.88 137.4,59.77 137.55,59.77 137.66,59.66 137.66,59.5 137.55,59.38 137.4,59.38 137.29,59.27 137.29,59.11 137.4,59 137.55,59 137.66,58.88 137.66,58.25 152.14,43.77 152.14,39.26 v2(151.73,38.85)
  IN5 w0.102: 139.55,81.82 139.55,82.53 v2(138.46,83.62)
  BOTTOM w0.089: UH1.BN8 141.15,83.54 138.99,83.54 138.9,83.62 v2(138.46,83.62)
  BOTTOM w0.14: JDIMM1.186 151.08,35.93 151.25,36.1 151.25,38.54 151.56,38.85 v2(151.73,38.85)
DDR_A_D24: length 62.8
  IN5 w0.076: 140.24,77.95 140.37,78.08 140.37,82.16 142.6,84.38 v2(142.6,85.03)
  IN5 w0.097: v2(153.32,37.87) 153.32,37.91 152.87,38.35 152.87,44.07 152,44.94 152,45.1 152.33,45.42 152.33,45.58 152.21,45.7 152.05,45.7 151.73,45.37 151.57,45.37 138.39,58.55 138.39,71.94 137.68,72.65 137.68,75.39 140.24,77.95
  BOTTOM w0.089: UH1.BL12 v2(142.6,85.03)
  BOTTOM w0.14: v2(153.32,37.87) 153.32,37.91 153.86,38.46 153.86,41.53 153.71,41.69 153.71,41.7 153.57,41.84 153.57,41.87 153.5,41.94 153.5,41.94 153.33,42.12 JDIMM1.195
DDR_A_D25: length 62.1
  IN5 w0.076: 140.48,77.72 140.69,77.93 140.69,82.21 143.39,84.91 v2(143.39,85.02)
  IN5 w0.097: 140.48,77.72 137.98,75.22 137.98,72.77 138.7,72.06 138.7,58.68 148.16,49.21 148.32,49.21 148.64,49.53 148.8,49.53 148.92,49.42 148.92,49.26 148.6,48.94 148.6,48.78 148.71,48.66 148.87,48.66 149.19,48.99 149.35,48.99 149.46,48.87 149.46,48.71 149.14,48.39 149.14,48.23 149.26,48.12 149.42,48.12 149.74,48.44 149.9,48.44 150.01,48.33 150.01,48.17 149.69,47.85 149.69,47.69 149.8,47.57 149.96,47.57 150.28,47.89 150.44,47.89 150.6,47.73 150.6,47.57 150.28,47.25 150.28,47.09 150.39,46.98 150.55,46.98 150.87,47.3 151.03,47.3 151.15,47.19 151.15,47.03 150.82,46.7 150.82,46.54 150.94,46.43 151.1,46.43 151.42,46.76 151.58,46.76 151.69,46.64 151.69,46.48 151.37,46.16 151.37,46 151.48,45.88 151.64,45.88 151.97,46.21 152.13,46.21 153.06,45.28 153.06,44.65 153.28,44.43 v2(153.28,41.53)
  BOTTOM w0.089: UH1.BL11 v2(143.39,85.02)
  BOTTOM w0.14: v2(153.28,41.53) 152.85,41.53 152.33,42.05 JDIMM1.191
DDR_A_D26: length 62.9
  IN5 w0.076: v2(142.6,83.46) 142.45,83.46 141.32,82.33 141.32,78.14 140.69,77.51
  IN5 w0.097: 140.69,77.51 138.28,75.1 138.28,72.92 138.32,72.88 138.32,72.88 139,72.19 139,58.81 145.76,52.04 145.92,52.04 146.24,52.36 146.4,52.36 146.51,52.25 146.51,52.09 146.19,51.77 146.19,51.61 146.31,51.5 146.47,51.5 146.78,51.82 146.94,51.82 147.06,51.7 147.06,51.54 146.74,51.23 146.74,51.07 146.85,50.95 147.01,50.95 147.33,51.27 147.49,51.27 147.6,51.16 147.6,51 147.29,50.68 147.29,50.52 147.4,50.41 147.56,50.41 147.88,50.72 148.04,50.72 148.15,50.61 148.15,50.45 148.01,50.31 148.01,50.18 148.15,50.04 148.28,50.04 148.42,50.18 148.58,50.18 153.35,45.41 153.35,44.78 153.71,44.42 153.71,40.72 v2(153.32,40.33)
  BOTTOM w0.089: UH1.BL8 v2(142.6,83.46)
  BOTTOM w0.14: v2(153.32,40.33) 153.14,40.33 152.41,39.6 152.41,38.08 152.1,37.77 152.1,36.99 152.08,36.96 JDIMM1.190
DDR_A_D27: length 62.6
  IN5 w0.076: v2(144.26,83.07) 143.91,82.72 143.91,82.27 145.07,81.11 145.07,80.77 144.99,80.68 144.84,80.68 144.76,80.59 144.76,80.46 144.84,80.38 144.99,80.38 145.07,80.29 145.07,80.16 144.99,80.07 144.84,80.07 144.76,79.98 144.76,79.85 144.84,79.77 144.99,79.77 145.07,79.68 145.07,79.55 144.99,79.46 144.84,79.46 144.76,79.37 144.76,79.25 144.84,79.16 144.99,79.16 145.07,79.07 145.07,78.94 144.99,78.85 144.84,78.85 144.76,78.76 144.76,78.64 144.84,78.55 144.99,78.55 145.07,78.46 145.07,76.82 143.22,74.97
  IN5 w0.097: 143.22,74.97 143.21,74.97 142.58,74.34 142.58,74.11 142.42,73.96 142.42,73.48 142.58,73.32 142.58,73.09 142.42,72.94 142.42,72.71 142.58,72.55 142.58,72.32 142.42,72.17 142.42,71.94 142.58,71.78 142.58,71.55 142.42,71.39 142.42,71.16 142.58,71.01 142.58,70.78 142.42,70.62 142.42,70.39 142.58,70.24 142.58,70 142.42,69.85 142.42,69.62 142.58,69.46 142.58,69.23 142.42,69.08 142.42,68.85 142.58,68.69 142.58,68.46 142.42,68.31 142.42,68.07 142.58,67.92 142.58,67.69 142.45,67.56 142.07,67.56 142.01,67.5 142.01,64.29 142.15,64.15 142.15,63.05 142.04,62.94 141.76,62.94 141.64,62.83 141.64,62.67 141.76,62.55 142.38,62.55 142.48,62.46 142.48,62.27 142.38,62.17 141.76,62.17 141.64,62.06 141.64,61.9 141.76,61.78 142.38,61.78 142.48,61.69 142.48,61.49 142.38,61.4 141.76,61.4 141.64,61.28 141.64,61.12 141.76,61.01 142.48,61.01 142.58,60.91 142.58,59.91 156.74,45.75 156.74,43.68 156.86,43.57 156.87,43.57 156.98,43.46 156.98,43.3 156.87,43.18 156.86,43.18 156.74,43.07 156.74,42.91 156.86,42.8 156.87,42.8 156.98,42.69 156.98,42.53 156.87,42.41 156.86,42.41 156.74,42.3 156.74,42 156.98,41.76 156.98,40.58 156.98,40.57 156.98,40.25 156.88,40.16 156.72,40.16 v2(156.54,40.33)
  BOTTOM w0.089: UH1.BJ8 v2(144.26,83.07)
  BOTTOM w0.14: v2(156.54,40.33) 156.05,40.33 155.33,41.06 JDIMM1.203
DDR_A_D28: length 62.8
  IN5 w0.076: 143.73,77.37 143.73,81.71 143.44,82 143.44,83.2 143.85,83.61 143.85,83.96 v2(144.26,84.37)
  IN5 w0.097: v2(156.55,39.06) 156.55,39.13 156.13,39.55 156.13,45.38 140.95,60.56 140.95,71.28 141.07,71.4 141.66,71.4 141.77,71.51 141.77,71.67 141.66,71.78 141.07,71.78 140.95,71.9 140.95,72.06 141.07,72.17 141.66,72.17 141.77,72.28 141.77,72.44 141.66,72.56 141.07,72.56 140.95,72.67 140.95,72.83 141.07,72.94 141.66,72.94 141.77,73.06 141.77,73.22 141.66,73.33 141.07,73.33 140.95,73.44 140.95,74.43 142.36,75.83
  IN5 w0.102: 143.73,77.37 143.73,77.21 142.36,75.83
  BOTTOM w0.089: UH1.BJ11 v2(144.26,84.37)
  BOTTOM w0.14: v2(156.55,39.06) 156.62,39.06 157.01,38.68 157.01,37.26 156.57,36.83 JDIMM1.208
DDR_A_D29: length 61.7
  IN5 w0.076: v2(144.26,83.72) 143.65,83.11 143.65,82.15 144.5,81.29 144.5,78.26 144.91,77.85 144.91,77.1 143,75.19
  IN5 w0.097: v2(156.57,41.6) 156.54,41.6 156.44,41.7 156.44,44.86 156.43,44.86 156.43,45.5 141.25,60.69 141.25,63.24 141.37,63.35 141.72,63.35 141.83,63.47 141.83,63.63 141.72,63.74 141.37,63.74 141.25,63.85 141.25,64.14 141.37,64.26 141.53,64.26 141.64,64.37 141.64,64.53 141.53,64.64 141.37,64.64 141.25,64.76 141.25,64.92 141.37,65.03 141.53,65.03 141.64,65.14 141.64,65.3 141.53,65.42 141.37,65.42 141.25,65.53 141.25,65.69 141.37,65.8 141.53,65.8 141.64,65.91 141.64,66.07 141.53,66.19 141.37,66.19 141.25,66.3 141.25,66.46 141.37,66.57 141.53,66.57 141.64,66.69 141.64,66.85 141.53,66.96 141.37,66.96 141.25,67.07 141.25,67.74 141.37,67.86 141.98,67.86 142.09,67.97 142.09,68.13 141.98,68.24 141.37,68.24 141.25,68.35 141.25,68.51 141.37,68.63 141.98,68.63 142.09,68.74 142.09,68.9 141.98,69.01 141.37,69.01 141.25,69.13 141.25,69.29 141.37,69.4 141.98,69.4 142.09,69.51 142.09,69.67 141.98,69.79 141.37,69.79 141.25,69.9 141.25,70.12 141.35,70.22 141.95,70.22 142.06,70.33 142.06,70.49 141.95,70.6 141.3,70.6 141.25,70.65 141.25,70.94 141.3,70.99 141.95,70.99 142.12,71.17 142.12,74.08 142.28,74.24 142.28,74.46 143,75.19 143,75.19
  BOTTOM w0.089: UH1.BJ10 v2(144.26,83.72)
  BOTTOM w0.14: JDIMM1.207 156.33,41.8 156.52,41.6 v2(156.57,41.6)
DDR_A_D30: length 62.6
  IN5 w0.076: v2(142.64,82.64) 141.72,81.72 141.72,78.12 140.98,77.37
  IN5 w0.097: v2(153.29,39.14) 154.39,40.25 154.39,44.16 153.65,44.9 153.65,45.53 146.28,52.9 146.12,52.9 145.82,52.59 145.66,52.59 145.54,52.71 145.54,52.87 145.85,53.17 145.85,53.33 145.62,53.56 145.46,53.56 145.15,53.25 144.99,53.25 144.88,53.36 144.88,53.52 145.19,53.83 145.19,53.99 145.08,54.11 144.92,54.11 144.6,53.79 144.44,53.79 144.33,53.91 144.33,54.07 144.64,54.38 144.64,54.54 144.53,54.65 144.37,54.65 144.06,54.34 143.9,54.34 143.78,54.45 143.78,54.61 144.1,54.93 144.1,55.09 143.98,55.2 143.82,55.2 143.51,54.89 143.35,54.89 139.3,58.93 139.3,72.32 138.58,73.04 138.58,74.97 140.9,77.29
  IN5 w0.102: 140.9,77.29 140.98,77.37
  BOTTOM w0.089: UH1.BL7 v2(142.64,82.64)
  BOTTOM w0.14: JDIMM1.194 153.08,35.88 152.76,36.2 152.76,38.61 v2(153.29,39.14)
DDR_A_D31: length 62.1
  IN5 w0.076: v2(144.26,82.42) 145.24,81.44 145.24,76.57 143.52,74.86 143.52,74.85 143.44,74.76
  IN5 w0.097: v2(156.55,37.79) 156.38,37.61 156.38,37.13 156.27,37.02 155.68,37.02 155.55,36.9 155.55,36.65 155.63,36.58 156.81,36.58 156.91,36.69 156.91,37.39 157.09,37.56 157.09,37.97 157.28,38.17 157.28,38.49 157.17,38.61 157.05,38.61 156.93,38.72 156.93,38.88 157.05,38.99 157.17,38.99 157.28,39.1 157.28,39.34 157.18,39.44 157.04,39.44 156.94,39.53 156.94,39.73 157.04,39.82 157.18,39.82 157.28,39.92 157.28,40.45 157.28,40.45 157.28,43.83 157.07,44.03 157.07,45.85 143.55,59.37 143.55,59.39 142.88,60.06 142.88,63.85 142.31,64.42 142.31,66.73 142.88,67.3 142.88,74.21 143.34,74.67 143.35,74.67 143.44,74.76
  BOTTOM w0.089: UH1.BJ7 v2(144.26,82.42)
  BOTTOM w0.14: JDIMM1.204 155.57,36.93 156.44,37.79 v2(156.55,37.79)
DDR_A_D32: length 67.2
  IN1 w0.076: v2(144.3,77.07) 143.74,77.07 143.65,77.16 143.65,77.66 143.56,77.75 143.44,77.75 143.35,77.66 143.35,77.16 143.26,77.07 142.95,77.07 140.48,74.6 140.48,72.76 141.57,71.67 141.57,70.99
  IN1 w0.097: 141.57,70.99 141.57,64.91 130.31,53.65 122.66,53.65 113.23,44.22 113.23,42.1 113.01,41.87 113.01,37.99 v2(113.69,37.3)
  BOTTOM w0.076: v2(144.3,77.07) 144.31,77.07 144.31,77.08 144.57,77.08 144.9,77.41 144.9,77.83 144.73,78 144.73,78.48 144.83,78.58 144.83,79.77 145.2,80.14 UH1.BG4
  BOTTOM w0.14: JDIMM1.46 114.07,35.6 114.21,35.73 114.21,36.78 v2(113.69,37.3)
DDR_A_D33: length 67.4
  IN1 w0.076: 141.98,70.99 141.98,71.01 141.99,71.02 141.99,71.69 140.68,73 140.68,74.51 142.87,76.7 143.8,76.7 v2(143.8,76.7)
  IN1 w0.097: 141.98,70.99 141.98,64.9 130.43,53.35 122.79,53.35 113.53,44.09 113.53,41.89 113.31,41.67 113.31,38.84 113.41,38.74 v2(113.79,38.74)
  BOTTOM w0.076: UH1.BG5 145.71,80.34 145.71,80.02 145.52,79.83 145.36,79.83 145.07,79.54 145.07,78.77 145.03,78.73 145.03,78.49 144.93,78.39 144.93,78.03 145.11,77.86 145.11,77.09 144.72,76.7 v2(143.8,76.7)
  BOTTOM w0.14: JDIMM1.50 115.07,37.46 v2(113.79,38.74)
DDR_A_D34: length 67.2
  IN1 w0.076: 145.5,70.99 145.5,71.92 143.72,73.71 143.72,75.46 146.09,77.83 146.09,79.29 v2(146.61,79.81)
  IN1 w0.097: v2(117.84,40.25) 117.87,40.25 118.25,40.63 118.25,43.94 118.52,44.22 118.68,44.22 119.11,43.79 119.27,43.79 119.38,43.9 119.38,44.06 118.95,44.49 118.95,44.65 119.07,44.76 119.23,44.76 119.65,44.34 119.81,44.34 119.93,44.45 119.93,44.61 119.5,45.04 119.5,45.2 119.61,45.31 119.77,45.31 120.2,44.88 120.36,44.88 120.47,45 120.47,45.16 120.05,45.58 120.05,45.74 120.16,45.86 120.32,45.86 120.75,45.43 120.91,45.43 121.02,45.54 121.02,45.7 120.59,46.13 120.59,46.29 120.7,46.4 120.86,46.4 121.29,45.97 121.45,45.97 121.57,46.09 121.57,46.25 121.14,46.68 121.14,46.84 125,50.7 131.52,50.7 145.5,64.68 145.5,70.99
  BOTTOM w0.076: UH1.BF4 v2(146.61,79.81)
  BOTTOM w0.14: JDIMM1.63 118.33,40.71 117.87,40.25 v2(117.84,40.25)
DDR_A_D35: length 67.1
  IN1 w0.076: 145.2,70.99 145.2,71.85 143.42,73.62 143.42,75.61 145.82,78.01 145.82,79.72 146.56,80.46 v2(146.61,80.46)
  IN1 w0.097: v2(117.84,36.42) 117.42,36.83 117.42,38.66 117.31,38.77 116.87,38.77 116.75,38.89 116.75,39.05 116.87,39.16 117.31,39.16 117.42,39.27 117.42,39.43 117.31,39.55 116.87,39.55 116.75,39.66 116.75,39.82 116.87,39.93 117.31,39.93 117.42,40.05 117.42,40.21 117.31,40.32 117.04,40.32 116.94,40.42 116.94,40.61 117.04,40.7 117.31,40.7 117.42,40.82 117.42,43.55 124.88,51.01 131.4,51.01 145.2,64.81 145.2,70.99
  BOTTOM w0.076: UH1.BF5 v2(146.61,80.46)
  BOTTOM w0.14: v2(117.84,36.42) 117.07,35.65 JDIMM1.58
DDR_A_D36: length 67.1
  IN1 w0.076: v2(143.04,75.82) 142.88,75.97 142.38,75.97 140.86,74.45 140.86,73.21 142.27,71.79 142.27,71.02 142.28,71.01 142.28,70.99
  IN1 w0.097: v2(113.83,41.09) 113.83,42.69 113.94,42.81 114.48,42.81 114.59,42.92 114.59,43.08 114.48,43.19 113.94,43.19 113.83,43.31 113.83,43.97 114.15,44.28 114.31,44.28 114.75,43.84 114.91,43.84 115.02,43.95 115.02,44.11 114.58,44.56 114.58,44.72 114.69,44.83 114.85,44.83 115.29,44.39 115.45,44.39 115.57,44.5 115.57,44.66 115.12,45.1 115.12,45.26 115.24,45.38 115.4,45.38 115.84,44.93 116,44.93 116.11,45.05 116.11,45.21 115.67,45.65 115.67,45.81 115.78,45.92 115.94,45.92 116.39,45.48 116.55,45.48 116.66,45.59 116.66,45.75 116.22,46.2 116.22,46.36 122.91,53.05 130.56,53.05 142.28,64.77 142.28,70.99
  BOTTOM w0.076: UH1.BG2 145.24,78.57 145.24,78.41 145.13,78.31 145.13,78.07 145.31,77.89 145.31,77.01 144.6,76.29 v1(144.37,76.29) 144.05,76.29 143.69,75.92
  BOTTOM w0.14: JDIMM1.49 114.83,42.08 v2(113.83,41.09) ; 143.69,75.92 143.65,75.89 143.58,75.82 v2(143.04,75.82)
DDR_A_D37: length 67.2
  IN1 w0.076: v2(142.64,75.4) 142.5,75.53 142.24,75.53 141.09,74.37 141.09,73.55 142.79,71.84 142.79,70.99
  IN1 w0.097: 142.79,70.99 142.79,64.86 130.68,52.75 125.08,52.75 125.07,52.74 124.28,52.74 123.13,51.59 122.97,51.59 122.76,51.8 122.56,51.8 122.47,51.7 122.47,51.55 122.7,51.32 122.7,51.16 122.58,51.05 122.42,51.05 122,51.47 121.84,51.47 121.73,51.36 121.73,51.2 122.15,50.77 122.15,50.61 122.04,50.5 121.88,50.5 121.45,50.92 121.29,50.92 121.18,50.81 121.18,50.65 121.61,50.23 121.61,50.07 121.49,49.95 121.33,49.95 120.91,50.38 120.75,50.38 120.63,50.27 120.63,50.11 121.06,49.68 121.06,49.52 120.95,49.41 120.79,49.41 120.4,49.79 120.27,49.79 117.14,46.66 117.14,45.6 115.43,43.89 115.43,43.11 114.24,41.91 114.24,40.36 113.81,39.93 v2(113.81,39.92)
  BOTTOM w0.076: 143.88,75.73 144.13,75.97 144.61,75.97 145.51,76.87 145.51,78.09 145.43,78.17 UH1.BG1
  BOTTOM w0.14: v2(113.81,39.92) 113.64,40.08 113.63,40.08 113.38,40.33 113.38,40.34 113.22,40.5 113.22,41.15 113.6,41.53 113.6,41.66 113.83,41.88 JDIMM1.45 ; 143.88,75.73 143.55,75.4 v2(142.64,75.4)
DDR_A_D38: length 67
  IN1 w0.076: 146.11,70.99 146.11,72.2 144.31,74.01 144.31,75.55 146.61,77.84 v2(146.61,77.86)
  IN1 w0.097: 146.11,70.99 146.11,64.43 131.78,50.09 126.43,50.09 125.5,49.16 125.5,49 125.81,48.69 125.81,48.53 125.69,48.42 125.53,48.42 125.22,48.73 125.06,48.73 124.9,48.57 124.9,48.41 125.22,48.1 125.22,47.94 125.1,47.82 124.94,47.82 124.63,48.14 124.47,48.14 124.36,48.02 124.36,47.86 124.67,47.55 124.67,47.39 124.56,47.28 124.4,47.28 124.08,47.59 123.92,47.59 123.81,47.48 123.81,47.32 124.12,47.01 124.12,46.85 124.01,46.73 123.85,46.73 123.54,47.04 123.38,47.04 118.86,42.53 118.86,41.94 118.86,41.94 118.86,38.7 v2(117.84,37.69)
  BOTTOM w0.076: UH1.BF1 v2(146.61,77.86)
  BOTTOM w0.14: JDIMM1.59 117.33,41.72 117.35,41.69 117.35,38.17 v2(117.84,37.69)
DDR_A_D39: length 67
  IN1 w0.076: 145.81,70.99 145.81,72.06 143.99,73.88 143.99,75.5 146.25,77.76 146.25,78.19 146.58,78.51 v2(146.61,78.51)
  IN1 w0.097: v2(117.83,38.98) 118.55,39.7 118.55,42.65 123.39,47.49 123.39,47.65 122.96,48.08 122.96,48.24 123.08,48.35 123.24,48.35 123.66,47.92 123.82,47.92 123.94,48.03 123.94,48.19 123.51,48.62 123.51,48.78 123.62,48.9 123.78,48.9 124.21,48.47 124.37,48.47 124.48,48.58 124.48,48.74 124.06,49.17 124.06,49.33 124.17,49.44 124.33,49.44 124.76,49.01 124.92,49.01 125.03,49.13 125.03,49.29 124.6,49.71 124.6,49.87 124.71,49.99 124.87,49.99 125.3,49.56 125.46,49.56 126.3,50.4 131.65,50.4 145.81,64.56 145.81,70.99
  BOTTOM w0.076: UH1.BF2 v2(146.61,78.51)
  BOTTOM w0.14: v2(117.83,38.98) 118.55,38.26 118.55,36.14 118.07,35.67 JDIMM1.62
DDR_A_D40: length 62.2
  IN1 w0.076: v2(145.31,75.31) 145.31,74.41 147.28,72.43 147.28,70.85
  IN1 w0.097: v2(120.41,38.72) 120,38.72 119.9,38.82 119.9,41.7 120.46,42.26 121.51,42.26 123.15,43.89 123.15,44.41 127.79,49.05 132.21,49.05 147.28,64.12 147.28,70.85
  BOTTOM w0.076: UH1.BD2 147.94,78.6 147.66,78.32 147.66,76.8 146.74,75.88 146.43,75.88 146.12,75.57 146.12,75.51 146.05,75.43
  BOTTOM w0.14: JDIMM1.66 119.07,35.57 119.32,35.82 119.32,35.82 119.36,35.85 119.36,37.67 v2(120.41,38.72) ; 146.05,75.43 145.89,75.28 145.57,75.28 145.54,75.31 v2(145.31,75.31)
DDR_A_D41: length 61.9
  IN1 w0.076: 146.98,70.85 146.98,72.35 144.85,74.49 v2(144.85,74.85)
  IN1 w0.097: v2(120.38,37.26) 119.69,37.26 119.59,37.36 119.59,41.82 120.33,42.56 121.38,42.56 122.85,44.02 122.85,44.53 127.67,49.35 132.08,49.35 146.98,64.26 146.98,70.85
  BOTTOM w0.076: UH1.BD1 147.94,76.78 146.77,75.62 146.65,75.62 146.46,75.43
  BOTTOM w0.14: v2(120.38,37.26) 119.93,36.81 119.93,35.71 120.07,35.56 JDIMM1.70 ; 146.46,75.43 145.88,74.85 v1(145.58,74.85) v2(144.85,74.85)
DDR_A_D42: length 62.1
  IN1 w0.076: 149.26,73.25 149.84,72.67 149.84,70.85
  IN1 w0.097: 149.84,70.85 149.84,63.06 133.27,46.49 131.77,46.49 131.66,46.38 131.66,46.16 131.56,46.07 131.37,46.07 131.27,46.16 131.27,46.38 131.16,46.49 130.64,46.49 129.33,45.18 129.33,44.46 123.96,39.09 v2(123.96,39.03)
  IN1 w0.102: 149.26,73.25 148.5,74.01 148.5,77.89 148.2,78.2 147.6,78.2 147.41,78.39 147.41,79.25 147.87,79.7 v2(149.15,79.7)
  BOTTOM w0.076: v2(149.15,79.7) 148.9,79.67 148.73,79.79 UH1.BC4
  BOTTOM w0.14: v2(123.96,39.03) 123.74,38.82 123.73,38.82 123.48,38.57 123.48,38.56 123.41,38.48 123.41,36.92 122.75,36.27 122.75,36.25 122.58,36.08 JDIMM1.80
DDR_A_D43: length 61.7
  IN1 w0.076: 149.53,70.85 149.53,72.56 148.92,73.17 148.12,73.97 148.12,77.8 148.04,77.88 147.49,77.88 147.23,78.13 147.23,79.34
  IN1 w0.097: 149.53,70.85 149.53,63.18 133.14,46.79 130.4,46.79 128.88,45.28 128.88,44.45 128.29,43.86 128.08,43.86 127.88,44.06 127.67,44.06 127.52,43.92 127.52,43.71 127.73,43.5 127.73,43.29 127.58,43.15 127.37,43.15 127.17,43.35 126.96,43.35 126.81,43.21 126.81,43 127.02,42.79 127.02,42.58 126.87,42.44 126.66,42.44 126.45,42.64 126.25,42.64 126.1,42.49 126.1,42.29 126.3,42.08 126.3,41.87 124.75,40.31 v2(123.94,40.31)
  IN1 w0.102: v2(149.13,80.32) 148.22,80.32 147.23,79.34
  BOTTOM w0.076: UH1.BC5 149.11,80.47 v2(149.13,80.32)
  BOTTOM w0.14: JDIMM1.79 122.33,42.16 123.94,40.54 v2(123.94,40.31)
DDR_A_D44: length 61.8
  IN1 w0.076: v2(146.52,76.64) 146.81,76.93 147.47,76.93 147.55,76.85 147.55,76.29 146.64,75.38 146.63,75.38 146.42,75.17 146.42,75.16 145.97,74.72 145.97,74.43 147.88,72.52 147.88,70.85
  IN1 w0.097: v2(122.49,41.18) 122.49,41.21 126.25,44.97 126.25,45.4 126.07,45.58 126.07,45.79 126.21,45.94 126.42,45.94 126.6,45.76 126.81,45.76 126.96,45.91 126.96,46.12 126.78,46.3 126.78,46.5 126.93,46.65 127.13,46.65 127.31,46.47 127.52,46.47 127.67,46.62 127.67,46.83 127.49,47.01 127.49,47.22 127.64,47.36 127.85,47.36 128.03,47.18 128.23,47.18 128.38,47.33 128.38,47.54 128.2,47.72 128.2,47.93 128.35,48.07 128.56,48.07 128.74,47.9 128.95,47.9 129.49,48.44 132.46,48.44 147.88,63.86 147.88,70.85
  BOTTOM w0.076: v2(146.52,76.64) 146.66,76.64 147.33,77.31 147.33,78.65 147.43,78.74 147.43,80.27 UH1.BD5
  BOTTOM w0.14: JDIMM1.71 120.33,41.92 121.07,41.18 v2(122.49,41.18)
DDR_A_D45: length 62.1
  IN1 w0.076: 147.58,70.85 147.58,72.51 145.77,74.32 145.77,74.9 146.16,75.28 v2(146.16,76.18)
  IN1 w0.097: 147.58,70.85 147.58,63.99 132.34,48.74 127.93,48.74 123.68,44.49 123.68,44.28 123.72,44.24 123.72,44.03 123.49,43.8 123.49,43.59 123.75,43.33 123.75,43.12 123.6,42.98 123.39,42.98 123.13,43.24 122.92,43.24 122.78,43.09 122.78,42.88 123.04,42.62 123.04,42.41 122.89,42.27 122.68,42.27 122.42,42.53 122.21,42.53 122.07,42.38 122.07,42.17 122.33,41.91 122.33,41.7 122.18,41.55 121.97,41.55 121.71,41.81 121.5,41.81 121.35,41.67 121.35,41.46 121.61,41.2 121.61,40.99 121.47,40.84 121.26,40.84 121,41.1 120.79,41.1 120.37,40.68 v2(120.37,40.55)
  BOTTOM w0.076: UH1.BD4 147.65,79.73 147.65,78.64 147.5,78.49 147.5,77.02 146.66,76.18 v2(146.16,76.18)
  BOTTOM w0.14: v2(120.37,40.55) 120.33,40.55 119.33,41.55 JDIMM1.67
DDR_A_D46: length 61.7
  IN1 w0.076: 149.49,75.23 149.49,73.65 150.52,72.62 150.52,70.85
  IN1 w0.097: 150.52,70.85 150.15,70.48 150.15,69.43 150.27,69.31 150.41,69.31 150.53,69.2 150.53,69.04 150.41,68.93 150.27,68.93 150.15,68.82 150.15,68.66 150.27,68.54 150.41,68.54 150.53,68.43 150.53,68.27 150.41,68.16 150.27,68.16 150.15,68.04 150.15,63.08 150.14,63.07 150.14,62.94 136.09,48.89 136.09,48.68 136.23,48.55 136.23,48.34 136.08,48.2 135.87,48.2 135.74,48.33 135.53,48.33 135.38,48.18 135.38,47.97 135.52,47.84 135.52,47.63 135.37,47.48 135.16,47.48 135.03,47.62 134.82,47.62 134.67,47.47 134.67,47.26 134.8,47.13 134.8,46.92 133.02,45.13 131.31,45.13 130.01,43.83 129.63,43.83 124.31,38.51 124.31,38.22 124.08,37.99 123.96,37.99 v2(123.96,37.73)
  IN1 w0.102: 149.49,75.23 149.49,77.39 v2(149.12,77.76)
  BOTTOM w0.076: UH1.BC1 149.1,77.87 149.12,77.76 v2(149.12,77.76)
  BOTTOM w0.14: JDIMM1.83 123.33,41.82 124.44,40.71 124.44,38.21 v2(123.96,37.73)
