# Allegro board Dell_Inspiron_15_7577_Compal_CKA50_CKF50_LA_E992P_Rev_1_0_BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
TBT_A_USB20_NT: length 12.8
  IN5 w0.104: v2(367.86,71.62) 367.47,72.01 367.23,72.01 364.09,75.15 363.18,75.15 362.38,75.94 362.11,75.94 362,75.83 362,75.65 362.37,75.28 v2(362.37,75.28)
  BOTTOM w0.089: 361.94,74.38 361.91,74.35 361.91,74.32 361.46,73.87 361.46,73.16 361.67,72.95 361.67,72.79 361.57,72.68 361.49,72.68 361.44,72.74 UT4.L6
  BOTTOM w0.14: LT2.1 368.56,71.66 368.42,71.81 368.05,71.81 v2(367.86,71.62) ; v2(362.37,75.28) 362.37,75.28 362.37,75.25 361.99,74.87 361.99,74.43 361.94,74.38
TBT_A_USB20_P: length 35.8
  IN4 w0.147: v2(361.18,74.79) 361.12,74.79 361.11,74.78 360.94,74.78 360.55,75.17 354.83,75.17 344.76,65.1 344.76,60.71 348.31,57.16 351.18,57.16 v2(351.24,57.11)
  BOTTOM w0.076: UT4.L5 360.91,72.78 360.86,72.84 360.86,72.96 361,73.1 361,74.61 361.02,74.63
  BOTTOM w0.089: v2(351.24,57.11) 350.91,57.43 UT1.E20
  BOTTOM w0.14: 361.02,74.63 v2(361.18,74.79)
TBT_A_USB20_PB: length 14.9
  IN5 w0.104: v2(367.96,70.05) 367.89,69.98 367.89,69.83 367.98,69.74 368.24,69.74 368.38,69.88 368.38,70.34 368.48,70.44 368.62,70.44 368.77,70.29 368.77,69.73 368.32,69.28 367.77,69.28 366.34,70.71 366.34,72.33 365.51,73.15 364,73.15 363.89,73.05 362.28,73.05 362.13,73.2 362.13,73.39 362.22,73.47 362.41,73.47 v2(362.49,73.56)
  BOTTOM w0.076: UT4.K7 362.12,72.59 362.17,72.68 362.19,72.74 362.19,72.93 362.33,73.07 362.33,73.4 v2(362.49,73.56)
  BOTTOM w0.14: LT3.1 368.46,70.14 368.38,70.22 368.13,70.22 v2(367.96,70.05)
TBT_A_USB20_PT: length 12.8
  IN5 w0.104: v2(361.79,75.28) 361.8,75.29 361.8,75.91 362.03,76.14 362.46,76.14 363.26,75.34 364.17,75.34 367.31,72.2 v2(367.86,72.2)
  BOTTOM w0.076: UT4.K6 361.23,72.63 361.19,72.71 361.19,72.89 361.27,72.96 361.27,72.97 361.28,73.24 361.28,73.24
  BOTTOM w0.089: 361.28,73.24 361.28,73.94 361.74,74.4 361.74,74.5
  BOTTOM w0.14: LT2.4 368.55,72.16 368.45,72.06 368,72.06 v2(367.86,72.2) ; 361.74,74.5 361.74,75.22 v2(361.79,75.28)
TBT_CIO_PLUG_EVENT#: length 111.3
  TOP w0.14: v2(277.74,44.8) 277.99,44.8 v1(278.33,45.14)
  IN3 w0.124: v2(360.65,51.45) 359.95,51.45 359.26,50.76 359.26,48.67 357.42,46.83 352.72,46.83 351.77,45.88 346.05,45.88 344.78,47.15 344.78,51.59 341.46,54.91 335.48,54.91 334.69,55.71 326.62,55.71 318.47,47.57 313.75,47.57 313.55,47.77 309.33,47.77 307.95,46.38 306.73,46.38 306.07,45.73 295.69,45.73 295.24,46.18 293.82,46.18 293.4,46.6 291.79,46.6 291.05,47.34 291.05,50.75 290.39,51.41 286.53,51.41 285.67,50.56 284.68,50.56 283.64,51.6 282.12,51.6 279.77,49.25 279.77,47.71 279.41,47.36 279.41,46.47 v2(277.74,44.8)
  BOTTOM w0.076: v2(277.74,44.8) 277.65,44.8 277.5,44.64 277.5,44.64 277.29,44.43 277.29,44.43 277.15,44.3 UH2.U41
  BOTTOM w0.089: 360.76,51.35 360.65,51.45 v2(360.65,51.45) 360.61,51.41 360.28,51.41 360.19,51.32 360.19,51.32 360.07,51.2 359.63,51.2 359.41,50.98 UT1.W2
  BOTTOM w0.14: 360.76,51.35 361.71,51.35 RT29.2
TBT_CLK_REQ#: length 90.9
  TOP w0.14: v2(359.13,44.54) v1(359.86,44.54)
  IN4 w0.137: v2(285.16,28.6) 285.16,27.78 286.07,26.86 289.76,26.86 290.99,28.1 293.28,28.1 294.11,28.92 296.66,28.92 296.78,29.04 297.95,29.04 298.48,28.51 299.28,28.51 299.37,28.6 299.39,28.6 299.64,28.85 299.64,28.86 300.49,29.71 305.93,29.71 306.72,30.5 306.72,31.18 307.45,31.91 307.88,31.91 307.88,31.91 308.09,31.91 308.09,31.91 308.84,31.91 309.14,31.61 310.85,31.61 312.48,33.24 313.98,33.24 315.99,31.23 325.07,31.23 326.62,32.79 328.65,32.79 329.49,33.62 344.29,33.62 346.33,35.67 349.69,35.67 351.7,37.68 355.13,37.68 358.88,41.43 358.88,43.24 359.13,43.49 v2(359.13,44.54)
  BOTTOM w0.076: v2(285.16,28.6) 285.16,28.62 284.71,29.07 284.71,30.18 UH2.BE25
  BOTTOM w0.14: RT2.2 359.2,45.08 RT24.1 359.13,45.01 v2(359.13,44.54)
TBT_CLK_REQ#_R: length 4.6
  BOTTOM w0.076: 358.15,46.95 358.15,47.48 358.03,47.6 UT1.AC5
  BOTTOM w0.14: 358.15,46.95 358.15,46.92 358.41,46.66 358.41,46.54 359.17,45.79 RT20.2 359.2,45.66 RT2.1
TBT_CONFIG: length 11
  IN3 w0.124: v2(361.12,71.72) 360.54,71.14 359.75,71.14 359.28,70.66 357.2,70.66 356.06,69.52 354.61,69.52 354.27,69.18 v2(353.81,69.18)
  BOTTOM w0.089: v2(361.12,71.72) 361.12,71.51 361.35,71.28 UT4.H6
  BOTTOM w0.14: v2(353.81,69.18) 353.81,68.69 RT112.2 353.82,68.44 353.61,68.23 353.36,68.23 353.35,68.22 353,68.22 352.99,68.23 352.78,68.23 RT113.1
TBT_EE_CLK: length 2.7
  BOTTOM w0.089: RT101.1 359.54,47.82 358.72,48.63 358.72,49.36 UT1.AB4
TBT_EE_CLK_R: length 20.5
  TOP w0.14: v2(356.27,42.83) 356.18,42.83 355.64,42.29 355.64,40.35 356.59,39.4 360.13,39.4 360.42,39.68 360.42,40.98 361.24,41.8 361.24,42.72 362.37,43.85 362.37,46.83 v4(361.78,47.42) 361.31,47.88 v2(360.21,47.88)
  BOTTOM w0.076: v2(360.21,47.88) 360.12,47.8 RT101.2
  BOTTOM w0.14: UT2.6 v2(356.27,42.83)
TBT_EE_CS_N: length 32.1
  IN1 w0.097: v2(349.09,40.29) 349.43,40.29 350.85,41.7 350.85,43.04 350.14,43.75 350.14,46.35 350.8,47.02 363.84,47.02 363.98,46.88 364.39,46.88 364.59,47.08 364.59,48.07 v2(364.03,48.63)
  BOTTOM w0.076: 361.23,47.68 RT49.1
  BOTTOM w0.089: RT49.1 360.6,47.51 360.6,48.06 360.4,48.26 359.6,48.26 358.95,48.91 UT1.AC3
  BOTTOM w0.14: 361.23,47.68 361.4,47.86 362.08,47.86 362.85,48.63 v2(364.03,48.63) ; v2(349.09,40.29) UT2.1
TBT_EE_DI: length 24
  TOP w0.14: v1(361.64,49.08) 361.64,48.95 v2(361.01,48.33)
  IN1 w0.097: v2(355.83,43.4) 355.83,44.1 356.27,44.54 356.27,46.19 356.85,46.76 360.38,46.76 360.82,46.32 363.75,46.32 364.11,45.97 364.49,45.97 364.85,46.32 364.85,48.43 364.2,49.08 361.76,49.08 v2(361.01,48.33)
  BOTTOM w0.089: 360.84,48.5 359.66,48.5 359.19,48.97 359.19,49.36 UT1.AB3
  BOTTOM w0.14: v2(355.83,43.4) 355.83,43.84 355.57,44.1 355.01,44.1 ; 360.84,48.5 v2(361.01,48.33)
TBT_EE_DO: length 24.6
  TOP w0.14: v1(358.91,46.87) 358.92,46.88 358.92,47.67 v2(358.98,47.73)
  IN1 w0.097: v2(358.98,47.73) 358.95,47.7 358.63,47.7 358.39,47.46 350.96,47.46 349.94,46.44 349.94,43.66 350.65,42.95 350.65,41.8 350.18,41.33 v2(349.11,41.33)
  BOTTOM w0.076: UT1.AC4 358.49,48.22 v2(358.98,47.73) 359.21,47.5 359.21,47.11 359.36,46.95 360.26,46.95
  BOTTOM w0.14: 360.26,46.95 360.52,46.7 362.29,46.7 RT50.1 ; UT2.2 348.88,41.56 v2(349.11,41.33)
TBT_EE_WP_N: length 34.2
  TOP w0.14: v2(364.15,47.28) 365.04,48.17 365.04,50.86 365.35,51.18 365.35,51.91 365.04,52.23 364.02,52.23 363.58,51.78 v1(361.85,51.78) 361.18,51.78 361.16,51.77 361.16,51.74 v2(361.16,51.74)
  IN1 w0.097: v2(364.15,47.28) 360.21,47.28 359.27,48.22 358.88,48.22 358.54,47.88 358.31,47.65 350.88,47.65 349.74,46.52 349.74,43.67 348.86,42.79 348.86,42.24 v2(349.11,41.99)
  BOTTOM w0.089: UT1.V1 360.05,51.43 360.11,51.49 360.12,51.49 360.21,51.58 360.25,51.58 360.64,51.97 360.93,51.97 v2(361.16,51.74)
  BOTTOM w0.14: v2(349.11,41.99) 349.11,42.22 348.5,42.83 UT2.3 ; v2(364.15,47.28) RT48.2
TBT_FORCE_PWR: length 113.3
  TOP w0.14: RT13.2 358.91,54.58 359.32,54.17 v2(360.6,54.17) 360.6,53.87 v1(360.21,53.48)
  IN3 w0.124: v2(360.6,54.17) 359.93,53.5 359.93,52.2 359.03,51.3 359.03,51.3 359.03,50.89 359.03,50.88 359.03,48.76 357.32,47.05 352.62,47.05 351.67,46.1 346.14,46.1 345.01,47.24 345.01,51.68 341.55,55.14 335.58,55.14 334.78,55.94 326.52,55.94 318.38,47.79 313.85,47.79 313.64,48 309.24,48 307.85,46.61 306.63,46.61 305.98,45.95 295.79,45.95 295.3,46.44 293.9,46.44 293.51,46.83 291.89,46.83 291.27,47.44 291.27,50.85 290.48,51.64 286.44,51.64 286.04,51.24 285.47,51.24 284.88,51.82 282.02,51.82 279.54,49.34 279.54,47.8 279.19,47.45 279.19,46.57 277.86,45.24 277.59,45.24 v2(277.14,44.79)
  BOTTOM w0.076: v2(277.14,44.79) 276.87,45.06 276.87,45.36 276.55,45.68 UH2.P43
TBT_FORCE_PWR_R: length 4.2
  TOP w0.14: RT94.2 357.72,56.33 357.72,55.84 v2(357.74,55.82) 357.88,55.96 v1(358.43,55.96) 358.51,55.96 358.91,55.56 RT13.1 359.5,55.2 RT35.1
  BOTTOM w0.14: UT1.H4 358.71,56.13 358.41,55.82 v2(357.74,55.82)
TBT_HDMI_DDC_CLK: length 3.8
  BOTTOM w0.089: 361.23,51.02 361.07,51.02 360.6,50.54 360.26,50.54 360.22,50.58 360.07,50.74 359.64,50.74 UT1.Y2
  BOTTOM w0.14: 361.23,51.02 362.17,51.02 T9.1
TBT_HDMI_DDC_DATA: length 1.6
  BOTTOM w0.089: UT1.Y1 360.04,50.51 360.19,50.37 360.76,50.37 360.99,50.59
  BOTTOM w0.14: 360.99,50.59 T7.1
TBT_HOLD_N: length 8.1
  BOTTOM w0.14: RT51.2 360.83,44.21 360.02,43.4 359.13,43.4 357.99,42.26 356.97,42.26 356.27,41.56 UT2.7
TBT_I2C_SCL: length 26.4
  TOP w0.14: v1(357.79,69.43) 357.47,69.12 v2(357.47,68.91)
  IN5 w0.097: v2(357.47,68.91) 357.68,69.12 358.6,69.12 358.85,68.88 358.85,66.65 359.65,65.85 360.22,65.85 360.65,65.41 360.65,65.08 360.47,64.89 360.47,57.05 361.1,56.42 361.1,53.81 360.66,53.37 360.66,52.94 360.61,52.89 v2(360.61,52.87)
  BOTTOM w0.076: UT4.D2 359.29,69.43 359.14,69.43 359.04,69.53 358.5,69.53
  BOTTOM w0.089: 360.79,53.04 v2(360.61,52.87) 360.6,52.87 360.59,52.86 360.52,52.86 360.17,52.5 360.17,52.26 360.03,52.12 359.84,52.12 359.64,52.12 UT1.U2
  BOTTOM w0.14: RT27.2 362.51,53.17 360.91,53.17 360.79,53.04 ; v2(357.47,68.91) 357.47,69.01 358,69.54 358.35,69.54 358.35,69.53 358.5,69.53
TBT_I2C_SDA: length 27.5
  TOP w0.14: v2(357.43,68.33) v1(356.83,68.33)
  IN5 w0.097: v2(357.43,68.33) 357.02,68.73 357.02,69.1 357.29,69.37 358.64,69.37 359.05,68.96 359.05,66.73 359.73,66.04 360.3,66.04 361.42,64.93 361.42,59.24 360.73,58.55 360.73,57.07 361.3,56.5 361.3,53.73 361.29,53.72 361.29,52.73 v2(361.14,52.59)
  BOTTOM w0.076: UT4.D1 358.5,69.28
  BOTTOM w0.089: v2(361.14,52.59) 360.84,52.59 360.76,52.51 360.62,52.51 360.35,52.24 360.35,52.19 360.1,51.94 360.05,51.94 360.01,51.89 UT1.U1
  BOTTOM w0.14: v2(361.14,52.59) 361.35,52.8 RT26.2 ; 358.5,69.28 358.22,69.28 357.9,68.96 357.9,68.67 357.56,68.33 v2(357.43,68.33)
TBT_PCIE_WAKE_N: length 6.2
  TOP w0.14: v2(360.41,50.91) 360.85,50.91 361.04,51.1 v1(363.7,51.1) v2(364.66,51.1)
  BOTTOM w0.089: v2(360.41,50.91) 360.39,50.91 360.36,50.93 359.91,50.93 UT1.W1
  BOTTOM w0.14: v2(364.66,51.1) 364.58,51.17 RT10.1 364,51.08 363.54,51.08 RT28.2
TBT_RBIAS: length 1.5
  TOP w0.14: v2(357.09,56.47) 357.09,56.5 356.42,57.16 RT25.1
  BOTTOM w0.14: v2(357.09,56.47) 357.09,56.47 UT1.H6
TBT_RESET_N: length 23
  IN3 w0.124: v2(369.19,69.12) 369.43,68.87 369.43,66.86 366.28,63.71 363.11,63.71 360.97,61.57 v2(360.97,60.67)
  IN4 w0.137: v2(358.41,57.12) 358.41,57.14 358.88,57.61 358.88,58.51 360.97,60.61 v2(360.97,60.67)
  BOTTOM w0.076: v2(358.41,57.12) 358.41,57.11 358.41,57.09 UT1.F4 ; v2(360.97,60.67) 361.04,60.73 RT121.1 361.01,61.2 RT80.2
  BOTTOM w0.14: v2(369.19,69.12) 368.92,69.38 367.63,69.38 367.2,69.81 RT102.2
TBT_RESET_N_EC#: length 123
  TOP w0.14: UE1.97 313.2,22.3 313.37,22.13 313.92,22.13 314.96,23.17 v2(315.84,23.17)
  IN1 w0.097: v2(305.74,15.33) 306.27,15.86 308.8,15.86 312.65,19.71 313.93,19.71 315.05,20.83 315.05,22.38 v2(315.84,23.17) ; v2(346.56,29.09) 347.47,28.18 352.89,28.18 354.65,26.41 359.86,26.41 363.36,29.91 363.36,43.22 365.58,45.44 365.58,53.84 363.27,56.15 363.27,56.9 361.88,58.29 361.88,60.46 361.01,61.33 v2(361.01,62.32)
  IN3 w0.124: v2(368.73,68.74) 368.92,68.54 368.92,67.06 366.07,64.21 362.9,64.21 v2(361.01,62.32)
  IN4 w0.137: v2(346.56,29.09) 346.34,28.87 336.1,28.87 332.23,25 317.67,25 v2(315.84,23.17)
  BOTTOM w0.14: RE151.2 302.27,14.86 305.27,14.86 v2(305.74,15.33) ; RT121.2 361.03,61.77 361.03,62.14 361.01,62.16 v2(361.01,62.32) ; v2(368.73,68.74) 368.48,68.99 RT122.2
TBT_RSENSE: length 1.3
  TOP w0.14: v2(357.08,55.82) 356.56,56.34 RT25.2
  BOTTOM w0.14: UT1.J6 v2(357.08,55.82)
TBT_RST#_R: length 244.1
  TOP w0.14: v2(160.99,87.78) 160.99,87.82 161.41,88.25 RT1.2 ; v1(184.27,79.96) 184.02,79.72 v2(183.49,79.72)
  IN2 w0.097: v2(330.21,47.11) 328.58,45.47 328.58,40.97 326.52,38.91 318.95,38.91 316.58,41.28 316.58,41.91 315.94,42.56 315.94,47.94 316.7,48.7 316.7,52.36 313.29,55.78 309.64,55.78 308.18,57.24 304.59,57.24 302.95,58.88 298.76,58.88 290.74,66.89 289.54,66.89 288.9,67.53 287,67.53 286.36,66.89 284.25,66.89 282.03,69.11 277.62,69.11 277.61,69.12 275.24,69.12 274.92,68.8 264.42,68.8 262.09,71.13 245.37,71.13 244.55,71.94 222.94,71.94 222.27,71.28 212.13,71.28 211.78,70.92 206.77,70.92 205.15,72.54 198.45,72.54 197.68,73.31 194.61,73.31 193.02,74.9 193.02,75.72 193.46,76.16 193.46,76.7 192.83,77.34 191.9,77.34 191.62,77.05 190.09,77.05 189.14,76.1 187.23,76.1 183.61,79.72 v2(183.49,79.72)
  IN5 w0.097: v2(330.21,47.11) 331.31,48.2 337.02,48.2 338.44,49.62 340.84,49.62 345.58,54.36 346.28,54.36 346.4,54.48 348.11,54.48 348.97,53.62 353.48,53.62 354.33,52.77 355.39,52.77 356.27,53.66 356.27,54.47 356.97,55.17 v2(358.39,55.17) ; v2(183.49,79.72) 182.79,79.02 177.39,79.02 175.11,81.31 171.24,81.31 170.66,81.88 165.29,81.88 164.9,82.27 164.9,82.69 163.87,83.72 163.87,84.83 160.99,87.71 v2(160.99,87.78)
  BOTTOM w0.14: UT1.L4 v2(358.39,55.17)
TBT_SRC_AUX_N: length 1.7
  TOP w0.14: v2(351.24,50.63) 350.42,49.81 T26.1
  BOTTOM w0.076: v2(351.24,50.63) 351.56,50.31 UT1.Y19
TBT_SRC_AUX_P: length 1.5
  TOP w0.14: v2(351.24,51.27) 351.07,51.09 T25.1
  BOTTOM w0.076: UT1.W19 v2(351.24,51.27)
TBT_SRC_CFG1: length 5.7
  BOTTOM w0.076: 360.78,49.65 360.49,49.94 360.14,49.94 360.02,50.05 UT1.AA1
  BOTTOM w0.14: RT11.1 364.06,49.65 v1(363.63,49.22) 363.45,49.04 361.39,49.04 360.78,49.65
TBT_SRC_HPD: length 4.5
  BOTTOM w0.076: UT1.G1 360.05,56.49 361.03,55.51 361.03,54.62 361.23,54.42
  BOTTOM w0.14: RT4.1 362.65,54.7 362.19,54.24 v1(361.8,54.24) 361.4,54.24 361.23,54.42
TBT_SVR_IND:
  vias: v1(362.67,61.43)
TBT_TCK: length 50
  IN5 w0.097: v2(367.02,76.48) 367.48,76.48 370.63,73.33 370.63,66.5 369.35,65.22 369.35,58.53 367.49,56.68 365.65,56.68 364.9,55.93 364.9,53.67 365.54,53.03 365.54,46.2 364.56,45.22 363.54,45.22 362.9,45.85 362.9,48.51 361.52,49.9 361.52,50.35 361.27,50.6 360.93,50.6 360.84,50.5 360.24,50.5 360.01,50.74 360.01,50.99 358.88,52.12 358.8,52.12 358.39,52.53 v2(358.39,52.57)
  BOTTOM w0.14: RT7.2 366.83,76.29 v2(367.02,76.48) ; UT1.T4 v2(358.39,52.57)
TBT_TDI: length 40.5
  TOP w0.14: v2(366.5,76.93) 366.85,77.28 v4(366.85,78.26)
  IN4 w0.137: v2(366.5,76.93) 367.49,77.92 369.73,77.92 369.93,77.73 369.93,77.12 368.64,75.83 368.64,69.65 367.74,68.75 363.99,68.75 362.75,67.51 362.75,66.13 361.67,65.05 361.67,61.04 361.73,60.98 361.73,59.63 359.69,57.59 359.69,52.23 359.09,51.63 359.09,51.37 358.69,50.97 358.69,50.92 v2(358.39,50.62)
  BOTTOM w0.14: RT9.2 v2(366.5,76.93) ; UT1.Y4 v2(358.39,50.62)
TBT_TDO: length 34.8
  TOP w0.14: v2(369.39,77.5) v1(369.39,78.25)
  IN4 w0.137: v2(369.39,77.5) 368.4,76.51 368.4,69.75 367.64,68.99 363.89,68.99 362.51,67.61 362.51,66.23 361.44,65.15 361.44,60.94 361.49,60.89 361.49,59.73 359.45,57.68 359.45,52.33 v2(358.39,51.27)
  BOTTOM w0.14: v2(369.39,77.5) 369.33,77.56 RT6.2 ; UT1.W4 v2(358.39,51.27)
TBT_TEST_EN: length 2.1
  BOTTOM w0.076: UT1.E1 359.92,57.37 361.23,57.37
  BOTTOM w0.14: RT17.1 361.63,57.37 361.23,57.37
TBT_TEST_PWG: length 3.4
  BOTTOM w0.076: 359.06,46.95 v1(358.58,47.44) 358.28,47.74 358.28,49.33 358.03,49.58 UT1.AB5
  BOTTOM w0.14: RT18.1 359.13,46.89 359.06,46.95
TBT_TMS: length 2.5
  TOP w0.14: v2(358.39,51.92) 358.86,51.92 v4(359.08,51.7) 359.51,51.26 RT8.2
  BOTTOM w0.14: UT1.V4 v2(358.39,51.92)
TBT_TMU_CLK_OUT: length 2.8
  BOTTOM w0.089: 360.84,52.2 360.61,52.2 360.17,51.76 360.13,51.76 360.04,51.67 360.04,51.67 360.02,51.66 359.64,51.66 UT1.V2
  BOTTOM w0.14: RT34.1 361.85,52.2 360.84,52.2
TBT_XTAL_25_IN: length 3.5
  BOTTOM w0.089: 348.91,59.34 349.46,58.79 349.46,58.24 349.59,58.11 349.63,58.11 349.63,58.11 349.98,58.11 UT1.D22
  BOTTOM w0.14: RT116.1 348.29,59.48 348.77,59.48 348.91,59.34
TBT_XTAL_25_IN_R: length 5.1
  BOTTOM w0.14: YT1.3 347.66,64.12 347.66,61.92 348.01,61.57 CT38.1 347.89,61.25 RT116.2
TBT_XTAL_25_OUT: length 3.9
  BOTTOM w0.089: UT1.D23 349.55,57.87 349.28,58.14 349.28,58.65 348.73,59.2 348.27,59.2 348.11,59.03
  BOTTOM w0.14: RT117.1 347.26,59.69 347.92,59.03 v1(348.1,59.03) 348.11,59.03
TBT_XTAL_25_OUT_R: length 2.5
  BOTTOM w0.14: YT1.1 347.14,62.52 CT37.1 347.26,61.25 RT117.2
TBTA_CC1: length 21.4
  TOP w0.14: v2(366.07,75.52) v1(365.35,75.52)
  TOP w0.254: JUSBC1.B5 377.15,70.98 376.9,71.22 376.68,71.22 v2(376.67,71.23)
  IN3 w0.406: 375.91,71.23 v2(376.67,71.23)
  IN3 w0.508: 375.91,71.23 375.45,71.69 375.45,72.49 374.65,73.29 374.65,75.25 372.95,76.95 370.08,76.95 368.85,75.72 366.26,75.72 v2(366.07,75.52)
  BOTTOM w0.254: UT4.L9 362.94,72.82 363.46,73.33
  BOTTOM w0.305: 363.46,73.33 364.47,74.34 CT112.1
  BOTTOM w0.356: DT11.3 364.96,75.13 364.96,74.95 364.77,74.75 364.77,74.74 364.76,74.74 364.76,74.74 364.68,74.67 CT112.1
  BOTTOM w0.508: v2(366.07,75.52) DT11.3
TBTA_CC2: length 18
  TOP w0.14: v1(366.75,74.89) 366.44,74.89 v2(366.07,74.52)
  TOP w0.305: v2(372.78,69.71) 372.82,69.75 374.63,69.75 374.65,69.73 JUSBC1.A5
  IN3 w0.508: v2(366.07,74.52) 366.57,75.02 368.53,75.02 371.07,72.48 371.07,71.85 372.78,70.13 v2(372.78,69.71)
  BOTTOM w0.254: 364.21,73.18 363.83,73.18 363.44,72.79 UT4.L10
  BOTTOM w0.305: 364.21,73.18 365.35,74.32 DT11.2
  BOTTOM w0.356: v2(366.07,74.52) 366.07,74.45 365.93,74.31 365.93,73.74 CT113.1
  BOTTOM w0.508: v2(366.07,74.52) DT11.2
TBTA_DEBUG1: length 23.4
  IN1 w0.097: v2(364.71,64.98) 363.83,65.85 363.83,68.04 363.64,68.23 363.64,71.91 362.62,72.93 360.02,72.93 359.22,73.73 v2(359.07,73.73)
  BOTTOM w0.089: UT4.L2 359.44,73.04 359.13,73.35
  BOTTOM w0.102: 359.13,73.35 359.13,73.66 v2(359.07,73.73)
  BOTTOM w0.14: v2(364.71,64.98) 364.55,64.82 362.4,64.82 RT118.1 ; v2(359.07,73.73) 359.05,73.73 358.45,74.32 v1(358.01,74.32) 357.2,74.32 356.5,75.02 354.28,75.02 353.77,74.51 353.59,74.51 RT71.1
TBTA_DEBUG2: length 19.4
  IN2 w0.097: v2(360.25,65.24) 360.21,65.28 360.21,65.74 360.09,65.85 359.05,65.85 358.38,66.52 358.38,67.48 358.88,67.97 358.88,72.79 357.97,73.7 357.46,73.7 v2(357.45,73.69)
  BOTTOM w0.076: UT4.K2 359.19,72.53 359.19,72.94 358.5,73.64
  BOTTOM w0.14: v2(360.25,65.24) 360.36,65.36 RT119.1 ; 358.5,73.64 358.45,73.68 357.99,73.68 357.99,73.69 357.45,73.69 v2(357.45,73.69) 357.32,73.69 v1(356.69,74.31) 356.23,74.78 354.38,74.78 353.85,74.25 353.63,74.25 RT72.1
TBTA_DIG_AUD_N: length 7.5
  BOTTOM w0.076: 359.33,74.63 v1(359.31,74.62) ; UT4.K3 359.69,72.53 359.69,73
  BOTTOM w0.089: 359.69,73 359.69,73.14 359.47,73.36 359.47,74.01 359.31,74.17
  BOTTOM w0.14: 359.33,74.63 361.21,76.52 361.89,76.52 362.42,77.05 RT69.1 RT115.2 ; 359.31,74.17 v1(359.31,74.62)
TBTA_DIG_AUD_P: length 6.3
  BOTTOM w0.089: 359.64,74.49 359.64,73.43 359.87,73.2 359.87,72.85 UT4.L3
  BOTTOM w0.14: 359.64,74.49 361.32,76.16 v1(361.54,76.16) 361.87,76.16 362.26,75.78 RT114.2 RT68.1
TBTA_HPD: length 18.9
  TOP w0.14: RT41.1 358.81,53.92 358.81,54.05 358.39,54.47 358.39,54.52 v2(358.39,54.52)
  IN4 w0.137: v2(362.94,68.76) 361.63,67.44 361.63,65.97 361.01,65.36 361.01,63.86 360.41,63.27 360.41,62.07 359,60.66 359,59.78 357.89,58.67 357.89,56.32 358.85,55.36 358.85,54.98 v2(358.39,54.52)
  BOTTOM w0.076: UT4.C10 362.97,68.78 v2(362.94,68.76)
  BOTTOM w0.14: v2(358.39,54.52) UT1.M4
TBTA_HRESET: length 91
  TOP w0.14: v2(315.89,25.19) 316.45,24.63 RE148.1 ; v1(361.18,69.55) v2(361.18,68.86) 360.55,68.23 RT108.1
  IN2 w0.097: v2(361.18,68.86) 361.18,67.84 361.49,67.53 361.49,65.61 361.66,65.45 361.66,53.54 362.18,53.02 362.18,44.41 361.21,43.44 361.21,42.22 360.75,41.76 359.14,41.76 357.42,40.03 355.32,40.03 355.25,39.96 353.68,39.96 353.58,40.06 352.17,40.06 351.89,39.78 351.89,35.84 352.46,35.27 353.59,35.27 v2(354.1,34.76)
  IN4 w0.137: v2(315.89,25.19) 316.93,26.23 332.73,26.23 336.69,30.2 347.73,30.2 349.64,32.11 351.88,32.11 354.1,34.33 v2(354.1,34.76)
  BOTTOM w0.089: v2(361.18,68.86) 361.44,69.12 UT4.D6
TBTA_HRESET_EC: length 3.8
  TOP w0.14: v1(317.53,23.22) 317.07,22.76 RE148.2 315.85,22.16 315.85,21.61 315.63,21.39 UE1.96
TBTA_I2C_INT: length 19.5
  TOP w0.14: v1(358.48,59.52) 358.15,59.18 RT32.2 358.15,58.2 357.96,58 357.96,57.65 357.98,57.63 357.98,56.88 v2(358.39,56.47)
  IN5 w0.097: v2(358.39,56.47) 358.49,56.47 360.21,58.19 360.21,63.91 359.8,64.32 359.8,65.41 358.65,66.57 358.65,68.4 v2(358.33,68.72)
  BOTTOM w0.076: UT4.C1 358.88,68.72 358.5,68.72 ; v2(358.39,56.47) 358.75,56.47 359,56.21 359,55.78 358.72,55.49 UT1.J4
  BOTTOM w0.14: 358.5,68.72 v2(358.33,68.72)
TBTA_LDO_BMC: length 3.7
  BOTTOM w0.076: 358.5,69.78 UT4.E1
  BOTTOM w0.152: CT98.1 356.91,68.47 357.01,68.57 357.01,69.07 357.73,69.78 358.5,69.78
TBTA_LSRX: length 42.8
  TOP w0.14: v2(368.91,80.42) v1(368.91,81.4)
  IN1 w0.097: v2(360.04,73.88) 360.04,74.28 363.98,78.22 366.71,78.22 v2(368.91,80.42)
  IN5 w0.097: v2(360.04,73.88) 360.02,73.86 360.02,72.89 355.39,68.26 355.39,61.4 355.45,61.35 355.45,61.31 356.4,60.35 357.04,60.35 357.35,60.04 357.35,59.85 357.61,59.59 358.05,59.59 v2(358.56,60.1)
  BOTTOM w0.076: v2(360.04,73.88) 360.04,73.17 360.19,73.02 360.19,72.53 UT4.K4 ; UT1.A4 358.49,59.74 358.56,59.81 v2(358.56,60.1) 358.48,60.18 RT42.1
  BOTTOM w0.14: v2(368.91,80.42) 364.66,80.42 363.17,78.93 RT115.1
TBTA_LSTX: length 24.8
  TOP w0.14: v1(359.89,73.02) 360.27,73.39 v2(360.44,73.39)
  IN5 w0.097: v2(362.61,74.64) 362.12,74.64 360.87,73.39 v2(360.44,73.39) 360.44,73.39 360.44,73.02 355.59,68.18 355.59,61.48 356.49,60.58 357.13,60.58 357.55,60.16 v2(357.86,60.16)
  BOTTOM w0.076: RT21.2 RT40.1 v2(357.86,60.16) 358.03,59.99 UT1.A5
  BOTTOM w0.102: UT4.L4 v2(360.44,73.39)
  BOTTOM w0.14: RT114.1 363.17,75.2 v2(362.61,74.64)
TBTA_MRESET: length 4.2
  BOTTOM w0.076: UT4.E11 364.38,69.78 364.63,69.54
  BOTTOM w0.14: RT122.1 367.32,69.12 367.01,69.43 366.46,69.43 366.19,69.17 366.19,69.1 RT63.1 365.18,68.99 364.63,69.54
TBTA_ROSC: length 4.2
  BOTTOM w0.076: 358.5,71.03 359.04,71.03 359.12,70.96 359.27,70.96 UT4.G2
  BOTTOM w0.14: 358.5,71.03 358.49,71.03 357.04,71.03 356.73,70.72 356.4,70.72 RT75.1
TBTA_SBU1: length 23.9
  TOP w0.14: JUSBC1.B8 376.67,69.48 v2(376.67,69.47) ; v2(363.5,74.1) v1(364.49,74.1)
  IN1 w0.097: v2(373.86,74.96) 373.86,73.92 374.79,72.99 375.39,72.99 376.15,72.23 376.15,69.69 376.36,69.47 v2(376.67,69.47) ; v2(371.13,74.77) 371.13,74.01 370.95,73.82 365.78,73.82 365.57,73.61 363.4,73.61 363.33,73.68 363.28,73.73 363.28,73.89 v2(363.5,74.1)
  BOTTOM w0.076: v2(363.5,74.1) 363.32,73.93 363.32,73.6 362.78,73.06 362.78,73.04 362.68,72.94 362.68,72.9 362.69,72.89 362.69,72.68 362.68,72.67 362.68,72.53 UT4.K8
  BOTTOM w0.14: v2(373.86,74.96) 373.17,75.66 DT13.1 372.06,75.7 v2(371.13,74.77)
TBTA_SBU2: length 17.2
  TOP w0.14: v2(371.77,72.61) 371.77,71.93 DT14.1 372.51,71.4 374.05,71.4 374.23,71.23 JUSBC1.A8
  IN1 w0.097: v2(371.77,72.61) 371.77,73.51 371.65,73.62 365.86,73.62 365.65,73.41 363.33,73.41 363.2,73.54 363.09,73.65 363.09,73.92 v2(362.9,74.1)
  BOTTOM w0.076: v2(362.9,74.1) 363.15,73.86 363.15,73.66 362.62,73.13 362.62,73.11 362.52,73.01 362.52,72.86 UT4.L8
TBTB_I2C_INT: length 2.4
  BOTTOM w0.076: 361.23,56.92 360.47,56.92 360.21,57.18 359.7,57.18 359.47,57.41 UT1.E2
  BOTTOM w0.14: RT33.2 361.51,56.92 361.23,56.92
THM_SML1_CLK: length 17.6
  TOP w0.14: v2(95.14,76.14) v1(95.56,76.56) 95.76,76.76 97.16,76.76 97.52,76.39 RTH3.2 97.52,75.54 97.4,75.42 QTH3.4 97.4,74.83 97.64,74.59 RTH6.1
  BOTTOM w0.14: v2(95.14,76.14) 94.41,75.42 94.41,71.85 95.78,70.48 95.78,67.38 96.38,66.78 UTH1.10
THM_SML1_DATA: length 12.1
  TOP w0.14: v2(94.87,72.86) v1(93.88,72.86) 93.88,73.83 RTH4.2 94.6,73.85 RTH5.1 95.61,73.68 QTH3.1
  BOTTOM w0.14: v2(94.87,72.86) 94.87,71.88 96.11,70.64 96.11,67.76 96.59,67.28 UTH1.9
TMDS_T_TX0N: length 60.2
  TOP w0.112: UP2.16 335.05,48.88 334.97,48.96 334.97,49.27 335.49,49.79 335.49,53.26 335.86,53.64 335.86,54.42 336.55,55.11 340.81,55.11 345.16,59.46 345.69,59.46 347.06,60.83 349.62,60.83 350.32,61.53 350.32,62.83 351.07,63.58 v3(351.07,68.25) 351.07,69.98 352.36,71.27 354.68,71.27 355.32,71.92 355.32,73.7 355.74,74.12 359.36,74.12 359.66,74.41 360.18,74.41 363.77,77.99 363.77,82.01 366.69,84.93 366.69,85.49 RV557.2 367.02,86.63 366.88,86.77 367.01,86.9 RV612.1
TMDS_T_TX0N_R: length 13.2
  TOP w0.112: RV612.2 367.01,87.89 366.88,88.02 366.88,88.1 366.56,88.42 366.56,88.83 366.79,89.06 v3(367.09,89.06) 368.44,89.06 369.87,87.63 370.72,87.63 371.12,88.03 371.12,93.6 371.25,93.72 371.35,93.72 371.8,93.27 JHDMI1.9
TMDS_T_TX0P: length 60.2
  TOP w0.112: RV611.1 366.12,86.93 366.28,86.77 366.1,86.59 RV557.1 366.4,85.52 366.4,85.05 363.48,82.12 363.48,78.11 360.07,74.7 359.54,74.7 359.25,74.4 355.62,74.4 355.04,73.82 355.04,72.04 354.56,71.56 352.24,71.56 350.78,70.1 v3(350.78,65.09) 350.78,63.7 350.03,62.95 350.03,61.65 349.5,61.12 346.94,61.12 345.57,59.75 345.04,59.75 340.69,55.4 336.44,55.4 335.58,54.54 335.58,53.76 335.2,53.38 335.2,50.58 335.28,50.51 335.28,49.88 334.76,49.36 334.76,48.99 334.65,48.88 UP2.17
TMDS_T_TX0P_R: length 13.3
  TOP w0.112: RV611.2 366.12,87.86 366.28,88.02 366.28,88.95 366.67,89.34 368.56,89.34 v3(368.83,89.07) 369.99,87.91 370.6,87.91 370.84,88.15 370.84,93.71 371.22,94.1 JHDMI1.7
TMDS_T_TX1N: length 70.6
  TOP w0.112: UP2.19 333.85,48.88 333.8,48.93 333.8,49.37 333.54,49.63 333.54,52.48 335.04,53.98 335.04,54.59 337.63,57.18 v3(339.08,57.18) 341.32,57.18 344.75,60.61 345.29,60.61 346.24,61.56 349.35,61.56 349.62,61.82 349.62,63.12 350.37,63.87 350.37,70.27 352.07,71.97 352.6,71.97 355.45,74.82 359.07,74.82 359.36,75.11 359.89,75.11 362.94,78.15 362.94,81.4 362.08,82.25 362.08,90.5 362.67,91.08 366.73,91.08 367.7,92.05 367.7,92.66 RV562.2 367.97,93.36 367.66,93.67 367.66,93.83 367.71,93.88 367.83,93.88 367.96,94.01 RV614.1
TMDS_T_TX1N_R: length 8
  TOP w0.112: JHDMI1.6 369.61,95.24 369.61,95.51 369.01,96.11 369.01,97.51 368.5,98.02 367.91,98.02 367.63,97.75 v3(367.63,96.55) 367.63,95.33 367.96,95 RV614.2
TMDS_T_TX1P: length 70.6
  TOP w0.112: RV613.1 367.07,94.04 367.23,93.88 367.32,93.88 367.37,93.83 367.37,93.67 367.06,93.36 RV562.1 367.42,92.57 367.42,92.17 366.62,91.37 362.55,91.37 361.8,90.62 361.8,82.13 362.65,81.28 362.65,78.27 359.78,75.4 359.25,75.4 358.96,75.11 355.33,75.11 352.48,72.26 351.95,72.26 350.08,70.39 350.08,63.99 349.33,63.24 349.33,61.94 349.23,61.84 346.12,61.84 345.17,60.89 344.63,60.89 v3(343.24,59.5) 341.2,57.46 337.51,57.46 334.76,54.71 334.76,54.1 333.26,52.6 333.26,49.52 333.45,49.32 UP2.20
TMDS_T_TX1P_R: length 8
  TOP w0.112: JHDMI1.4 369.92,95.6 369.29,96.23 369.29,97.63 368.61,98.3 v3(368.14,98.3) 367.79,98.3 367.35,97.86 367.35,95.25 367.07,94.97 RV613.2
TMDS_T_TX2N: length 67.2
  TOP w0.112: UP2.22 332.65,48.88 332.6,48.93 332.6,49.61 332.84,49.85 332.84,52.77 334.32,54.25 334.32,54.88 337.51,58.08 340.86,58.08 345.23,62.45 345.23,65.41 349.67,69.85 349.67,70.57 351.77,72.67 352.31,72.67 355.16,75.52 358.78,75.52 359.07,75.81 359.58,75.81 362.15,78.39 362.15,81.19 361.38,81.96 v3(361.38,85.56) 361.38,91.22 362.17,92.01 365.64,92.01 365.93,92.29 365.93,92.66 RV565.2 366.19,93.74 366.05,93.88 366.18,94.01 RV616.1
TMDS_T_TX2N_R: length 10.7
  TOP w0.112: JHDMI1.3 371.39,96.51 371.39,96.55 371.13,96.8 371.03,96.8 370.91,96.92 370.91,96.94 369.04,98.81 366.6,98.81 365.76,97.97 v3(365.76,96.17) 365.76,95.43 366.18,95 RV616.2
TMDS_T_TX2P: length 67.2
  TOP w0.112: UP2.23 332.25,48.88 332.32,48.95 332.32,49.73 332.56,49.97 332.56,52.89 334.03,54.36 334.03,55 337.39,58.36 340.74,58.36 344.94,62.57 344.94,65.53 349.38,69.97 349.38,70.68 351.66,72.96 352.19,72.96 355.04,75.81 358.67,75.81 358.94,76.08 358.97,76.1 359.46,76.1 361.87,78.51 361.87,81.07 361.1,81.84 v3(361.1,88.5) 361.1,91.34 362.05,92.29 365.52,92.29 365.6,92.37 365.6,92.6 RV565.1 365.28,93.71 365.45,93.88 365.29,94.04 RV615.1
TMDS_T_TX2P_R: length 10.8
  TOP w0.112: JHDMI1.1 371.15,97.1 369.16,99.09 366.48,99.09 v3(365.94,98.55) 365.45,98.06 365.45,95.13 365.3,94.97 RV615.2
TMDS_T_TXCN: length 54.7
  TOP w0.112: v2(364.74,84.99) 364.62,85.11 364.62,85.47 364.97,85.82 RV554.2 364.99,86.63 364.85,86.77 364.97,86.9 RV610.1 ; v2(339.84,50.13) 339.56,50.42 339.39,50.42 339.18,50.2 339.18,49.99 338.89,49.7 338.89,49.57 338.79,49.46 338.65,49.46 338.49,49.3 338.49,49.06 CP23.2 338.12,49.28 337.96,49.28 337.6,48.92 336.36,48.92 336.25,48.81 UP2.13
  IN1 w0.089: v2(364.74,84.99) 364.74,82.09 358.55,75.91 355.7,75.91 345.21,65.41 345.21,63.97 341.92,60.69 341.92,57.51 340.98,56.56 340.98,51.02 340.25,50.3 340.01,50.3 v2(339.84,50.13)
TMDS_T_TXCN_R: length 8.8
  TOP w0.112: JHDMI1.12 369.86,91.99 369.86,92.12 369.67,92.32 369.45,92.32 367.31,90.17 365.73,90.17 v3(365.17,89.62) 364.55,88.99 364.55,88.32 364.97,87.89 RV610.2
TMDS_T_TXCP: length 54.6
  TOP w0.112: UP2.14 335.85,48.88 336.18,49.21 337.49,49.21 337.85,49.57 338.08,49.57 CP23.1 338.69,49.9 338.89,50.11 338.89,50.32 339.27,50.7 339.83,50.7 v2(339.84,50.72) ; RV609.1 364.08,86.93 364.25,86.77 364.07,86.59 RV554.1 364.34,85.55 364.34,85.17 v2(364.16,84.99)
  IN1 w0.089: v2(364.16,84.99) 364.16,84.83 364.25,84.74 364.39,84.74 364.48,84.65 364.48,82.2 358.45,76.16 355.59,76.16 344.95,65.52 344.95,64.08 341.66,60.79 341.66,57.62 340.72,56.67 340.72,51.13 340.41,50.82 340.28,50.82 340.12,50.98 339.93,50.98 339.84,50.89 v2(339.84,50.72)
TMDS_T_TXCP_R: length 8.8
  TOP w0.112: JHDMI1.10 369.33,92.6 v3(367.84,91.11) 367.19,90.46 365.61,90.46 364.25,89.09 364.25,88.02 364.09,87.86 RV609.2
TON_1.2V: length 2.5
  TOP w0.203: PU200.9 113.82,67.58 114.15,67.91 114.15,68.48 114.41,68.74 PR207.2
TOUCH_SCREEN_PD#: length 211.2
  TOP w0.14: v1(88.19,47.15) 88.75,47.15 v2(88.88,47.02)
  IN4 w0.137: v2(88.88,47.02) 88.88,45.93 91.03,43.77 91.03,37.43 94.4,34.06 97.7,34.06 99.18,35.55 110.46,35.55 111.13,34.88 240.75,34.88 241.34,35.46 241.34,37.49 242.05,38.2 242.05,40.67 242.53,41.15 243.88,41.15 244.71,40.32 245.63,40.32 245.63,40.31 246.84,40.31 248.06,39.09 249.1,39.09 251,37.19 251,36.16 251.32,35.84 260.22,35.84 260.29,35.78 264.5,35.78 267.43,38.71 271.94,38.71 272.28,39.04 v2(274.03,39.04)
  BOTTOM w0.076: 274.23,39.15 274.49,39.4 275.08,39.4 UH2.AE44
  BOTTOM w0.14: DI1.1 88.11,47.15 88.75,47.15 v2(88.88,47.02) ; 274.23,39.15 274.13,39.04 v2(274.03,39.04) 273.71,39.04 273.11,38.45 272.91,38.45 RH69.1
TOUCHPAD_INTR#: length 8.3
  TOP w0.14: RH179.1 281.39,28.84 282.39,27.85 282.7,27.85 282.79,27.94 DH1.2 283.38,28.65 285.29,30.57 285.29,31.34 v1(285.47,31.52) v2(285.91,31.95)
  BOTTOM w0.076: v2(285.91,31.95) 286.08,31.78 UH2.BC23
TP_EN#: length 185.7
  TOP w0.14: v2(307.19,8.92) 307.2,8.91 UE1.49
  IN1 w0.097: v2(135.17,25.68) 135.78,26.3 237.77,26.3 239.73,24.33 252.03,24.33 253.03,23.33 256.17,23.33 264.07,15.43 268.18,15.43 272.19,11.42 277.17,11.42 279.06,9.53 295.65,9.53 296.36,10.24 296.36,10.78 296.73,11.15 298.44,11.15 299.13,10.46 304.11,10.46 304.76,9.81 304.95,9.81 305.39,9.38 306.5,9.38 307.01,8.87 307.14,8.87 v2(307.19,8.92)
  BOTTOM w0.127: v2(135.17,25.68) v1(135.17,25.03)
  BOTTOM w0.14: v2(135.17,25.68) RZ32.1 133.91,26.5 UE4.4
TP_WAKE_KBC#: length 8.4
  TOP w0.14: UE1.33 300.8,6.49 300.56,6.25 299.87,6.25 299.53,5.91 v4(299.06,5.91) 298.86,5.91 297.65,7.11 296.23,7.11 RE53.1 294.83,7.06 RE61.1
TPM_LPM#: length 20.6
  TOP w0.14: RTPM9.1 288.9,10.47 v2(288.84,10.53) 288.65,10.72 v1(288.65,11.39)
  IN1 w0.097: v2(297.65,14.93) 297.12,14.4 293.14,14.4 292.49,13.76 290.82,13.76 288.84,11.78 v2(288.84,10.53)
  BOTTOM w0.14: UTPM1.3 291.43,11.13 291.3,11 289.27,11 288.84,10.57 v2(288.84,10.53) 288.84,10 289.12,9.72 QTPM1.1 ; v2(297.65,14.93) 297.65,13.82 297.18,13.35 RTPM11.2
TPM_PIRQ#: length 36
  TOP w0.14: RH568.2 280.16,33.48 279.06,34.58 v1(279.06,35.08) 279.06,35.88 v2(278.25,36.69)
  IN2 w0.097: v2(275.54,28.97) 275.91,29.34 275.91,30.38 276.8,31.27 276.8,31.9 277.42,32.53 277.42,33.04 276.62,33.84 276.62,35.62 277.24,36.24 277.92,36.24 278.25,36.57 v2(278.25,36.69)
  BOTTOM w0.076: v2(275.54,28.97) 275.86,29.29 276.29,29.29 276.65,28.93 279.58,28.93 280.04,28.48 ; UH2.AN38 278.76,36.18 v2(278.25,36.69)
  BOTTOM w0.14: RTPM12.1 287.43,20.06 287.43,20.59 287.16,20.86 286.69,20.86 286.43,20.6 286.43,20.42 286.03,20.02 283.33,20.02 283.07,20.28 283.07,23.77 282.87,23.97 282.87,25.49 282.03,26.33 281.65,26.33 280.38,27.6 280.38,28.13 280.04,28.48
TPM_PIRQ#_R: length 4
  BOTTOM w0.14: UTPM1.18 289.43,17.41 288.79,18.05 288.52,18.05 RTPM12.2 287.52,18.57 v1(287.52,17.86)
TRIP_+1.35V: length 4.1
  TOP w0.14: v1(232.97,57.99) 233.62,57.34 234.51,57.34 PR802.2
  TOP w0.254: PU800.2 235.63,56.22 PR802.2
TS_EN: length 6.8
  BOTTOM w0.14: DI1.2 92.75,47.78 93.78,46.75 JEDP1.12
TYPEC_SMBCLK: length 87.9
  TOP w0.14: v2(317.82,20.67) 317.82,20.13 RE140.1 317.07,19.39 UE1.91
  IN3 w0.124: v2(363.41,65.24) 362.67,65.98 358.23,65.98 357.69,65.43 357.69,64.56 354.34,61.21 350.24,61.21 349.57,60.55 343.77,60.55 339.76,56.54 v2(339.76,56.23)
  BOTTOM w0.076: 363.38,65.62 363.38,65.65 RT60.1
  BOTTOM w0.14: 363.38,65.62 363.41,65.59 v2(363.41,65.24) ; v2(317.82,20.67) 318.33,21.17 319.1,21.17 320.61,22.69 320.61,27.16 319.23,28.54 319.23,30.66 319.51,30.94 319.51,33.11 318.3,34.32 318.3,39.84 321,42.54 321,48.58 327.96,55.55 339.6,55.55 339.76,55.71 v2(339.76,56.23) 339.76,56.82 v1(339.65,56.94)
TYPEC_SMBDA: length 85.6
  TOP w0.14: UE1.89 315.71,18.59 315.95,18.34 317.25,18.34 RE139.1 317.6,18 318.24,17.36 318.94,17.36 v2(319.32,16.98)
  IN3 w0.124: v2(358.13,65.17) 358.13,64.68 354.43,60.99 350.33,60.99 349.66,60.32 343.86,60.32 340.34,56.79 v2(340.34,56.48)
  BOTTOM w0.14: v2(340.34,56.48) 340.34,55.67 v1(340.22,55.55) 339.97,55.3 328.99,55.3 321.48,47.8 321.48,42.34 320.42,41.28 320.42,39.2 321.9,37.72 321.9,32.64 321.35,32.1 321.35,22.39 321.65,22.09 321.65,19.32 v2(319.32,16.98) ; RT59.1 359.32,64.95 358.34,64.95 v2(358.13,65.17)
UART_2_CRXD_DTXD: length 66.9
  TOP w0.14: RN6.2 330.8,35.68 v2(330.8,36.22)
  IN4 w0.137: v2(273.51,36.41) 273.92,36.41 274.24,36.09 276.27,36.09 277.03,35.33 277.79,35.33 277.86,35.26 278.56,35.26 278.92,35.61 279.91,35.61 280.19,35.9 283.34,35.9 284.34,34.89 285.27,34.89 285.61,34.55 286.54,34.55 286.89,34.9 288.49,34.9 289.78,33.62 289.78,33.44 290.16,33.06 293.76,33.06 294.92,31.91 295.66,31.91 295.92,32.17 300.08,32.17 300.48,32.57 301.73,32.57 302.49,33.32 305.56,33.32 308.01,35.78 317.98,35.78 318.69,36.49 327.35,36.49 328.12,37.26 330.26,37.26 330.8,36.72 v2(330.8,36.22)
  BOTTOM w0.076: 274.23,36.08 274.31,36.08 274.59,35.8 274.82,35.8 UH2.AR45
  BOTTOM w0.14: RH160.2 v2(273.51,36.41) 273.83,36.1 274.22,36.1 274.23,36.08
UART_2_CRXD_DTXD_R: length 10.5
  TOP w0.14: v2(331.99,36.22) 331.99,36.1 331.29,35.4 RN6.1 332.25,35.26 332.65,35.66 333.25,35.66 v1(333.71,36.12)
  BOTTOM w0.14: v2(331.99,36.22) 331.99,36.6 332.82,37.43 335.37,37.43 336.49,38.55 JNGFF1.22
UART_2_CTXD_DRXD: length 76.5
  TOP w0.14: v2(278.23,35.72) 277.78,35.27 v1(277.08,35.27) 275.95,35.27 275.13,36.09 274.23,36.09 273.99,36.33 273.99,36.57 273.44,37.11 RH159.2 ; RN7.2 342.51,38.93 v2(342.1,38.52)
  IN4 w0.137: v2(278.23,35.72) 278.36,35.85 279.81,35.85 280.09,36.13 283.44,36.13 283.56,36.02 289.54,36.02 290.03,35.52 290.78,35.52 291.62,34.69 293.4,34.69 293.61,34.9 296.45,34.9 296.82,34.53 297.77,34.53 298.13,34.18 298.49,34.18 299.35,33.32 299.39,33.32 299.4,33.32 301.47,33.32 302.19,34.04 302.39,34.04 304.99,34.04 308.63,37.68 317.39,37.68 318.1,36.97 327.09,36.97 327.86,37.73 336.44,37.73 336.92,37.25 340.83,37.25 v2(342.1,38.52)
  BOTTOM w0.089: UH2.AR39 277.83,35.32 v2(278.23,35.72)
UART_2_CTXD_DRXD_R: length 8.6
  TOP w0.14: v1(340.6,37.98) 341.14,38.51 341.47,38.51 v2(341.49,38.53) 341.59,38.64 RN7.1 RN8.2
  BOTTOM w0.14: JNGFF1.24 340,41.05 341.59,39.45 341.59,38.64 v2(341.49,38.53)
UG_1.2V: length 11.4
  TOP w0.14: 103.13,76.18 v4(101.89,76.18)
  IN1 w0.889: 107.1,67.97 103.79,67.97 103,68.76 103,74.03 103.35,74.39
  vias: v2(103.23,75.62) v2(103.73,75.94) v2(108.82,68.24) v2(109.21,67.79)
UG_3V: length 7.1
  TOP w0.14: v1(72.78,45.98) 72.62,46.14 v2(72.62,46.83)
  IN5 w0.762: 79.21,45.63 78.02,46.83 73.51,46.83
  vias: v2(71.98,46.83) v2(80.1,45.06) v2(80.23,45.69)
UG_5V: length 16.5
  TOP w0.14: 71.67,32.02 v4(71.67,31.09)
  IN5 w0.762: 69.95,32.73 69.57,33.11 69.57,35.14 73.06,38.64 73.06,40.22 73.65,40.8 77.82,40.8 78.4,40.22 79.03,40.22
  vias: v2(71.35,32.29) v2(71.98,32.29) v2(79.92,40.99) v2(79.92,40.35)
UG_+1.35V: length 11.6
  TOP w0.14: 257.61,58.99 257.61,59.64 v1(257.8,59.83)
  IN1 w0.762: 251.5,57.94 250.61,57.05 244.58,57.05 243.95,56.42 241.47,56.42
  vias: v2(240.07,56.29) v2(240.7,56.29) v2(251.25,58.7) v2(251.88,58.7) v2(257.34,58.71) v2(257.92,58.71)
UG_CHG: length 14.5
  TOP w0.14: v2(47.32,46.64) v4(47.32,47.97)
  IN1 w1.016: 36.87,39.84 36.87,40.86 37.19,41.18 37.19,42.76 41.44,47.02 45.58,47.02
  vias: v2(37.82,39.02) v2(46.69,46.64)
UPD1_ALERT: length 120.1
  TOP w0.14: v2(364.72,65.67) 364.31,65.67 v1(363.94,66.04) ; RE141.1 297.3,8.26 298.02,8.99 UE1.32 299.99,8.99 300.58,9.58 301.11,9.58 306.39,14.86 v2(306.39,15.38)
  IN1 w0.097: v2(306.39,15.38) 309.07,15.38 311.09,17.4 311.09,17.48 312.84,19.23 314.13,19.23 315.53,20.63 315.53,22.16 317.55,24.18 v2(317.65,24.18) ; v2(346.56,28.35) 347.21,27.7 352.48,27.7 354.24,25.94 360.08,25.94 363.84,29.69 363.84,43.03 365.78,44.96 366.06,45.24 366.06,54.04 363.74,56.35 363.74,62.97 365.5,64.73 365.5,65.3 365.13,65.67 v2(364.72,65.67)
  IN4 w0.137: v2(346.56,28.35) 336.31,28.35 332.45,24.49 317.96,24.49 v2(317.65,24.18)
  BOTTOM w0.14: v2(364.72,65.67) 364.68,65.67 364.3,65.29 RT120.2
USB2_COMP: length 5
  TOP w0.14: v2(295.28,38.86) 296.05,38.86 v1(296.33,39.14) 296.97,39.78 298.11,39.78 RH109.1
  BOTTOM w0.076: v2(295.28,38.86) 295.53,38.86 UH2.AG3
USB2_ID: length 9.3
  BOTTOM w0.076: UH2.AG2 296.55,39.05 296.96,39.46 298.19,39.46 v1(298.77,40.03) 300.46,40.03 300.78,39.72 300.78,37.06
  BOTTOM w0.14: 300.78,37.06 301.69,36.15 301.88,36.15 RH113.1
USB2_VBUSSENSE: length 3.4
  TOP w0.14: RH112.1 293.24,40.12 293.85,40.73 v2(293.85,41.18)
  BOTTOM w0.076: v2(293.85,41.18) 293.79,41.11 293.47,41.11 292.92,40.56 UH2.AD10
USB3_A_TRX_DTX_N0: length 39.8
  TOP w0.14: JUSBC1.A10 375.75,72.23 arc(375.42,72.29) 375.13,72.48 373.93,73.69 arc(373.89,73.72) 373.86,73.75 373.86,73.75 arc(373.65,73.89) 373.41,73.94 373.34,73.94 arc(372.82,73.84) 372.37,73.54 DT5.1 arc(372.25,73.79) 372.01,73.96 371.9,73.99 arc(371.84,74.01) 371.78,74.01 arc(371.51,73.93) 371.27,73.77 arc(371.15,73.59) 371.11,73.37 371.11,67.94 arc(371.03,67.55) 370.81,67.22 368.31,64.72 arc(367.71,64.32) 367,64.18 357.07,64.18 arc(356.63,64.26) 356.25,64.51 356.01,64.76 arc(355.81,64.89) 355.58,64.94 354.53,64.94 arc(354.39,64.91) 354.27,64.83 arc(354.19,64.77) 354.09,64.76 353.04,64.76 arc(352.79,64.71) 352.58,64.57 v2(352.49,64.48)
  BOTTOM w0.089: 350.51,60.15 350.57,60.09 arc(350.6,60.04) 350.62,59.97 350.62,59.85 arc(350.62,59.83) 350.62,59.81 arc(350.65,59.72) 350.7,59.64 350.85,59.5 arc(350.89,59.42) 350.91,59.34 350.91,59.21 arc(350.9,59.16) 350.87,59.12 350.81,59.06 350.74,59.06 arc(350.69,59.13) 350.67,59.21 UT1.A21
  BOTTOM w0.14: 350.51,60.15 350.51,63.4 arc(350.56,63.65) 350.7,63.86 351.39,64.55 arc(351.62,64.7) 351.89,64.76 arc(352.19,64.7) 352.44,64.53 v2(352.49,64.48)
USB3_A_TRX_DTX_N1: length 29.2
  TOP w0.14: JUSBC1.B10 377.17,68.48 arc(376.93,68.43) v2(376.72,68.29)
  BOTTOM w0.089: UT1.B15 353.3,58.92 arc(353.24,59.03) 353.21,59.15 353.21,59.34 arc(353.24,59.47) 353.31,59.58 353.59,59.86 arc(353.67,59.97) 353.7,60.1 353.7,60.16
  BOTTOM w0.14: 353.7,60.16 353.7,60.17 arc(353.73,60.33) 353.82,60.46 355.39,62.04 arc(355.48,62.17) 355.51,62.32 355.51,62.34 arc(355.57,62.6) 355.72,62.83 356.03,63.14 arc(356.3,63.32) 356.63,63.39 363.94,63.39 arc(364,63.38) 364.04,63.35 arc(364.16,63.25) 364.29,63.17 arc(364.48,63.11) 364.68,63.08 368.13,63.08 368.54,63.08 368.57,63.08 arc(368.9,63.15) 369.17,63.33 371.55,65.71 arc(371.81,65.88) 372.1,65.94 372.89,65.94 arc(373.11,65.98) DT9.1 arc(373.38,66.05) 373.48,66.03 373.56,66.03 arc(373.66,66.08) 373.75,66.15 375.6,68 arc(375.82,68.16) 376.08,68.27 arc(376.18,68.28) 376.29,68.29 arc(376.29,68.29) 376.3,68.29 v2(376.72,68.29)
USB3_A_TRX_DTX_P0: length 39.8
  TOP w0.14: JUSBC1.A11 375.69,72.73 arc(375.35,72.79) 375.06,72.98 374.08,73.97 arc(373.77,74.17) 373.4,74.25 372.85,74.25 arc(372.66,74.28) 372.5,74.39 DT4.1 372.26,74.48 arc(372.12,74.37) 371.95,74.33 arc(371.93,74.32) 371.91,74.32 arc(371.9,74.32) 371.9,74.32 371.88,74.32 arc(371.81,74.32) 371.75,74.32 arc(371.38,74.21) 371.06,73.99 arc(371.05,73.98) 371.04,73.97 arc(370.86,73.71) 370.8,73.41 370.8,67.97 arc(370.74,67.67) 370.57,67.41 368.1,64.94 arc(367.59,64.6) 367,64.48 357.07,64.48 arc(356.75,64.55) 356.47,64.73 356.15,65.05 arc(355.94,65.19) 355.69,65.24 354.43,65.24 arc(354.23,65.2) 354.06,65.09 arc(353.99,65.07) 353.91,65.06 v2(352.49,65.06)
  BOTTOM w0.089: UT1.B21 350.52,58.95 arc(350.46,59.04) 350.44,59.15 350.44,59.78 arc(350.43,59.84) 350.42,59.89 arc(350.39,59.94) 350.35,59.99 350.2,60.14 350.2,60.16
  BOTTOM w0.14: 350.2,60.16 350.2,63.4 arc(350.28,63.76) 350.48,64.07 351.23,64.82 arc(351.49,65) 351.8,65.06 v2(352.49,65.06)
USB3_A_TRX_DTX_P1: length 29.2
  TOP w0.14: JUSBC1.B11 377.37,67.98 arc(377.02,67.91) v2(376.72,67.71)
  BOTTOM w0.089: UT1.A15 353.43,59.22 arc(353.45,59.16) 353.48,59.11 353.61,59.11 arc(353.65,59.18) 353.67,59.26 353.67,59.4 arc(353.66,59.46) 353.63,59.51 353.62,59.51 353.62,59.59 arc(353.63,59.64) 353.66,59.67 353.82,59.83 arc(353.86,59.9) 353.87,59.97 arc(353.88,60.01) 353.89,60.04 arc(353.9,60.05) 353.91,60.06 354,60.15 354,60.15
  BOTTOM w0.14: 354,60.15 arc(354,60.16) 354,60.16 arc(354.01,60.21) 354.04,60.26 355.62,61.83 arc(355.75,62) 355.82,62.2 355.82,62.2 arc(355.88,62.48) 356.04,62.72 356.18,62.86 arc(356.42,63.03) 356.72,63.08 363.77,63.08 arc(363.88,63.06) 363.98,62.99 arc(364.04,62.94) 364.1,62.9 arc(364.32,62.79) 364.56,62.75 368.13,62.75 368.54,62.75 arc(368.99,62.84) 369.37,63.09 371.7,65.43 arc(371.93,65.58) 372.19,65.64 372.4,65.64 arc(372.53,65.63) 372.66,65.59 arc(372.81,65.52) 372.94,65.41 DT8.1 373.48,65.25 arc(373.53,65.31) 373.57,65.39 arc(373.6,65.51) 373.67,65.62 375.74,67.69 arc(375.93,67.84) 376.16,67.94 376.17,67.94 arc(376.47,67.88) v2(376.72,67.71)
USB3_A_TTX_C_DRX_N0: length 32.7
  TOP w0.14: v2(376.66,72.47) 376.66,72.46 376.92,72.2 arc(377.16,72.03) JUSBC1.B3
  BOTTOM w0.14: v2(376.66,72.47) arc(376.57,72.53) 376.47,72.55 375.76,72.55 arc(375.59,72.51) 375.45,72.42 375.2,72.17 arc(375.1,72.02) 375.07,71.85 375.07,68.98 arc(375.03,68.77) 374.9,68.58 arc(374.45,68.28) 373.92,68.18 373.83,68.18 arc(373.26,68.06) DT3.1 arc(372.58,68.14) 372.16,68.3 371.34,68.3 arc(371.15,68.26) 370.98,68.15 370.51,67.68 arc(370.41,67.53) 370.37,67.34 370.37,66.46 arc(370.32,66.22) 370.18,66 368.09,63.91 arc(367.89,63.78) 367.66,63.73 365.11,63.73 arc(364.87,63.78) 364.66,63.92 364.58,64 arc(364.53,64.04) 364.47,64.05 355.91,64.05 arc(355.78,64.08) 355.67,64.15 355.31,64.5 arc(355.13,64.63) 354.91,64.67 354.23,64.67 arc(353.97,64.56) 353.86,64.3 353.86,64.16 arc(353.81,63.93) 353.68,63.73 353.03,63.08 arc(352.96,62.97) CT42.1
USB3_A_TTX_C_DRX_N1: length 25.5
  TOP w0.14: JUSBC1.A3 375.17,68.73 arc(374.96,68.68) 374.79,68.57 arc(374.64,68.34) 374.59,68.08 374.59,67.34 arc(374.54,67.1) 374.41,66.9 374.4,66.9 arc(374.19,66.75) 373.93,66.7 372.96,66.7 arc(372.66,66.76) DT7.1 372.24,66.77 arc(372.08,66.66) 371.9,66.63 371.56,66.63 arc(371.22,66.56) 370.94,66.37 368.19,63.62 arc(368.02,63.5) 367.82,63.46 354.79,63.46 arc(354.71,63.48) v2(354.64,63.53)
  BOTTOM w0.14: CT40.1 arc(353.66,62.64) 353.71,62.68 354.51,63.47 arc(354.57,63.51) v2(354.64,63.53)
USB3_A_TTX_C_DRX_P0: length 32.7
  TOP w0.14: v2(376.66,73.05) 376.87,72.84 376.87,72.84 377.08,72.63 377.08,72.63 arc(377.25,72.51) JUSBC1.B2
  BOTTOM w0.14: v2(376.66,73.05) arc(376.43,72.9) 376.17,72.85 375.76,72.85 arc(375.47,72.79) 375.24,72.63 374.99,72.39 arc(374.82,72.14) 374.77,71.85 374.77,68.98 arc(374.75,68.88) 374.69,68.8 arc(374.34,68.56) 373.92,68.48 373.53,68.48 arc(373.13,68.56) DT2.1 arc(372.58,68.66) 372.35,68.61 371.28,68.61 arc(371.03,68.56) 370.82,68.42 370.3,67.9 arc(370.13,67.64) 370.07,67.34 370.07,66.55 arc(370.02,66.34) 369.9,66.16 367.96,64.22 arc(367.76,64.08) 367.52,64.04 365.23,64.04 arc(364.99,64.08) 364.79,64.22 arc(364.64,64.32) 364.47,64.35 356.08,64.35 arc(355.91,64.39) 355.76,64.49 355.48,64.77 arc(355.21,64.92) 354.91,64.98 354.23,64.98 arc(353.75,64.78) 353.56,64.3 353.56,64.16 arc(353.53,64.05) 353.47,63.95 352.93,63.41 arc(352.74,63.29) CT41.1
USB3_A_TTX_C_DRX_P1: length 25.5
  TOP w0.14: JUSBC1.A2 375.64,68.23 arc(375.46,68.26) 375.3,68.37 arc(375.24,68.41) 375.17,68.42 arc(375.08,68.4) 375.01,68.35 arc(374.92,68.2) 374.89,68.04 374.89,67.33 arc(374.82,66.99) 374.63,66.7 374.5,66.57 arc(374.31,66.44) 374.09,66.4 373.17,66.4 arc(372.93,66.35) 372.74,66.22 DT6.1 372.2,66.09 arc(371.94,66.26) 371.64,66.32 371.56,66.32 arc(371.34,66.28) 371.16,66.15 368.4,63.4 arc(368.14,63.22) 367.82,63.16 355.16,63.16 arc(354.88,63.1) v2(354.64,62.94)
  BOTTOM w0.14: CT39.1 354.14,62.39 arc(354.19,62.62) 354.32,62.81 354.38,62.88 arc(354.5,62.93) v2(354.64,62.94)
USB3_A_TTX_DRX_N0: length 4.2
  BOTTOM w0.089: 351.64,60.16 351.64,59.84 arc(351.69,59.77) 351.7,59.69 351.7,59.6 arc(351.71,59.57) 351.72,59.53 arc(351.73,59.52) 351.74,59.51 arc(351.75,59.49) 351.77,59.47 351.77,59.47 arc(351.8,59.42) 351.82,59.36 351.82,59.14 arc(351.79,59.03) 351.73,58.93 UT1.B19
  BOTTOM w0.14: 351.64,60.16 351.64,61.37 arc(351.72,61.78) 351.95,62.13 352.08,62.26 arc(352.27,62.38) 352.49,62.43 CT42.2
USB3_A_TTX_DRX_N1: length 3.9
  BOTTOM w0.089: UT1.B17 352.38,58.92 arc(352.32,59.03) 352.29,59.15 352.29,59.4 arc(352.32,59.53) 352.39,59.64 352.4,59.65 arc(352.46,59.74) 352.48,59.83 352.48,60.04 arc(352.46,60.1) 352.43,60.16 352.42,60.16
  BOTTOM w0.14: CT40.2 353.19,62.22 352.6,61.63 arc(352.47,61.43) 352.42,61.2 352.42,60.16
USB3_A_TTX_DRX_P0: length 4.2
  BOTTOM w0.089: 351.33,60.16 351.42,60.08 arc(351.45,60.03) 351.46,59.97 351.46,59.77 351.47,59.76 arc(351.5,59.71) 351.51,59.65 arc(351.5,59.6) 351.47,59.55 351.43,59.5 arc(351.42,59.5) 351.41,59.49 arc(351.37,59.42) 351.36,59.34 351.36,59.3 arc(351.38,59.24) 351.45,59.21 351.49,59.21 arc(351.55,59.22) UT1.A19
  BOTTOM w0.14: 351.33,60.16 351.33,61.37 arc(351.44,61.9) 351.74,62.34 351.87,62.47 352.04,62.65 arc(352.1,62.73) CT41.2
USB3_A_TTX_DRX_P1: length 3.9
  BOTTOM w0.089: UT1.A17 352.51,59.18 arc(352.51,59.18) 352.51,59.17 arc(352.53,59.11) 352.57,59.06 352.6,59.06 arc(352.69,59.1) 352.73,59.19 352.73,59.41 arc(352.72,59.48) 352.68,59.54 arc(352.66,59.59) 352.65,59.65 352.65,60.07 352.72,60.14 352.72,60.16
  BOTTOM w0.14: 352.72,60.16 352.72,61.2 arc(352.75,61.32) 352.82,61.42 352.87,61.47 arc(352.97,61.54) 353.08,61.56 arc(353.21,61.53) 353.32,61.46 arc(353.36,61.43) 353.42,61.42 353.46,61.42 arc(353.51,61.43) 353.56,61.46 353.69,61.59 arc(353.72,61.64) CT39.2
USB3RN1: length 316.5
  IN5 w0.104: v2(293.76,53.13) 294.15,52.74 294.15,51.94 294.04,51.83 290.86,51.83 289.83,50.8 289.83,48.9 288.83,47.9 288.83,46.95 288.37,46.48 287.72,46.48 286.67,45.43 284.88,45.43 284.73,45.28 283.96,45.28 281.89,43.21 274.05,43.21 273.81,43.45 272.07,43.45 271.16,42.54 271.16,41.21 269.55,39.6 267.45,39.6 263.07,35.22 263.07,34.33 262.18,33.44 260.78,33.44 259.69,32.35 259.69,30.55 259.34,30.19 246.84,30.19 245.61,28.96 230.9,28.96 230.5,28.56 222.34,28.56 221,27.23 179.49,27.23 178.87,26.6 140.11,26.6 139.29,27.42 107.92,27.42 107.05,28.29 104.73,28.29 103.67,27.23 68.21,27.23 67.74,26.75 37.35,26.75 34.67,29.42 34.67,30.18 31.33,33.53 31.33,36.43 28.33,39.43 26.21,39.43 24.69,40.95 10.11,40.95 8.09,42.96 8.09,43.28 8.18,43.36 8.51,43.36 8.61,43.46 8.61,43.68 8.51,43.78 v2(8.48,43.78)
  BOTTOM w0.076: UH2.B7 293.65,51.82 293.65,52.29 293.64,52.29 293.64,52.33 293.64,52.54 293.94,52.84 293.94,52.94 v2(293.76,53.13)
  BOTTOM w0.14: CI8.1 8.33,44.18 8.33,43.94 v2(8.48,43.78)
USB3RN1_C: length 2.1
  BOTTOM w0.14: UI3.11 8.69,46.72 8.56,46.59 8.56,46.34 8.36,46.13 8.36,45.76 CI8.2
USB3RN1_RE: length 33.2
  TOP w0.14: v2(7.87,58.55) 8.04,58.38 v3(11.62,58.38) 18.97,58.38 19.93,59.35 19.93,59.93 19.75,60.11 19.52,60.11 19.4,59.99 DI12.6 DI12.5 17.87,59.99 17.74,60.11 17.13,60.11 16.78,60.46 16.78,60.89 16.78,61.6 16.1,62.27 16.1,64.69 15.55,65.24 14.87,65.24 14.17,64.54 13.79,64.54 13.62,64.37 JUSB3.5
  BOTTOM w0.14: UI3.20 8.69,51.96 8.76,52.03 8.76,52.28 8.66,52.38 8.5,52.38 8.44,52.43 8.44,56.63 8.93,57.11 8.93,57.91 8.62,58.22 8.23,58.22 7.9,58.55 v2(7.87,58.55)
USB3RN2: length 103.6
  TOP w0.14: JUSB1.5 368.38,52.9 367.96,52.48 367.93,52.48 367.22,51.77 366.57,51.77 365.48,50.68 365.48,47.13 364.91,46.55 364.91,45.54 361.68,42.31 361.68,41.42 360.99,40.72 360.99,40.2 360.86,40.08 DI9.9 DI9.1 360.86,38.34 360.98,38.22 360.98,37.84 v2(360.82,37.68)
  IN1 w0.104: v2(360.82,37.68) 361.03,37.47 361.03,37 360.36,36.32 336.58,36.32 336.07,35.81 329.04,35.81 325.7,39.15 318.42,39.15 317.95,38.68 308.29,38.68 305.92,41.05 305.92,43.87 304.33,45.46 304.01,45.46 301.54,47.93 301.54,51.08 297.72,54.89 293.88,54.89 293.61,54.62 293.61,54.4 v2(293.39,54.17)
  BOTTOM w0.076: 293.37,53.88 293.37,53.48 293.07,53.18 293.07,51.88 292.97,51.79 292.97,51.52 UH2.C8
  BOTTOM w0.14: 293.37,53.88 293.37,53.93 293.39,53.95 v2(293.39,54.17)
USB3RN3: length 98.8
  TOP w0.14: v2(357.32,30.76) 357.32,30.76 357.05,30.5 357.05,30.2 357.19,30.06 357.52,30.06 357.66,30.2 357.66,30.24 357.8,30.38 358.08,30.38 358.22,30.24 358.22,30.2 358.36,30.06 358.68,30.06 358.93,30.3 DI7.1 DI7.9 360.46,30.3 360.58,30.18 365.85,30.18 366.18,30.51 367.09,30.51 367.8,31.21 368.13,31.21 368.38,31.46 JUSB2.5
  IN1 w0.104: v2(292.51,54.69) 292.6,54.77 292.6,54.94 292.49,55.05 292.21,55.05 292.01,54.85 292.01,54.13 292.23,53.92 292.37,53.92 292.52,54.07 292.67,54.07 292.8,53.94 292.8,53.75 292.67,53.62 292.67,53.47 293.72,52.42 294.89,52.42 295.09,52.62 298.8,52.62 300.9,50.52 300.9,47.27 304.59,43.59 304.59,41.53 308.06,38.05 325.35,38.05 328.24,35.16 336.27,35.16 336.83,35.72 350.86,35.72 352.49,34.1 354.78,34.1 356.98,31.9 356.98,31.11 v2(357.32,30.76)
  BOTTOM w0.076: UH2.B10 292.71,51.76 292.33,52.14 292.33,53.53 292.67,53.88
  BOTTOM w0.14: v2(292.51,54.69) 292.51,54.67 292.67,54.51 292.67,53.88
USB3RP1: length 316.5
  IN5 w0.104: v2(294.34,53.13) 294.34,51.86 294.12,51.64 290.94,51.64 290.02,50.72 290.02,48.82 289.03,47.82 289.03,46.87 288.45,46.29 287.8,46.29 286.75,45.24 284.96,45.24 284.81,45.09 284.04,45.09 281.97,43.02 273.97,43.02 273.73,43.26 272.15,43.26 271.35,42.46 271.35,41.13 269.63,39.41 267.53,39.41 263.27,35.14 263.27,34.25 262.26,33.25 260.86,33.25 259.88,32.27 259.88,30.47 259.42,30 246.92,30 245.69,28.77 230.98,28.77 230.58,28.37 222.42,28.37 221.08,27.03 179.57,27.03 178.95,26.41 140.03,26.41 139.21,27.23 107.84,27.23 106.97,28.1 104.81,28.1 103.75,27.03 68.29,27.03 67.82,26.56 37.27,26.56 34.48,29.34 34.48,30.1 31.13,33.45 31.13,36.35 28.25,39.23 26.13,39.23 24.61,40.76 10.03,40.76 7.9,42.88 v2(7.9,43.78)
  BOTTOM w0.076: UH2.A7 293.88,52 293.96,51.92 294.06,51.92 294.11,51.98 294.11,52.16 293.98,52.3 293.87,52.3 293.81,52.36 293.81,52.4 293.81,52.47 294.11,52.77 294.11,52.89 v2(294.34,53.13)
  BOTTOM w0.14: CI7.1 8.07,44.18 8.07,43.95 v2(7.9,43.78)
