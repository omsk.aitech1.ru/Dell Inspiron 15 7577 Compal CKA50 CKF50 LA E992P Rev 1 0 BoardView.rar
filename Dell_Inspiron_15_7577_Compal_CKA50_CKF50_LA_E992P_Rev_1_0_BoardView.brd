# Allegro board Dell_Inspiron_15_7577_Compal_CKA50_CKF50_LA_E992P_Rev_1_0_BoardView.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+5VS on IN5 (solid shape): 369.93,113.57 369.93,112.49 369.8,112.36 366.82,112.36 366.69,112.49 366.69,113.31 367.2,113.82 369.67,113.82
+5VS on IN5 (solid shape): 86.57,62.27 86.57,60.47 86.39,60.29 86.37,60.29 85.64,60.29 85.45,60.48 85.45,62.26 85.64,62.45 86.39,62.45
+5VS on IN5 (solid shape): 102.39,64.11 102.39,64.04 102.53,63.9 102.53,62 101.96,61.43 100.62,61.43 100.05,62 100.05,62.11 101.35,62.11 101.35,62.05 101.36,62 101.37,61.95 101.39,61.91 101.43,61.87 101.46,61.83 101.5,61.8 101.55,61.77 101.6,61.76 101.65,61.75 101.7,61.75 101.75,61.76 101.8,61.77 101.85,61.8 101.89,61.83 101.93,61.87 101.96,61.91 101.98,61.95 102,62 102.01,62.05 102.01,62.11 102,62.16 101.98,62.21 101.96,62.25 101.93,62.3 101.89,62.33 101.85,62.36 101.8,62.39 101.75,62.4 101.7,62.41 101.65,62.41 101.6,62.4 101.55,62.39 101.5,62.36 101.46,62.33 101.43,62.3 101.39,62.25 101.37,62.21 101.36,62.16 101.35,62.11 100.05,62.11 100.05,63.72 100.56,64.23 102.27,64.23
+5VS on BOTTOM: 335.55,30.98 335.19,31.33 324.71,31.33 322.11,33.94 322.11,37.84 320.63,39.32 320.63,41.39 321.17,41.94 322.87,41.94 322.97,41.84 322.97,40.45 322.73,40 323.23,39.86 323.3,39.88 323.37,39.84 323.56,39.72 323.79,39.76 323.86,39.77 323.92,39.73 324.05,39.63 324.21,39.59 324.21,39.59 324.4,39.64 324.53,39.78 325.19,39.78 327.9,37.06 328.13,37.06 332.08,33.11 336.18,33.11 336.84,32.45 338.09,32.45 338.47,32.07 338.47,31.14 338.3,30.98
+5VS on VCC: 298.91,48.1 298.49,48.52 298.49,53.03 289.45,62.07 284.75,62.07 284.33,62.49 284.33,72 285.64,73.3 295.99,62.91 309.41,56.98 309.41,49.22 308.29,48.1
+5VS_HDD on BOTTOM (solid shape): 248.2,32.13 248.2,30.51 248.11,30.42 247.43,30.42 246.7,29.7 245.61,29.7 245.6,29.69 244.94,29.69 244.26,29.01 244.26,24.31 244.11,24.16 243.31,24.16 242.62,24.84 242.62,30.41 242.98,30.76 245.66,30.76 245.97,31.08 246.67,31.08 247.18,31.59 247.18,31.94 247.46,32.22 248.11,32.22
+5VS_KBL on BOTTOM (solid shape): 198.13,31.47 198.13,28.34 197.7,27.9 193.78,27.9 193.51,28.17 193.51,30.03 193.73,30.24 193.73,30.98 193.89,31.14 195.66,31.14 196.2,31.68 197.92,31.68
+5VS_OUT on TOP (solid shape): 260.23,36.03 260.23,35.42 260.55,35.1 260.55,35.06 260.5,34.96 260.49,34.85 260.5,34.73 260.55,34.63 260.55,33.51 260.49,33.45 259.84,33.45 259.72,33.32 259.72,32.52 259.53,32.33 257.33,32.33 257.33,32.33 256.54,32.33 256.38,32.49 256.38,33.14 256.35,33.17 255.85,33.17 255.84,33.18 255.84,33.62 255.85,33.63 256.38,33.63 256.39,33.65 256.39,34.37 256.39,34.37 255.85,34.37 255.85,34.38 255.85,34.82 255.85,34.83 256.39,34.83 256.39,34.83 256.39,35.5 257.18,36.28 259.98,36.28
+5VS_TS on BOTTOM (solid shape): 93.28,50.43 95.87,50.43 95.94,50.37 95.94,50.16 95.87,50.09 94.78,50.09 94.64,49.95 92.76,49.95 91.26,51.45 89,51.45 89,52.48 91.24,52.48
+VCC_3IN1 on TOP (solid shape): 20.94,40.72 20.94,39.8 21.2,39.54 21.2,38.9 21.07,38.76 19.47,38.76 19.41,38.83 19.41,39.4 19.84,39.83 19.84,40.78 19.98,40.92 20.74,40.92
+VCC_3IN1 on TOP (solid shape): 19.28,31.31 19.28,31.12 19.08,30.92 19.08,30.32 18.35,29.59 17.64,29.59 17.5,29.73 17.5,30.35 17.95,30.79 17.95,31.41 17.95,31.41 17.95,31.46 18.35,31.85 18.73,31.85
+VCC_3IN1 on BOTTOM (solid shape): 18.58,30.48 18.58,29.24 18.35,29.01 17.46,29.01 17.39,29.09 17.39,29.95 18.02,30.58 18.48,30.58
+VCC_CORE on TOP (solid shape): 174.12,87.05 174.12,87.04 174.17,86.93 174.26,86.85 174.78,86.33 174.78,85.98 174.65,85.85 174.45,85.85 174.27,86.03 174.27,86.42 174.27,86.48 174.2,86.55 172.12,86.55 171.98,86.42 171.98,86.25 171.71,85.98 170.77,85.98 170.61,86.13 170.32,86.13 170.24,86.17 170.22,86.25 170.21,86.43 170.11,86.58 170.07,86.66 170.1,86.74 170.14,86.77 170.17,86.82 170.23,86.86 170.31,86.85 170.35,86.83 170.39,86.81 170.45,86.79 170.51,86.79 170.59,86.79 170.83,86.55 170.91,86.55 170.91,86.51 171.62,86.51 171.62,87.03 171.67,87.11 171.76,87.11 171.81,87.09 171.86,87.08 171.96,87.06 172.06,87.05 172.95,87.05 173.15,87.25 173.93,87.25
+VCC_CORE on TOP (solid shape): outline of 1852 points within 141.26,85.98 172,115.92
+VCC_CORE on BOTTOM (solid shape): outline of 422 points within 162.92,85.72 174.29,87.63
+VCC_CORE on BOTTOM (solid shape): outline of 1092 points within 141.2,98.05 172.67,115.92
+VCC_CORE on IN1 (solid shape): outline of 2144 points within 146.98,86.09 174.11,106.91
+VCC_CORE on IN2 (solid shape): outline of 3171 points within 141.01,84.99 175.29,117.82
+VCC_CORE on IN3 (solid shape): outline of 2378 points within 146.98,85.71 174.79,107.41
+VCC_CORE on IN4 (solid shape): outline of 1507 points within 157.46,91.84 172.11,110.07
+VCC_CORE on IN5 (solid shape): outline of 2576 points within 141.01,85.71 174.79,117.76
+VCC_CORE on VCC: 160.51,85.98 160.06,86.43 160.06,98.82 160.7,99.46 160.7,103.86 158.64,105.95 146.96,105.95 146.91,105.99 146.91,108.02 142.66,112.27 142.66,115.37 143.08,115.79 165.54,115.79 165.96,115.37 165.96,113.21 166.75,112.42 170.75,112.42 172.13,111.04 172.13,95.07 172.12,95.07 172.12,94.86 172.13,94.85 172.13,93.93 172.12,93.92 172.12,93.71 172.13,93.71 172.13,89.43 174.8,86.76 174.8,86.43 174.34,85.98
+VCCGT on TOP (solid shape): outline of 3164 points within 126.91,86.04 160.24,129.44
+VCCGT on BOTTOM (solid shape): outline of 162 points within 146.02,85.94 159.03,87.63
+VCCGT on BOTTOM (solid shape): outline of 1971 points within 127.04,98.31 160.23,134.9
+VCCGT on IN1 (solid shape): outline of 4387 points within 139.88,86.09 160.35,106.52
+VCCGT on IN2 (solid shape): outline of 7314 points within 129.45,85.19 160.63,123.98
+VCCGT on IN3 (solid shape): outline of 3709 points within 139.99,86.09 160.21,106.9
+VCCGT on IN4 (solid shape): outline of 3796 points within 126.85,92.35 160.2,134.71
+VCCGT on IN5 (solid shape): outline of 4201 points within 126.79,86.09 160.21,123.98
+VCCGT on VCC: 139.72,85.98 139.09,86.61 134.8,86.61 134.41,87 134.41,89.8 134.41,103.17 134.41,103.38 127.78,110.01 127.33,110.01 126.91,110.43 126.91,129.08 127.53,129.7 139.13,129.7 142.15,126.67 142.15,112.06 146.41,107.81 146.41,105.78 146.75,105.44 158.43,105.44 160.19,103.65 160.19,99.67 159.56,99.03 159.56,86.43 159.1,85.98 154.58,85.98 154.5,86.06 154.06,86.06 153.98,85.98 ; 1 cut-out
+VCCIO on TOP (solid shape): 174.78,97.3 174.78,96.67 175.02,96.43 175.67,96.43 175.73,96.36 175.73,95.71 175.72,95.7 175.69,95.7 175.64,95.65 175.57,95.65 174.88,95.65 174.27,96.26 174.27,96.69 174.35,96.77 174.35,97.25 174.45,97.35 174.73,97.35
+VCCIO on TOP (solid shape): 176.96,92.55 176.96,92.12 176.79,91.94 176.61,91.94 176.38,91.72 176.38,89.75 176.56,89.57 176.81,89.57 176.95,89.43 176.95,89.01 176.76,88.82 176.66,88.82 176.38,88.54 176.38,88.03 176.32,87.98 175.85,87.98 175.74,88.08 175.74,88.73 175.64,88.84 175.03,88.84 174.83,88.64 174.83,88.31 174.73,88.21 174.53,88.21 174.35,88.39 174.35,89.84 174.47,89.96 175.34,89.96 175.95,90.57 175.95,91.34 175.74,91.54 175.03,91.54 174.78,91.28 174.58,91.28 174.4,91.46 174.4,91.64 174.78,92.02 174.78,92.55 174.98,92.76 176.76,92.76
+VCCIO on BOTTOM (solid shape): 130.85,90.07 131.67,90.07 131.67,90.64 132.37,90.64 132.5,90.52 132.5,88.93 132.18,88.61 132.18,85.25 132.25,85.18 133.34,85.18 133.34,84.76 133.51,84.26 133.68,84.76 133.68,85.18 134.79,85.18 135.76,84.21 135.76,84.19 135.81,83.91 135.97,83.68 136.17,83.47 136.17,83.45 136.19,83.35 136.25,83.25 136.25,81 135.84,80.59 135.84,79.58 135.95,79.2 136.25,78.94 136.25,77.16 136.12,76.48 136.63,76.02 136.65,76.02 140.44,72.23 172.78,72.23 173.07,71.94 173.07,71.13 173.2,71 173.73,71 173.83,70.9 173.83,70.39 174.2,70.01 175.6,70.01 177.81,72.23 178.79,72.23 179.81,71.21 179.81,67.53 180.37,66.97 182.56,66.97 183.45,66.08 183.45,65.73 183.89,65.29 184.13,65.05 184.13,64.23 184.98,63.38 184.98,62.86 184.8,62.68 182.02,62.68 180.34,61.01 167.69,61.01 166.01,62.68 144.52,62.68 133.02,74.18 132.79,74.65 132.5,75.07 132.5,78.39 129.01,81.88 129.01,90.45 129.13,90.58 129.64,90.58 129.64,90.07 130.47,90.07 130.47,90.64 130.85,90.64
+VCCIO on BOTTOM (solid shape): outline of 89 points within 173.57,87.69 176.93,97.78
+VCCIO on IN1 (solid shape): outline of 1526 points within 174.14,82.57 184.14,97.29
+VCCIO on IN2 (solid shape): outline of 177 points within 174.16,85.75 177.78,97.37
+VCCIO on IN3 (solid shape): outline of 12299 points within 132.93,58.79 188.75,98.7
+VCCIO on IN4 (solid shape): outline of 162 points within 127.36,77.5 134.85,88.29
+VCCIO on VCC: 180.99,82.32 180.44,82.87 180.44,85.35 179.85,85.94 175.76,85.97 175.3,86.43 175.3,86.97 172.64,89.64 172.64,93.72 173.03,94.11 183.3,94.13 183.33,94.1 183.35,94.1 185.08,92.38 185.08,82.94 184.46,82.32
+VCCIOP on BOTTOM (solid shape): outline of 125 points within 127.61,90.26 133.2,98.77
+VCCSA on TOP (solid shape): outline of 829 points within 171.88,89.21 183.62,116.2
+VCCSA on IN1 (solid shape): outline of 333 points within 172.49,90.9 175.32,106.9
+VCCSA on IN2 (solid shape): outline of 2361 points within 166.54,89.37 182.43,115.79
+VCCSA on IN4 (solid shape): outline of 1355 points within 172.25,92.1 179.52,115.53
+VCCSA on IN5 (solid shape): outline of 690 points within 169.01,92.17 182.19,115.92
+VCCSA on BOTTOM: outline of 141 points within 166.05,98.02 179.62,116.4
+VCCSA on VCC: 173.08,94.61 172.64,95.06 172.64,111.25 170.96,112.93 166.96,112.93 166.47,113.42 166.47,115.37 166.9,115.79 180.72,115.79 183.17,113.33 183.17,109.04 182.22,108.08 182.22,106.86 183.17,105.9 183.17,105.59 183.18,95.06 183.18,94.64
+VCCST on TOP (solid shape): outline of 547 points within 174.35,97.6 182.47,101.5
+VCCST on IN4 (solid shape): outline of 1358 points within 173.64,81.4 187.1,99.72
+VCCST_OUT on BOTTOM (solid shape): 182.84,110.54 182.84,108.95 182.69,108.8 180.76,108.8 180.57,108.99 180.57,110.48 180.86,110.77 182.6,110.77
+VCCSTG on BOTTOM (solid shape): 184.52,104.04 186.24,104.04 186.38,103.97 186.54,103.98 186.56,103.96 186.56,103.11 186.48,103.03 185.69,103.03 185.68,103.03 185.49,103.03 185.48,103.03 185.11,103.03 185.1,103.03 184.75,103.03 184.39,102.66 183.93,102.66 183.8,102.53 183.53,102.53 183.33,102.73 183.33,103.58 183.48,103.74 183.87,103.74 184.18,104.04 184.52,104.04
+VCCSTG on IN3 (solid shape): outline of 1069 points within 175.41,98.29 184.57,103.66
+VCCSTG_OUT on BOTTOM (solid shape): 188.08,106.06 188.08,103.15 187.99,103.07 187.3,103.07 187.25,103.11 187.25,106.2 187.42,106.37 187.76,106.37
AVCC33 on TOP (solid shape): 318.91,36.83 318.91,35.94 318.17,35.21 315.7,35.21 315.7,35.27 314.8,35.27 314.8,36.08 314.86,36.15 316.56,36.15 317.2,36.78 318.59,36.78 318.73,36.92 318.82,36.92
GND on TOP (solid shape): 183.62,117.12 183.62,116.61 183.36,116.36 176.25,116.36 176.25,117.31 176.38,117.44 183.3,117.44
GND on TOP (solid shape): 108.88,64.93 108.88,63.66 108.75,63.53 106.34,63.53 105.45,64.42 105.45,64.93 105.58,65.05 108.75,65.05
GND on TOP (solid shape): 116.85,132.59 116.85,131.19 115.81,130.15 114.44,130.15 114.06,130.53 114.06,132.16 114.59,132.69 116.75,132.69
GND on TOP (solid shape): 153.71,125.82 153.71,124.17 153.46,123.92 150.6,123.92 150.41,124.11 150.41,125.89 150.53,126.01 153.52,126.01
GND on TOP (solid shape): 162.22,125.89 162.22,124.04 162.15,123.98 159.23,123.98 159.04,124.17 159.04,125.89 159.23,126.08 162.03,126.08
GND on TOP (solid shape): 172.19,136.62 172.19,131.79 172,131.6 170.73,131.6 168.89,133.44 168.89,136.36 169.39,136.87 171.93,136.87
GND on TOP (solid shape): 173.96,124.57 173.96,121.41 173.86,121.31 172.25,121.31 172.17,121.4 172.17,124.68 172.24,124.75 173.79,124.75
GND on TOP (solid shape): 176.11,135.3 174.71,135.3 174.65,135.36 174.65,136.61 174.73,136.69 176.11,136.69
GND on TOP (solid shape): 196.64,132.87 196.64,128.93 196.44,128.74 194.29,128.74 193.9,129.12 193.9,132.81 194.16,133.06 196.44,133.06
GND on TOP (solid shape): 213.24,84.92 213.24,83.93 212.8,83.49 212.11,83.49 212.05,83.55 212.05,84.95 212.14,85.04 213.13,85.04
GND on TOP (solid shape): 243.37,54.64 243.37,53.75 243.24,53.62 242.1,53.62 241.97,53.75 241.97,54.64 242.1,54.77 243.24,54.77
GND on TOP (solid shape): 256.33,62.64 256.33,61.24 256.07,60.99 248.32,60.99 248.2,61.12 248.2,62.64 248.58,63.02 255.94,63.02
GND on TOP (solid shape): 259.25,42.51 259.25,41.37 259.12,41.24 258.29,41.24 258.1,41.43 258.1,42.51 258.23,42.64 259.12,42.64
GND on TOP (solid shape): 266.99,86.64 266.99,82.07 266.74,81.82 265.85,81.82 265.6,82.07 265.6,86.77 265.72,86.9 266.74,86.9
GND on TOP (solid shape): 279.31,75.91 279.31,75.47 278.01,74.16 277.69,74.16 277.09,74.77 277.09,75.11 278.4,76.42 278.8,76.42
GND on TOP (solid shape): 330.95,10.73 330.95,7.17 330.53,6.75 329.2,6.75 328.79,7.16 328.79,10.89 329.06,11.16 330.52,11.16
GND on TOP (solid shape): 180.51,134.08 180.51,132.36 180.25,132.11 179.3,132.11 179.3,133.57 179.43,133.7 179.43,134.08 179.49,134.14 180.44,134.14
GND on TOP (solid shape): 122.4,124.49 122.4,119.41 121.9,118.9 120.12,118.9 119.99,119.03 119.99,124.3 120.63,124.93 121.96,124.93
GND on TOP (solid shape): 145.14,125.63 145.14,123.98 144.95,123.79 143.69,123.79 141.96,123.79 141.77,123.98 141.77,125.69 141.9,125.82 144.95,125.82
GND on TOP (solid shape): 171.13,96.35 171.13,93.01 171,92.88 167.95,92.88 167.7,93.14 167.7,95.68 168.53,96.51 170.97,96.51
GND on TOP (solid shape): 180.76,121.69 180.76,120.74 180.63,120.61 180.63,120.17 180.57,120.11 179.11,120.11 179.05,120.17 179.05,121.63 179.17,121.76 180.7,121.76
GND on TOP (solid shape): 248.83,38 248.83,36.54 248.64,36.35 248.64,34.19 248.58,34.13 248.01,34.13 247.88,34.25 247.88,38 248.13,38.26 248.58,38.26
GND on TOP (solid shape): 251.88,49.24 251.88,47.91 251.75,47.78 248.36,47.78 248.23,47.92 248.23,49.22 248.31,49.3 251.82,49.3
GND on TOP (solid shape): 263.44,37.49 263.44,36.79 263.04,36.4 260.34,36.4 260.2,36.54 259.18,36.54 258.99,36.73 258.99,37.62 259.06,37.68 263.25,37.68
GND on TOP (solid shape): 269.79,7.33 270.23,7.33 271.25,6.31 271.25,5.87 271.18,5.81 269.22,5.81 269.22,7.52 269.6,7.52
GND on TOP (solid shape): 321.16,10.91 321.16,6.48 320.74,6.06 318.81,6.06 318.61,6.26 318.61,9.1 319.43,9.91 319.43,10.87 319.66,11.1 320.97,11.1
GND on TOP (solid shape): 177.46,130.97 177.46,130.84 177.59,130.71 177.9,130.71 178.03,130.58 178.03,129.95 177.97,129.89 176.32,129.89 176,130.2 176,131.16 176.12,131.28 177.14,131.28
GND on TOP (solid shape): 177.78,127.66 177.78,122.71 177.59,122.52 176.32,122.52 176.12,122.71 176.12,125.76 176.38,126.01 176.89,126.01 177.01,126.14 177.01,127.73 177.08,127.79 177.65,127.79
GND on TOP (solid shape): 197.82,82.31 197.82,81.62 197.7,81.51 195.21,81.51 195.08,81.64 195.08,81.97 195.2,82.09 196.1,82.09 196.18,82.17 196.18,82.32 196.27,82.41 197.71,82.41
GND on TOP (solid shape): 199.3,86.43 199.3,85.05 199.21,84.96 198.76,84.96 198.38,84.58 198.38,82.65 198.31,82.59 197.27,82.59 197.1,82.76 197.1,86.24 197.33,86.48 199.25,86.48
GND on TOP (solid shape): 207.08,106.89 207.08,106.09 206.9,105.91 205.28,105.91 204.8,106.39 204.57,106.39 204.38,106.58 204.38,106.71 204.57,106.9 204.58,106.9 204.71,107.02 206.94,107.02
GND on TOP (solid shape): 217.24,85.08 217.24,83.09 217.36,82.97 217.36,82.62 217.26,82.52 215.81,82.52 215.67,82.66 215.67,85.37 215.74,85.44 215.78,85.44 215.78,85.45 216.88,85.45
GND on TOP (solid shape): 342.3,29.68 342.3,28.35 342.11,28.16 341.91,28.16 341.91,28.16 339.03,28.16 338.75,28.44 338.75,29.59 339.03,29.87 342.11,29.87
GND on TOP (solid shape): 111.29,70.26 111.29,69.33 111.3,69.32 111.3,68.34 111.25,68.29 111.14,68.29 111.09,68.34 111.09,69.18 110.78,69.49 110.78,69.5 110.78,70.32 110.91,70.45 111.1,70.45
GND on TOP (solid shape): 116.88,122.46 116.63,122.2 114.75,122.2 114.61,122.34 114.61,124.46 114.76,124.62 115.16,124.62 115.48,124.93 116.88,124.93
GND on TOP (solid shape): 134.28,133.12 134.28,133.02 134.25,133.02 134.25,132.27 133.18,131.2 133.18,129.84 133.12,129.77 130.38,129.77 130.28,129.88 130.28,132.62 130.91,133.25 134.15,133.25
GND on TOP (solid shape): 165.61,124.95 165.61,124.09 165.15,123.64 165.15,119.86 164.82,119.54 163.55,119.54 163.16,119.93 163.16,123.63 162.76,124.02 162.45,124.02 162.37,124.1 162.37,124.94 162.45,125.02 165.54,125.02
GND on TOP (solid shape): 170.77,143.88 170.77,143.5 171.68,142.59 171.68,139.86 171.43,139.6 169.9,139.6 169.27,138.97 167.87,138.97 167.68,139.16 167.68,141.51 168.31,142.14 168.31,143.86 168.58,144.12 170.52,144.12
GND on TOP (solid shape): 260.52,41.62 260.52,39.53 260.07,39.08 258.48,39.08 258.04,38.64 256.6,38.64 256.43,38.8 256.43,39.63 256.58,39.78 259.25,39.78 259.42,39.96 259.42,41.54 259.68,41.8 260.34,41.8
GND on TOP (solid shape): 149.56,125.2 149.56,124.19 148.67,123.3 148.67,121.48 147.61,120.42 145.32,120.42 145.06,120.68 145.06,122.3 145.1,122.35 145.9,122.35 146.09,122.54 146.09,125.15 146.17,125.24 149.53,125.24
GND on TOP (solid shape): 154.69,86.48 154.69,86.23 154.51,86.05 154.47,86.05 154.46,86.06 154.33,86.08 154.21,86.06 154.2,86.05 153.06,86.05 152.94,86.18 152.94,86.74 152.96,86.76 154.41,86.76
GND on TOP (solid shape): 109.56,73.54 109.56,71.47 109.31,71.21 107.35,71.21 107.04,70.89 107.04,68.34 106.1,67.4 105.42,67.4 105.29,67.54 105.29,68.2 105.46,68.37 105.46,71.71 105.79,72.04 106.72,72.04 107.42,72.74 107.42,73.37 107.7,73.65 109.45,73.65
GND on TOP (solid shape): 156.5,125.54 156.5,120.42 156.34,120.26 154.13,120.26 154,120.39 154,121.09 154.25,121.34 154.25,121.91 154.3,121.95 155.08,121.95 155.33,122.2 155.33,123.51 155.16,123.68 154.54,123.68 154.45,123.78 154.45,125.52 154.54,125.62 156.42,125.62
GND on TOP (solid shape): 164.82,92.15 164.82,90.45 164.57,90.19 164.57,89.91 164.82,89.66 164.82,89.23 164.62,89.02 163.19,89.02 162.97,89.25 162.97,92.15 163.07,92.25 164.72,92.25
GND on TOP (solid shape): 270.36,82.2 270.36,81.75 270.99,81.12 270.99,80.29 270.87,80.17 270.36,80.17 270.3,80.23 270.3,81.05 270.04,81.31 269.66,81.31 269.47,81.5 269.47,81.88 269.28,82.07 269.28,82.26 269.41,82.39 270.17,82.39
GND on TOP (solid shape): 341.58,36.87 341.58,35.57 341.5,35.49 340.74,35.49 340.45,35.2 339.76,35.2 339.43,35.54 338.58,35.54 338.42,35.7 338.42,36.33 338.55,36.46 339.23,36.46 339.35,36.58 339.35,36.93 339.5,37.08 341.37,37.08
GND on TOP (solid shape): 169.79,126.53 169.79,124.99 170.2,124.58 170.2,123.04 170.06,122.91 169.79,122.91 169.6,123.09 168.11,123.09 167.82,123.38 167.82,124.63 168,124.81 168.44,124.81 168.63,125 168.63,125.63 168.18,126.08 168.18,126.65 168.24,126.71 169.61,126.71
GND on TOP (solid shape): 228.18,81.04 228.18,79.84 228.79,79.23 228.79,78.73 228.14,78.08 225.43,78.08 224.85,78.66 224.85,79.97 224.99,80.11 225.38,80.11 225.71,80.44 225.71,80.93 226.34,81.56 227.66,81.56
GND on TOP (solid shape): 112.45,66.33 111.76,66.33 111.7,66.27 111.7,65.22 111.66,65.18 111.53,65.18 111.48,65.23 111.48,66.3 111.44,66.33 111.01,66.33 110.9,66.22 110.9,65.26 110.83,65.19 110.75,65.19 110.68,65.26 110.68,66.35 110.75,66.41 110.75,68.02 110.76,68.04 112.45,68.04
GND on TOP (solid shape): 177.05,145.56 177.05,144.12 176.89,143.96 176.89,138.84 176.76,138.71 175.93,138.71 175.81,138.84 175.81,139.41 175.62,139.6 174.92,139.6 174.78,139.74 174.78,143.57 173.83,144.52 173.83,145.58 173.97,145.72 176.89,145.72
GND on TOP (solid shape): 199.6,91.99 199.6,91.67 199.49,91.55 199.01,91.55 198.94,91.48 198.94,90.54 198.92,90.52 198.35,90.52 198.16,90.71 195.49,90.71 195.43,90.77 195.43,91.47 196.03,92.07 199.51,92.07
GND on TOP (solid shape): 363.07,62.32 363.07,62.07 362.81,61.81 362.81,59.53 362.94,59.4 363.45,59.4 364.28,60.23 368.28,60.23 368.36,60.32 368.85,60.32 369.04,60.12 369.04,59.4 368.85,59.21 364.28,59.21 363.64,58.58 362.24,58.58 362.18,58.64 362.18,62.13 362.56,62.51 362.88,62.51
GND on TOP (solid shape): 123.97,133.61 123.97,131.63 123.29,130.95 123.29,128.23 122.84,127.78 120.19,127.78 120.13,127.84 120.13,130.77 120.35,131 120.35,132.51 120.41,132.57 120.92,132.57 120.99,132.49 120.99,131.93 121.07,131.85 122.16,131.85 122.59,132.29 122.59,133.61 122.82,133.84 123.74,133.84
GND on TOP (solid shape): 203.23,110.21 203.23,109.51 203.54,109.2 204.81,109.2 204.89,109.12 204.89,107.38 204.52,107.01 203.75,107.01 203.62,107.14 203.62,107.79 202.83,108.58 199.34,108.58 199.2,108.72 197.8,108.72 197.68,108.84 197.68,110.09 197.92,110.33 200.57,110.33 203.11,110.33
GND on TOP (solid shape): 45.12,41.24 45.12,38.7 45,38.57 44,38.57 43.94,38.63 43.38,38.63 43.16,38.41 43.16,37.21 43.31,37.05 44.15,37.05 44.22,36.98 44.22,36.48 44.1,36.36 43.08,36.36 42.58,36.85 42.58,39.91 42.84,40.16 42.84,41.43 43.03,41.62 44.74,41.62
GND on TOP (solid shape): 248.71,43.65 248.71,41.11 248.77,41.05 251.37,41.05 251.82,40.6 253.02,40.6 253.21,40.8 253.98,40.8 254.1,40.67 254.1,40.34 253.98,40.22 253.14,40.22 253.07,40.29 251.88,40.29 251.54,39.94 250.25,39.94 249.87,40.33 248.41,40.33 248.13,40.6 248.13,43.59 248.32,43.78 248.58,43.78
GND on TOP (solid shape): 211.06,85.6 211.06,83.78 210.94,83.66 209.35,83.66 209.34,83.67 208.63,83.67 208.17,83.21 206.49,83.21 205.74,83.96 205.74,84.58 205.78,84.62 206.37,84.62 206.9,84.09 207.96,84.09 208.61,84.74 208.61,85.61 208.78,85.79 210.88,85.79
GND on TOP (solid shape): 144.32,145.2 144.32,144.34 143.99,144.01 139.71,144.01 139.54,144.18 139.54,144.76 139.58,144.8 140.76,144.8 141.16,144.93 141.12,145.34 141.28,145.49 144.03,145.49
GND on TOP (solid shape): 247.34,52.86 250.36,52.86 250.48,52.73 250.48,51.46 250.74,51.21 251.88,51.21 252.13,51.46 252.13,52.61 252.39,52.86 256.45,52.86 256.71,52.61 256.71,51.54 256.94,51.3 258.07,51.3 258.18,51.41 259.17,51.41 259.25,51.34 259.25,50.76 259.18,50.7 254.55,50.7 254.17,50.32 254.17,49.81 253.91,49.56 251.94,49.56 251.82,49.43 244.83,49.43 244.39,49.88 244.39,53.63 244.68,53.91 246.29,53.91
GND on TOP (solid shape): 72.75,45.55 72.75,43.08 72.43,42.76 72.43,37.87 72.18,37.62 71.1,37.62 70.65,38.06 66.97,38.06 66.84,38.19 66.84,40.03 66.27,40.6 63.48,40.6 63.29,40.8 63.29,43.78 63.41,43.91 65.57,43.91 65.76,44.1 68.56,44.1 68.75,43.91 68.75,43.02 69.25,42.51 70.71,42.51 71.03,42.83 71.03,45.94 71.29,46.19 72.1,46.19
GND on TOP (solid shape): 347,60.1 347,57.81 346.94,57.75 346.41,57.75 346.11,58.22 345.81,57.75 345.35,57.75 344.97,58.13 344.97,58.77 345.42,59.21 345.73,59.21 346.69,60.16 346.94,60.16
GND on TOP (solid shape): 369.23,21 369.83,20.3 370.6,20.8 373.99,20.8 374.49,21.1 380.1,21.1 380.1,18.37 370.12,18.37 368.59,19.9 365.48,19.9 364.78,20.6 364.78,22.32 365.17,22.71 369.23,22.71
GND on TOP (solid shape): 228.01,106.77 228.01,106.07 228.01,106.07 228.01,105.44 227.88,105.31 227.43,105.31 227.12,105 227.12,104.43 227.5,104.06 227.5,100.49 227.75,100.23 227.75,98.11 227.28,97.64 227.28,94.49 227.29,94.49 227.19,94.39 226.74,94.39 226.55,94.2 226.55,93.75 226.93,93.37 228,93.37 228.08,93.29 228.08,92.8 227.95,92.67 227.31,92.67 227.06,92.42 227.06,90.07 227.31,89.81 227.31,89.05 227,88.73 227,87.28 226.93,87.21 226.41,87.21 226.33,87.28 226.33,87.78 226.13,87.98 224.66,87.98 224.58,88.06 224.58,88.73 224.61,88.76 225.94,88.76 226.11,88.92 226.11,96.35 225.97,96.48 225.97,97.34 225.98,97.35 226.02,97.5 225.98,97.65 225.97,97.67 225.97,100.97 225.97,101.03 225.97,102.37 225.97,102.43 225.97,103.67 225.98,103.68 226,103.8 225.98,103.92 225.97,103.93 225.97,104.92 226.05,105 226.05,106.65 226.24,106.83 227.95,106.83
GND on TOP (solid shape): 369.26,72.28 369.26,69.67 369.26,69.65 369.26,69.55 369.23,69.48 369.16,69.45 368.97,69.36 368.86,69.17 368.83,69.11 368.76,69.09 368.46,68.51 369.09,68.7 369.12,68.76 369.19,68.79 369.24,68.77 369.26,68.73 369.26,68.4 369.26,68.37 369.26,67.47 368.52,66.72 367.34,66.72 367.11,66.95 367.11,69.05 367.73,69.68 368.1,69.68 368.35,69.92 368.35,72.24 368.51,72.4 369.14,72.4
GND on TOP (solid shape): outline of 91 points within 206.79,85.42 211.11,105.13
GND on TOP (solid shape): 206.29,94.83 206.29,94.39 206.22,94.33 205.97,94.33 205.95,94.32 205.75,94.23 205.66,94.03 205.66,94.02 205.53,93.88 205.53,93.68 205.51,93.68 205.51,93.17 205.31,92.96 205.28,92.97 205.19,92.96 205.11,92.93 205.1,92.93 204.7,92.93 204.69,92.93 204.55,92.97 204.41,92.93 204.4,92.93 203.4,92.93 203.38,92.94 203.35,92.98 203.37,93.02 203.2,93.58 202.9,93.09 202.9,92.98 202.81,92.93 201.46,92.93 200.89,93.5 200.89,94.14 201.14,94.39 201.33,94.39 201.52,94.2 202.99,94.2 203.72,94.93 204.15,94.93 204.15,94.96 206.16,94.96
GND on TOP (solid shape): 11.94,106.35 12.23,106.29 12.48,106.13 18.55,100.38 18.55,99.91 11.96,99.91 11.85,99.8 11.85,97.64 11.58,97.37 7.8,97.37 7.59,97.46 7.5,97.67 7.5,97.9 7.3,98.4 6.8,98.6 6,98.6 5.5,98.4 5.3,97.9 5.3,97.67 5.21,97.46 5,97.37 0.5,97.37 0.29,97.46 0.2,97.67 0.2,99.85 0.44,100.41 1,100.65 2.6,100.65 3.45,101 3.8,101.85 3.8,105.55 4.04,106.11 4.6,106.35
GND on TOP (solid shape): 11.93,76.7 13.5,75.12 16.63,75.12 17.03,74.72 17.03,73.61 16.73,73.31 12.77,73.31 12.77,74.75 12.17,75.45 11.4,74.95 8.01,74.95 7.51,74.65 3.42,74.65 3.42,79.05 3.07,79.9 2.22,80.25 1,80.25 0.44,80.49 0.2,81.05 0.2,82.31 0.29,82.52 0.5,82.61 5,82.61 5.21,82.52 5.3,82.31 5.3,82.1 5.5,81.6 6,81.4 6.8,81.4 7.3,81.6 7.5,82.1 7.5,82.31 7.59,82.52 7.8,82.61 11.4,82.61 11.69,82.67 11.93,82.84
GND on TOP (solid shape): outline of 175 points within 365.35,33.35 380.1,43.49
GND on TOP (solid shape): outline of 101 points within 351.95,54.91 357.31,61.5
GND on TOP (solid shape): outline of 259 points within 348.52,48.16 353.05,54.96
GND on TOP (solid shape): outline of 639 points within 202.95,108.61 210.99,116.44
GND on TOP (solid shape): outline of 236 points within 0.2,0.2 365.77,62.59
GND on TOP (solid shape): outline of 1849 points within 357.14,54.24 383.1,143.1
GND on TOP (solid shape): outline of 212 points within 0.21,58.04 369.92,146.7
GND on BOTTOM (solid shape): 137.2,111.41 137.2,108.55 134.41,108.55 134.15,108.8 134.15,111.57 137.04,111.57
GND on BOTTOM (solid shape): 196.76,132.87 196.76,128.81 194.35,128.81 194.22,128.93 194.22,132.74 194.48,133 196.64,133
GND on BOTTOM (solid shape): 115.29,96.29 115.29,94.26 115.16,94.14 114.09,94.14 114.02,94.2 114.02,96.42 114.09,96.48 115.1,96.48
GND on BOTTOM (solid shape): 121.39,100.23 121.39,99.28 121.26,99.15 120.24,99.15 120.05,99.34 120.05,100.17 120.18,100.29 121.32,100.29
GND on BOTTOM (solid shape): 126.47,85.56 126.47,81.75 126.15,81.44 117.77,81.44 117.64,81.56 117.64,85.46 117.86,85.68 126.35,85.68
GND on BOTTOM (solid shape): 129.26,100.42 129.26,99.53 129.13,99.41 128.06,99.41 127.93,99.53 127.93,100.49 127.99,100.55 129.13,100.55
GND on BOTTOM (solid shape): 137.33,130.08 137.33,127.66 137.01,127.35 133.96,127.35 133.83,127.47 133.83,129.89 134.09,130.14 137.26,130.14
GND on BOTTOM (solid shape): 169.9,131.6 169.9,130.71 169.77,130.58 168.76,130.58 168.63,130.71 168.63,131.6 168.7,131.66 169.84,131.66
GND on BOTTOM (solid shape): 175.93,115.6 175.93,114.65 175.87,114.58 174.73,114.58 174.66,114.65 174.66,115.53 174.85,115.73 175.81,115.73
GND on BOTTOM (solid shape): 193.08,123.47 193.08,121.31 192.83,121.06 190.16,121.06 189.9,121.31 189.9,123.47 190.03,123.6 192.95,123.6
GND on BOTTOM (solid shape): 197.02,136.93 197.02,134.39 196.76,134.14 194.48,134.14 194.35,134.27 194.35,137.06 194.48,137.19 196.76,137.19
GND on BOTTOM (solid shape): 198.35,138.64 198.35,137.63 198.1,137.38 197.4,137.38 197.14,137.63 197.14,138.6 197.28,138.74 198.26,138.74
GND on BOTTOM (solid shape): 267.68,131.64 267.68,128.47 267.61,128.4 264.37,128.4 264.22,128.55 264.22,131.65 264.29,131.72 267.6,131.72
GND on BOTTOM (solid shape): 276.05,7.14 276.05,5.6 275.95,5.5 271.59,5.5 271.37,5.73 271.37,7.07 272.73,8.44 274.75,8.44
GND on BOTTOM (solid shape): 368.22,38.68 368.22,36.93 368.13,36.84 366.52,36.84 366.37,36.99 366.37,38.55 366.59,38.76 368.14,38.76
GND on BOTTOM (solid shape): 37.62,54.89 37.62,53.6 31.8,47.78 31.71,47.78 27.93,51.56 27.93,51.74 33.65,57.45 35.06,57.45
GND on BOTTOM (solid shape): 259.25,40.16 259.25,37.94 259.12,37.81 256.71,37.81 256.45,38.06 256.45,39.91 256.9,40.35 259.06,40.35
GND on BOTTOM (solid shape): 377.64,75.01 377.64,73.89 377.37,73.63 375.21,73.63 375.01,73.84 375.01,74.7 375,74.71 375.58,75.29 377.36,75.29
GND on BOTTOM (solid shape): 68.29,31.85 68.29,29.39 68.01,29.11 64.86,29.11 64.56,29.42 64.56,31.91 64.75,32.1 68.05,32.1
GND on BOTTOM (solid shape): 126.21,91.91 127.36,91.91 127.42,91.85 127.42,90.77 127.29,90.64 124.05,90.64 123.93,90.77 123.93,92.23 124.18,92.48 125.64,92.48
GND on BOTTOM (solid shape): 147.17,112.99 147.17,108.55 146.98,108.36 144.63,108.36 144.5,108.49 144.5,112.04 145.58,113.12 147.04,113.12
GND on BOTTOM (solid shape): 255.44,63.4 255.44,60.61 255.31,60.48 249.34,60.48 249.09,60.73 249.09,63.66 249.21,63.78 255.06,63.78
GND on BOTTOM (solid shape): 279.12,76.1 279.12,75.21 278.93,75.02 277.28,75.02 277.15,75.15 277.15,76.42 277.28,76.55 278.68,76.55
GND on BOTTOM (solid shape): 127.74,94.77 127.74,92.61 127.61,92.48 126.98,92.48 126.85,92.61 126.85,92.87 126.28,93.44 126.28,94.77 126.4,94.9 127.61,94.9
GND on BOTTOM (solid shape): 61.51,54.57 61.51,52.92 61.06,52.48 58.08,52.48 57.89,52.67 57.89,54.64 58.08,54.83 61.25,54.83
GND on BOTTOM (solid shape): 275.25,63.27 275.25,56.99 274.8,56.54 272.66,56.54 272.26,56.94 272.26,63.08 272.64,63.46 275.06,63.46
GND on BOTTOM (solid shape): 363.32,38.7 363.32,38.13 362.88,37.68 362.88,35.4 362.56,35.08 361.61,35.08 361.1,35.59 361.1,36.6 361.86,37.37 361.86,38.32 362.37,38.83 363.2,38.83
GND on BOTTOM (solid shape): 196.89,128.04 196.89,125.57 198.98,123.47 198.98,122.84 198.79,122.65 194.16,122.65 194.03,122.77 194.03,127.98 194.35,128.3 196.64,128.3
GND on BOTTOM (solid shape): 145.96,125.25 147.8,125.25 147.8,120.42 147.49,120.11 145.58,120.11 145.45,120.23 145.45,123.03 144.63,123.85 141.07,123.85 141.07,124.93 141.83,124.93 141.83,125.82 145.39,125.82
GND on BOTTOM (solid shape): 154.47,125.57 156.38,125.57 156.38,120.55 156.12,120.3 154.22,120.3 154.09,120.42 154.09,123.22 153.26,124.04 149.71,124.04 149.71,125.12 150.47,125.12 150.47,126.01 154.03,126.01
GND on BOTTOM (solid shape): 173.84,131.41 174.92,131.41 175.11,131.22 175.11,130.01 174.92,129.82 173.84,129.82 173.71,129.95 173.71,131.09 173.55,131.25 172.67,131.25 172.58,131.34 172.58,131.5 172.67,131.59 173.66,131.59
GND on BOTTOM (solid shape): 186.73,25.68 186.73,22.63 186.11,22.02 186.07,22 179.56,22 179.31,22.25 179.31,26.13 179.7,26.52 180.21,26.52 180.21,26.53 185.88,26.53
GND on BOTTOM (solid shape): 169.58,140.43 169.58,139.54 169.46,139.41 169.2,139.41 169.06,139.56 168.3,139.56 168.28,139.57 168.28,140.42 168.32,140.45 169.08,140.45 169.16,140.53 169.48,140.53
GND on BOTTOM (solid shape): 151.97,141.89 151.97,141.28 151.87,141.18 151.82,141.18 151.82,141.24 151.26,141.24 151.26,141.18 151.12,141.18 150.89,140.94 150.89,137.59 150.53,137.24 148.65,137.24 148.3,137.59 148.3,141.66 148.65,142.01 151.85,142.01
GND on BOTTOM (solid shape): 164.17,100.02 164.17,99.83 163.79,99.45 163.79,98.82 163.67,98.69 163.44,98.69 163.35,98.79 163.35,99.67 163.53,99.84 163.53,99.87 163.83,100.17 164.03,100.17
GND on BOTTOM (solid shape): 170.95,30.64 170.95,30.42 171.17,30.2 171.17,27.32 171.12,27.27 168.8,27.27 168.71,27.36 168.71,29.41 168.31,29.81 166.61,29.81 166.31,30.11 165.59,30.11 165.45,30.25 165.45,30.82 165.55,30.91 170.67,30.91
GND on BOTTOM (solid shape): 173.39,140.24 174.41,140.24 174.6,140.05 174.6,138.84 174.41,138.65 173.39,138.65 173.27,138.78 173.27,139.86 173.08,140.05 172.19,140.05 172.12,140.11 172.12,140.36 172.19,140.43 173.2,140.43
GND on BOTTOM (solid shape): 175.3,118.9 176.44,118.9 176.57,118.77 176.57,117.44 176.44,117.31 175.24,117.31 175.17,117.38 175.17,118.52 174.98,118.71 174.16,118.71 174.09,118.77 174.09,119.03 174.16,119.09 175.11,119.09
GND on BOTTOM (solid shape): 157.06,100.06 157.06,99.87 156.68,99.5 156.68,98.75 156.62,98.69 156.36,98.69 156.24,98.82 156.24,99.45 155.86,99.83 155.86,100.02 155.98,100.15 156.17,100.15 156.32,100.01 156.59,100.01 156.75,100.17 156.94,100.17
GND on BOTTOM (solid shape): 44.28,41.62 44.34,41.62 44.64,41.32 44.64,39.07 44.16,38.6 43.58,38.6 43.24,38.93 42.67,38.93 42.52,39.08 42.52,40.3 42.81,40.59 42.81,41.57 42.86,41.62 44.27,41.62
GND on BOTTOM (solid shape): 118.66,124.93 118.66,124.42 117.26,124.42 116.88,124.04 115.93,124.04 115.74,123.85 115.74,122.27 115.67,122.2 114.97,122.2 114.66,122.52 114.66,124.42 114.85,124.62 116.75,124.62 117.13,125 118.59,125
GND on BOTTOM (solid shape): 123.8,133.72 123.8,131.99 122.26,130.46 122.26,126.98 122.16,126.87 121.05,126.87 120.99,126.93 120.99,127.57 120.84,127.73 120.18,127.73 120.11,127.8 120.11,131.48 120.44,131.8 122.04,131.8 122.49,132.26 122.49,133.63 122.67,133.81 123.71,133.81
GND on BOTTOM (solid shape): 153.99,99.98 154.19,99.98 154.39,100.18 154.55,100.18 154.71,100.02 154.71,99.83 154.33,99.45 154.33,98.82 154.2,98.69 153.95,98.69 153.89,98.75 153.89,99.46 153.5,99.85 153.5,100.04 153.64,100.18 153.79,100.18
GND on BOTTOM (solid shape): 159.4,100.04 159.4,99.85 159.03,99.47 159.03,98.75 158.97,98.69 158.71,98.69 158.59,98.82 158.59,99.45 158.2,99.83 158.2,100.02 158.33,100.15 158.52,100.15 158.67,100.01 158.92,100.01 159.1,100.18 159.27,100.18
GND on BOTTOM (solid shape): 165.58,114.68 165.58,112.68 166.47,111.79 166.47,106.96 166.41,106.9 164.31,106.9 164.02,107.19 164.02,111.24 164.89,112.11 164.89,114.61 165.07,114.8 165.46,114.8
GND on BOTTOM (solid shape): 163.74,125 165.08,125 165.14,124.93 165.14,119.85 164.82,119.54 163.17,119.54 162.66,120.04 162.66,123.35 162.02,123.98 158.34,123.98 158.32,124 158.32,125.13 158.33,125.14 159.17,125.14 159.17,126.01 162.73,126.01
GND on BOTTOM (solid shape): 146.89,99.99 147.11,99.99 147.28,100.16 147.52,100.16 147.64,100.03 147.64,99.88 147.43,99.67 147.43,98.9 147.21,98.69 146.68,98.69 146.53,98.84 146.53,99.68 146.36,99.85 146.36,100.02 146.5,100.16 146.72,100.16
GND on BOTTOM (solid shape): 366.94,69.15 366.94,68.44 367.06,68.32 368.53,68.32 368.63,68.23 368.63,65.85 367.33,64.55 366.75,64.55 366.69,64.61 366.69,67.92 366.43,68.17 366.43,69.16 366.46,69.2 366.9,69.2
GND on BOTTOM (solid shape): 180.89,136.93 180.89,134.9 180.57,134.58 180.57,133.95 180.38,133.76 177.52,133.76 177.46,133.7 177.46,130.01 177.27,129.82 176.12,129.82 176,129.95 176,130.58 175.87,130.71 175.36,130.71 175.24,130.84 175.24,134.68 174.65,135.27 174.63,135.28 174.63,136.55 174.76,136.68 175.93,136.68 176.38,137.12 180.7,137.12
GND on BOTTOM (solid shape): 72.87,45.49 72.87,39.91 72.43,39.46 72.43,37.87 72.18,37.62 70.28,37.62 69.19,37.62 68.24,38.57 68.24,39.33 66.78,40.8 66.78,43.02 66.9,43.14 68.75,43.14 68.94,42.95 70.24,42.95 70.33,42.94 70.43,42.95 70.59,42.95 70.97,43.34 70.97,46.13 71.1,46.26 72.11,46.26
GND on BOTTOM (solid shape): 122.15,124.74 122.15,123.92 121.96,123.73 121.71,123.73 121.51,123.54 121.51,123.15 121.71,122.96 122.21,122.96 122.4,122.77 122.4,122.14 122.21,121.95 122.21,118.2 122.09,118.07 120.82,118.07 120.75,118.14 120.75,118.84 120.69,118.9 119.99,118.9 119.93,118.96 119.93,122.84 120.34,123.25 120.34,124.65 120.63,124.93 121.96,124.93
GND on BOTTOM (solid shape): 181.46,124.81 183.68,124.81 184.19,124.3 184.19,123.6 183.55,122.96 182.67,122.96 182.03,122.33 182.03,121.44 181.84,121.25 179.17,121.25 178.98,121.06 178.98,117.5 178.86,117.38 177.65,117.38 177.52,117.5 177.52,118.07 177.39,118.2 176.82,118.2 176.7,118.33 176.7,122.14 176.12,122.71 176.12,125.82 176.25,125.95 180.32,125.95
GND on BOTTOM (solid shape): 165.72,100.08 165.81,100 166,100 166.03,100.02 166.08,100.02 166.21,100.15 166.4,100.15 166.52,100.02 166.52,99.83 166.14,99.45 166.14,98.82 166.02,98.69 165.76,98.69 165.7,98.75 165.7,99.43 165.3,99.82 165.3,100.04 165.44,100.18 165.63,100.18
GND on BOTTOM (solid shape): 168.9,100.05 168.9,99.86 168.49,99.45 168.49,98.75 168.43,98.69 168.17,98.69 168.05,98.82 168.05,99.45 167.67,99.83 167.67,100.02 167.79,100.15 167.98,100.15 168.11,100.02 168.17,100.02 168.18,100.02 168.26,100.01 168.34,100.02 168.35,100.02 168.4,100.02 168.56,100.18 168.77,100.18
GND on BOTTOM (solid shape): 147.44,130.64 147.44,130.23 147.84,129.82 148.2,129.82 148.25,129.77 148.25,128.1 147.79,127.64 147.79,127.28 147.23,127.28 147.23,128.76 147.33,128.86 147.44,128.86 147.64,129.06 147.64,129.67 147.23,130.08 145.77,130.08 145.71,130.14 145.71,130.58 145.64,130.65 144.25,130.65 144.03,130.86 144.03,132.21 144.12,132.3 145.77,132.3
GND on BOTTOM (solid shape): 270.68,82.07 270.68,80.17 271.06,79.78 271.06,77.05 271.25,76.86 272.19,76.86 272.27,76.85 272.34,76.86 272.64,76.86 272.84,76.67 272.84,76.42 272.77,76.36 270.04,76.36 269.91,76.48 269.91,76.67 270.36,77.11 270.36,78.2 269.96,78.59 269.96,79.83 270.3,80.17 270.3,80.27 270.3,81.12 270.11,81.31 269.6,81.31 269.47,81.44 269.47,81.88 269.28,82.07 269.28,82.26 269.41,82.39 270.36,82.39
GND on BOTTOM (solid shape): 170.39,100.15 170.42,100.11 170.46,100.07 170.62,100.01 170.71,100.02 170.71,100.02 170.78,100.02 170.9,100.15 171.1,100.15 171.22,100.02 171.22,99.83 170.84,99.45 170.84,98.82 170.71,98.69 170.46,98.69 170.4,98.75 170.4,99.45 170.03,99.81 170.03,100.08 170.15,100.2 170.34,100.2
GND on BOTTOM (solid shape): 149.97,100.06 149.97,99.85 149.66,99.54 149.66,99.46 149.64,99.43 149.64,98.82 149.49,98.67 149.08,98.67 148.9,98.85 148.9,99.6 148.86,99.64 148.85,99.66 148.8,99.75 148.72,99.81 148.7,99.83 148.7,100.02 148.84,100.16 149.11,100.16 149.21,100.06 149.23,100.05 149.43,100.02 149.59,100.14 149.59,100.15 149.63,100.18 149.84,100.18
GND on BOTTOM (solid shape): 126.09,108.43 126.09,107.98 125.9,107.79 125.77,107.79 125.52,107.53 125.52,107.41 125.32,107.21 125.2,107.21 125.13,107.14 125.13,106.96 125.01,106.84 125.01,105.31 124.75,105.06 124.75,103.72 125.1,103.38 125.1,102.23 124.68,101.81 124.68,100.77 124.82,100.63 124.82,99.72 124.69,99.6 124.44,99.6 124.31,99.72 124.31,100.68 124.42,100.78 124.42,101.84 123.95,102.3 123.95,104.96 124.05,105.06 124.05,105.37 123.86,105.57 123.86,107.53 124.3,107.97 124.3,108.44 124.43,108.57 125.95,108.57
GND on BOTTOM (solid shape): 161.79,100.05 161.79,99.82 161.46,99.49 161.46,98.82 161.34,98.7 160.87,98.7 160.73,98.84 160.73,99.59 160.66,99.65 160.66,99.66 160.61,99.76 160.52,99.82 160.52,100.01 160.66,100.15 160.93,100.15 160.97,100.11 160.99,100.08 161.05,100.04 161.24,100.02 161.39,100.13 161.44,100.18 161.67,100.18
GND on BOTTOM (solid shape): 369.23,21 369.83,20.3 370.6,20.8 373.99,20.8 374.49,21.1 380.1,21.1 380.1,18.37 379.64,18.37 379.64,18.38 370.11,18.38 368.59,19.9 365.48,19.9 364.78,20.6 364.78,22.32 365.17,22.71 369.23,22.71
GND on BOTTOM (solid shape): 170.76,35.76 170.76,33.58 170.47,33.29 170.18,33.29 170.09,33.38 170.09,33.56 169.79,33.86 169.45,33.86 169.41,33.9 169.41,35.57 169.23,35.75 168.94,35.75 168.74,35.55 168.74,33.68 168.69,33.64 168.66,33.58 168.64,33.56 168.63,33.56 168.63,33.42 168.27,33.06 168.05,33.06 167.92,33.19 167.92,33.41 168.34,33.82 168.37,33.9 168.38,33.98 168.38,35.42 168.37,35.48 168.4,35.56 168.47,35.6 168.61,35.6 168.93,35.92 170.6,35.92
GND on BOTTOM (solid shape): 173.91,128.05 174.11,127.98 174.3,128.05 174.59,128.05 174.62,128.02 174.66,128 174.75,127.9 174.75,124.68 174.71,124.63 174.49,124.63 173.9,124.04 173.9,122.58 173.71,122.39 173.2,122.39 172.76,122.84 169.77,122.84 169.58,123.03 167.3,123.03 167.23,122.96 166.22,122.96 166.16,123.03 166.16,123.98 166.28,124.11 167.11,124.11 167.81,124.81 170.47,124.81 170.98,124.3 173.45,124.3 173.85,124.7 173.85,126.98 173.57,127.25 171.36,127.25 171.25,127.37 171.25,127.93 171.36,128.05
GND on BOTTOM (solid shape): 151.52,100.11 151.64,100.02 151.79,100.02 151.83,100.03 151.89,100.06 152.01,100.18 152.2,100.18 152.33,100.06 152.33,99.87 151.95,99.49 151.95,98.85 151.82,98.72 151.42,98.72 151.3,98.84 151.3,99.59 151.2,99.69 151.2,99.69 151.14,99.77 151.06,99.83 151.06,100.04 151.12,100.08 151.17,100.15 151.2,100.18 151.47,100.18
GND on BOTTOM (solid shape): 200.1,81.22 200.17,81.19 200.19,81.17 200.22,81.1 200.19,81.03 200.18,80.48 200.73,80.49 200.85,80.49 201.58,79.75 201.58,79.11 201.42,78.94 201.42,78.57 201.1,78.26 199.7,78.26 199.44,78.51 199.44,80.86 199.66,81.08 199.86,81.08 200.03,81.19
GND on BOTTOM (solid shape): 276.13,31.14 276.23,31.09 276.33,31.08 276.35,31.08 276.42,31.01 276.43,30.97 276.45,30.93 276.45,30.65 276.4,30.62 276.16,30.62 276.15,30.62 275.79,30.41 276.15,30.2 276.16,30.21 276.4,30.21 276.45,30.18 276.45,29.75 276.3,29.59 275.6,29.59 275.57,29.57 274.49,29.57 274.42,29.5 274.36,29.56 274.36,30.89 274.49,31.02 275.44,31.02 275.57,31.14
GND on BOTTOM (solid shape): 275.26,52.51 275.26,52.51 275.33,52.41 275.43,52.34 275.44,52.34 275.48,52.29 275.82,52.29 275.82,52.17 275.82,52.16 275.8,51.96 275.95,51.81 275.98,51.8 275.98,51.66 275.96,51.62 275.95,51.58 275.68,51.32 275.61,51.39 275.3,51.39 275.29,51.4 275.17,51.43 275.05,51.4 275.04,51.39 274.67,51.39 274.66,51.42 274.5,51.6 274.27,51.62 274.18,51.64 274.14,51.72 274.14,52.5 274.31,52.67 275.1,52.67
GND on BOTTOM (solid shape): 218.45,106.35 218.45,106.18 218.35,106.08 218.35,105.73 218.44,105.64 218.44,105.49 218.36,105.41 218.36,105 218.5,104.86 218.5,104.19 218.75,103.94 218.75,103.87 218.76,103.86 218.77,103.8 218.76,103.75 218.75,103.73 218.75,103.7 218.32,103.26 218.18,103.26 218.04,103.4 218.01,103.48 218.05,103.55 218.17,103.83 218,104.08 218,104.96 218.12,105.21 218,105.46 218,105.65 218.14,105.91 218,106.17 218,106.28 218.14,106.43 218.37,106.43
GND on BOTTOM (solid shape): 217.69,95.92 217.7,95.91 217.77,95.84 217.87,95.79 217.89,95.79 217.96,95.71 217.99,95.69 217.99,95.68 218.04,95.59 218.11,95.52 218.11,95.46 218.45,95.11 218.45,93.77 218.66,93.57 218.69,93.5 218.72,93.46 218.72,93.17 218.47,92.93 218.47,92.2 218.32,92.05 218.19,92.05 218.03,92.21 218.03,94.98 217.83,95.17 217.78,95.24 217.72,95.27 217.68,95.32 217.67,95.33 217.53,95.47 217.5,95.55 217.48,95.6 217.42,95.65 217.39,95.72 217.38,95.75 217.39,95.78 217.42,95.85 217.48,95.9 217.52,95.92 217.56,95.93 217.65,95.94
GND on BOTTOM (solid shape): 168.07,43.95 168.07,43.92 168.04,43.88 167.68,43.89 167.52,43.62 167.52,42.18 167.61,41.96 167.82,41.87 167.85,41.87 168.31,41.4 168.31,41.11 168.26,41.02 168.16,41.03 168.06,41.06 167.94,41.06 167.92,41.06 167.03,41.95 167.06,41.98 167.11,42.07 167.13,42.18 167.13,43.62 167.1,43.75 167.03,43.85 167,43.91 167.01,43.98 167.04,44.02 167.05,44.07 167.1,44.11 167.91,44.11
GND on BOTTOM (solid shape): 195.21,117.88 195.21,117.63 195.21,117.62 195.17,117.48 195.21,117.33 195.21,117.32 195.21,117.22 195.31,117.12 195.64,117.12 195.75,117.02 195.75,116.72 195.64,116.61 195.39,116.61 195.26,116.49 195.26,116.16 195.24,116.02 195.26,115.9 195.26,115.89 195.26,115.75 195.37,115.65 195.67,115.65 195.82,115.5 195.82,115.29 195.7,115.17 195.42,115.17 195.26,115.01 195.26,114.82 195.24,114.68 195.26,114.56 195.26,114.56 195.26,114.43 195.37,114.33 195.67,114.33 195.82,114.18 195.82,113.94 195.7,113.82 195.42,113.82 195.26,113.67 195.26,113.55 195.24,113.41 195.26,113.29 195.26,113.29 195.26,113.16 195.37,113.06 195.67,113.06 195.82,112.91 195.82,112.68 195.69,112.55 195.37,112.55 195.26,112.45 195.26,112.28 195.24,112.14 195.26,112.02 195.26,112.02 195.26,111.84 195.31,111.79 195.67,111.79 195.82,111.64 195.82,111.38 195.7,111.27 194.74,111.27 194.48,111.53 194.48,112.55 194.22,112.8 194.22,117.76 194.41,117.95 195.15,117.95
GND on BOTTOM (solid shape): outline of 92 points within 173.84,137.95 190.98,145.7
GND on BOTTOM (solid shape): 129.91,39.62 130.02,39.64 130.09,39.54 130.09,39.34 129.45,38.7 129.42,38.71 129.01,38.25 129.62,38.27 129.62,38.28 129.91,38.57 130.02,38.6 130.09,38.5 130.09,37.35 130.02,37.25 129.91,37.28 129.78,37.41 129.57,37.41 129.19,37.51 128.98,37.19 128.98,37.17 128.93,37.12 128.82,37.22 128.82,38.72 128.89,38.79 128.89,39.28 128.96,39.38 129.07,39.35 129.33,39.23 129.58,39.35 129.65,39.35
GND on BOTTOM (solid shape): 233.43,100.79 233.7,100.79 233.76,100.73 234.15,100.53 234.47,100.82 235.1,100.82 235.24,100.67 235.24,100.58 235.17,100.5 234.82,100.5 234.54,100.23 234.47,100.23 234.17,100.19 234.05,99.92 234.02,99.84 233.95,99.8 233.92,99.8 233.85,99.74 233.54,99.74 233.45,99.82 233.45,99.92 233.55,100.49 232.97,100.51 232.9,100.48 232.83,100.51 232.8,100.54 232.77,100.57 232.72,100.65 232.77,100.73 232.88,100.85 232.93,101 232.95,101.03 232.98,101.05 233.03,101.06 233.09,101.08 233.12,101.09
GND on BOTTOM (solid shape): 217.76,91.62 217.76,91.45 217.63,91.17 217.8,90.92 217.8,90.78 217.63,90.5 217.8,90.22 217.83,90.21 217.83,90 217.73,89.9 217.73,89.67 217.8,89.6 217.8,89.39 217.63,89.09 217.82,88.81 217.85,88.8 217.85,88.7 217.7,88.55 217.4,88.55 217.15,88.8 217.15,88.81 217.1,88.93 217,89.01 217,89.18 217.07,89.24 217.18,89.35 217.18,89.53 217,89.71 217,89.89 217.09,89.96 217.14,90.06 217.14,90.07 217.15,90.14 217.15,90.2 217.15,90.8 217.15,90.8 217.13,90.97 217.03,91.1 217.03,91.3 217.09,91.37 217.15,91.5 217.4,91.75 217.63,91.75
GND on BOTTOM (solid shape): 234.65,99.4 234.72,99.36 234.75,99.29 234.86,99.01 235.15,98.97 235.19,98.98 235.28,98.88 235.28,98.52 235.17,98.4 234.77,98.4 234.49,98.12 234.42,98.15 234.38,98.15 234.35,98.17 234.33,98.2 234.07,98.51 233.67,98.41 233.6,98.38 233.53,98.41 233.36,98.52 233.16,98.52 233.06,98.55 233.04,98.66 233.07,98.79 233.06,98.92 233.06,98.95 233.08,98.98 233.16,99.03 233.21,99.1 233.3,99.15 233.39,99.1 233.73,98.96 233.95,99.25 233.95,99.27 234.08,99.4
GND on BOTTOM (solid shape): 232.29,116.39 232.4,116.41 232.46,116.31 232.46,115.81 232.37,115.72 232.37,115.07 232.26,114.96 232.24,114.95 231.96,114.72 232.1,114.39 232.15,114.3 232.1,114.21 232.02,114.15 231.97,114.07 231.96,114.05 231.83,114.03 231.48,113.75 231.64,113.33 231.68,113.25 231.64,113.17 231.6,113.14 231.57,113.11 231.5,113.08 231.43,113.11 231.32,113.19 231.2,113.23 231.17,113.25 231.15,113.28 231.11,113.41 231,113.51 230.95,113.6 231,113.69 231.11,113.79 231.15,113.94 231.15,113.96 231.41,114.21 231.41,114.71 232.05,115.36 232.05,116.15
GND on BOTTOM (solid shape): 223.12,111.2 223.18,111.17 223.21,111.15 223.23,111.11 223.22,111.08 223.19,110.7 223.5,110.48 223.55,110.44 223.59,110.29 223.7,110.19 223.75,110.1 223.7,110.01 223.55,109.78 223.65,109.52 223.67,109.5 223.67,109.43 223.64,109.43 223.16,108.95 223.09,108.95 223.01,109.03 222.98,109.1 223.01,109.17 223.13,109.41 223.07,109.67 223.06,109.69 223.08,109.73 223.23,110.12 222.94,110.42 222.76,110.48 222.75,110.49 222.75,110.51 222.7,110.63 222.6,110.71 222.55,110.8 222.6,110.89 222.68,110.95 222.73,111.03 222.74,111.05 222.98,111.13 223.05,111.18
GND on BOTTOM (solid shape): 250.37,51.91 250.57,51.91 250.65,51.87 250.67,51.79 250.84,51.42 251.23,51.49 251.31,51.53 251.38,51.49 251.78,51.42 251.95,51.79 251.97,51.87 252.05,51.91 256.79,51.91 256.87,51.87 256.89,51.79 257.06,51.42 257.46,51.49 257.53,51.53 257.61,51.49 257.96,51.41 258.18,51.7 258.24,51.78 258.35,51.76 258.75,51.36 258.75,50.57 257.32,49.14 253.35,49.14 251.88,47.67 249.02,47.67 248.39,48.3 244.86,48.3 244.6,48.56 244.6,53.03 244.72,53.15 249.12,53.15
GND on BOTTOM (solid shape): 231.2,97.05 231.29,97 231.35,96.92 231.42,96.87 231.44,96.86 231.48,96.76 231.48,96.62 231.29,96.43 231.01,96.35 230.87,96.1 230.85,96.07 230.82,96.05 230.69,96.01 230.59,95.9 230.5,95.85 230.41,95.9 230.17,96.05 229.91,95.94 229.84,95.9 229.76,95.93 229.51,96.18 229.45,96.28 229.38,96.36 229.38,96.54 229.42,96.58 229.49,96.6 229.56,96.57 229.85,96.43 230.15,96.56 230.22,96.59 230.29,96.57 230.66,96.48 230.92,96.76 230.96,96.86 230.98,96.87 231.05,96.92 231.11,97
GND on BOTTOM (solid shape): 11.94,106.35 12.23,106.29 12.48,106.13 18.56,100.37 18.56,99.91 11.99,99.91 11.86,99.79 11.86,97.64 11.6,97.37 7.8,97.37 7.59,97.46 7.5,97.67 7.5,97.9 7.3,98.4 6.8,98.6 6,98.6 5.5,98.4 5.3,97.9 5.3,97.67 5.21,97.46 5,97.37 0.5,97.37 0.29,97.46 0.2,97.67 0.2,99.85 0.44,100.41 1,100.65 2.6,100.65 3.45,101 3.8,101.85 3.8,105.55 4.04,106.11 4.6,106.35
GND on BOTTOM (solid shape): 236.39,115.18 236.39,113.88 236.27,113.75 236.08,113.75 236.01,113.82 235.7,113.82 235.63,113.88 235.63,114.01 235.71,114.09 235.71,114.11 235.72,114.14 235.54,114.58 235.07,114.51 235,114.48 234.93,114.51 234.55,114.62 234.28,114.34 234.24,114.24 234.15,114.18 234.08,114.09 234,114.05 233.92,114.09 233.87,114.17 233.79,114.22 233.75,114.3 233.79,114.38 233.88,114.45 233.94,114.54 234.04,114.58 234.33,114.97 234,115.33 233.97,115.36 233.93,115.51 233.82,115.62 233.82,115.86 234,116.04 234.16,116.07 234.44,116.25 234.47,116.58 234.48,116.67 234.57,116.71 234.86,116.71
GND on BOTTOM (solid shape): 7.99,82.61 8.53,82.5 9.05,82.32 9.05,81.96 9.18,80.99 10.04,80.55 11.07,80.55 11.58,77.67 10.12,75.14 7.87,75.14 7.87,76.4 3.65,76.4 3.53,76.65 3.42,76.9 3.42,79.05 3.4,79.31 3.31,79.56 4.05,81.02 5.3,82.09 5.51,81.6 6,81.4 6.8,81.4 7.3,81.6 7.5,82.1 7.5,82.31 7.59,82.52 7.8,82.61
GND on BOTTOM (solid shape): 203.2,84.45 203.29,84.4 203.35,84.32 203.43,84.27 203.46,84.26 203.47,84.2 203.73,83.89 204.13,83.99 204.2,84.02 204.27,83.99 204.5,83.76 204.5,83.13 204.37,83.09 204.26,83 203.98,83 203.85,83.13 203.64,83.44 203.29,83.3 203.2,83.25 202.85,83.45 202.5,83.25 202.41,83.3 202.35,83.38 202.27,83.43 202.24,83.44 202.23,83.5 202.17,83.65 202.07,83.77 202.02,83.85 202.07,83.93 202.1,83.96 202.13,83.99 202.2,84.02 202.27,83.99 202.67,83.89 202.93,84.2 202.94,84.26 202.97,84.27 203.05,84.32 203.11,84.4
GND on BOTTOM (solid shape): 233.45,96.6 233.69,96.6 233.72,96.57 234.1,96.3 234.47,96.59 234.54,96.63 234.62,96.6 235.15,96.6 235.25,96.49 235.25,96.39 235.17,96.3 234.77,96.3 234.49,96.02 234.46,96.04 234.21,96.02 234.06,95.83 234.05,95.79 233.84,95.79 233.61,95.57 233.52,95.57 233.45,95.63 233.45,95.77 233.46,96.42 232.87,96.15 232.85,96.04 232.82,96.03 232.75,95.97 232.69,95.9 232.6,95.85 232.51,95.9 232.45,95.98 232.38,96.03 232.36,96.04 232.25,96.29 232.12,96.39 232.06,96.47 232.1,96.56 232.13,96.59 232.2,96.62 232.27,96.59 232.67,96.49 232.93,96.8 232.98,96.85 233.04,96.86 233.1,96.89 233.14,96.91
