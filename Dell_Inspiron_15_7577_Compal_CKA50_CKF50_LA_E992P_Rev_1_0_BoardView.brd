# Allegro board Dell_Inspiron_15_7577_Compal_CKA50_CKF50_LA_E992P_Rev_1_0_BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_ACT#: length 93.8
  IN5 w0.076: v2(154.32,83.72) 154.68,83.37 154.68,77.74 155.21,77.21 155.21,73.17
  IN5 w0.145: 155.21,73.17 155.21,70.53 155.04,70.36 154.9,70.36 154.73,70.19 154.73,69.95 154.9,69.78 155.04,69.78 155.21,69.61 155.21,69.37 155.04,69.2 154.9,69.2 154.73,69.03 154.73,68.79 154.9,68.62 155.04,68.62 155.21,68.45 155.21,68.21 155.04,68.04 154.9,68.04 154.73,67.87 154.73,67.63 154.9,67.46 155.04,67.46 155.21,67.29 155.21,67.05 155.04,66.88 154.9,66.88 154.73,66.71 154.73,66.47 154.9,66.3 155.04,66.3 155.21,66.13 155.21,65.83 155.04,65.66 154.9,65.66 154.73,65.49 154.73,65.25 154.9,65.08 155.04,65.08 155.21,64.91 155.21,63.63 174.67,44.16 181.96,44.16 183.29,42.84 202.66,42.84 202.83,42.67 202.83,42.04 203,41.87 203.24,41.87 203.41,42.04 203.41,42.67 203.58,42.84 204.37,42.84 205.67,41.54 205.67,38.67 206.95,37.39 207.79,37.39 v2(207.84,37.44)
  BOTTOM w0.089: UH1.AT9 v2(154.32,83.72)
  BOTTOM w0.213: v2(207.84,37.44) 207.61,37.44 207.2,37.04 207.2,35.87 207.57,35.49 JDIMM2.114
DDR_B_ALERT#: length 88.4
  IN5 w0.076: v2(155.24,82.88) 155.59,82.53 155.59,82.07 155.19,81.68 155.19,77.96 156.87,76.28 156.87,74.47 157.04,74.3 157.04,73.17
  IN5 w0.145: 157.04,73.17 157.38,72.83 157.38,72.8 157.58,72.6 157.58,66.91 158.35,66.14 158.35,64.37 158.34,64.37 158.34,62.4 175.23,45.51 182.52,45.51 182.73,45.3 198.57,45.3 198.95,44.92 204.45,44.92 207.68,41.69 207.68,38.74 208.51,37.91 208.51,36.54 208.18,36.21 207.88,36.21 v2(207.84,36.17)
  BOTTOM w0.089: UH1.AR8 v2(155.24,82.88)
  BOTTOM w0.14: JDIMM2.116 208.08,35.59
  BOTTOM w0.213: 208.08,35.59 208.08,35.96 207.86,36.17 v2(207.84,36.17)
DDR_B_BG0: length 91.3
  IN5 w0.076: 155.67,73.3 155.67,76.98 154.84,77.81 154.84,83.33 v2(155.23,83.72)
  IN5 w0.145: 155.67,73.3 155.67,66.11 155.84,65.95 156.41,65.95 156.58,65.78 156.58,65.54 156.41,65.37 155.84,65.37 155.67,65.2 155.67,64.96 155.84,64.79 156.41,64.79 156.58,64.62 156.58,64.38 156.41,64.21 155.84,64.21 155.67,64.04 155.67,63.8 174.86,44.61 182.15,44.61 183.48,43.29 204.56,43.29 206.12,41.73 206.12,39.35 v2(206.74,38.72)
  BOTTOM w0.089: v2(155.23,83.72) 155.1,83.72 154.78,83.4 UH1.AR9
  BOTTOM w0.213: JDIMM2.115 207.83,40.89 207.56,40.62 207.56,39.54 v2(206.74,38.72)
DDR_B_BG1: length 93.5
  IN5 w0.076: 156.4,73.17 156.65,73.42 156.65,74.43 156.46,74.62 156.46,76.46 155.03,77.89 155.03,82.07 v2(155.23,82.28)
  IN5 w0.145: v2(206.74,40.03) 206.74,42 205,43.74 183.66,43.74 182.34,45.06 175.05,45.06 157.07,63.03 157.07,64.22 157.24,64.39 157.73,64.39 157.9,64.56 157.9,64.8 157.73,64.97 157.24,64.97 157.07,65.14 157.07,65.38 157.24,65.55 157.73,65.55 157.9,65.72 157.9,65.96 157.73,66.13 157.24,66.13 157.07,66.3 157.07,66.71 156.9,66.88 156.29,66.88 156.12,67.05 156.12,67.29 156.29,67.46 156.9,67.46 157.07,67.63 157.07,67.87 156.9,68.04 156.29,68.04 156.12,68.21 156.12,68.45 156.29,68.62 156.9,68.62 157.07,68.79 157.07,69.02 156.9,69.19 156.29,69.19 156.12,69.36 156.12,69.6 156.29,69.77 156.9,69.77 157.07,69.94 157.07,70.18 156.9,70.35 156.29,70.35 156.12,70.52 156.12,71.18 156.29,71.35 156.9,71.35 157.07,71.52 157.07,71.76 156.9,71.93 156.29,71.93 156.12,72.1 156.12,72.9 156.4,73.17
  BOTTOM w0.089: UH1.AR7 155.05,82.1 v2(155.23,82.28)
  BOTTOM w0.213: v2(206.74,40.03) 206.74,40.84 207.32,41.43 JDIMM2.113
DDR_B_BS0: length 98.7
  IN5 w0.076: v2(160.72,83.07) 161.12,82.67 161.12,78.9 161.3,78.72 163.04,78.72 163.62,78.13 164.71,78.13 165.01,77.84 165.01,75.11 169.16,70.95 169.16,69.86 169.21,69.81 169.16,69.76 169.16,69.58
  IN5 w0.145: v2(218.58,36.17) 219.49,37.08 219.49,46.12 210.27,55.34 191.76,55.34 191.59,55.51 191.59,55.72 191.42,55.89 191.18,55.89 191.02,55.72 191.02,55.51 190.85,55.34 190.61,55.34 190.44,55.51 190.44,55.72 190.27,55.89 190.03,55.89 189.86,55.72 189.86,55.51 189.69,55.34 189.45,55.34 189.28,55.51 189.28,55.72 189.11,55.89 188.87,55.89 188.7,55.72 188.7,55.51 188.53,55.34 187.96,55.34 187.79,55.51 187.79,55.72 187.62,55.89 187.38,55.89 187.21,55.72 187.21,55.51 187.04,55.34 186.8,55.34 186.63,55.51 186.63,55.72 186.46,55.89 186.22,55.89 186.05,55.72 186.05,55.51 185.88,55.34 185.64,55.34 185.47,55.51 185.47,55.72 185.31,55.89 185.07,55.89 184.9,55.72 184.9,55.51 184.73,55.34 184.38,55.34 183.2,56.52 182.96,56.52 182.47,56.03 182.23,56.03 182.06,56.2 182.06,56.44 182.55,56.93 182.55,57.17 175.59,64.13 175.59,64.13 175.48,64.24 171.53,64.24 169.16,66.61 169.16,69.58
  BOTTOM w0.076: UH1.AH8 v2(160.72,83.07)
  BOTTOM w0.213: JDIMM2.150 v2(218.58,36.17)
DDR_B_BS1: length 98.9
  IN5 w0.076: v2(160.72,83.72) 160.36,83.36 160.36,82.21 160.79,81.78 160.79,78.74 161.14,78.39 162.9,78.39 163.64,77.65 163.64,74.91 168.26,70.29 168.26,69.58
  IN5 w0.145: 168.26,69.58 168.26,66.24 171.16,63.34 175.11,63.34 175.21,63.23 175.65,62.8 175.65,62.8 176.03,62.41 176.47,61.98 176.47,61.98 176.85,61.59 176.85,61.59 177.29,61.16 178.11,60.34 178.11,60.34 178.47,59.97 178.47,59.73 177.98,59.24 177.98,59 178.15,58.83 178.39,58.83 178.88,59.32 179.12,59.32 179.29,59.15 179.29,58.91 178.8,58.42 178.8,58.18 182.55,54.44 209.85,54.44 218.56,45.73 218.56,38.9 217.4,37.75 v2(216.96,37.75)
  BOTTOM w0.076: UH1.AH9 160.26,83.62 160.54,83.81 160.64,83.8 160.72,83.73 v2(160.72,83.72)
  BOTTOM w0.213: JDIMM2.145 217.32,41.12 217.59,40.86 217.59,40.49 217.6,40.49 217.6,39.96 217.59,39.95 217.59,39.29 217.6,39.28 217.6,38.75 217.59,38.75 217.59,38.28 217.06,37.75 v2(216.96,37.75)
DDR_B_CAS#: length 100.3
  IN5 w0.076: 170.96,69.58 170.96,70.05 170.68,70.34 170.68,70.37 165.67,75.38 165.67,78.11 164.99,78.79 164.14,78.79 163.39,79.55 163.39,80.14 162.65,80.88 162.65,81.85 162.19,82.3 162.19,82.59 162.55,82.95 v2(162.55,83.08)
  IN5 w0.145: v2(222.56,38.59) 222.46,38.59 221.83,39.22 221.83,41.76 222.87,42.8 222.87,45.34 210.52,57.68 189.02,57.68 187.28,59.42 184.8,59.42 182.84,61.38 180.88,61.38 180.67,61.59 180.67,61.83 181.1,62.25 181.1,62.49 180.93,62.66 180.69,62.66 180.26,62.24 180.02,62.24 179.85,62.41 179.85,62.65 180.28,63.07 180.28,63.31 180.11,63.48 179.87,63.48 179.44,63.06 179.2,63.06 179.03,63.23 179.03,63.47 179.46,63.89 179.46,64.13 179.29,64.3 179.05,64.3 178.62,63.88 178.38,63.88 178.21,64.05 178.21,64.29 178.64,64.71 178.64,64.95 178.47,65.12 178.23,65.12 177.8,64.7 177.56,64.7 176.33,65.93 176.33,65.93 176.23,66.04 173.94,66.04 173.33,66.64 171.67,66.64 170.96,67.36 170.96,69.58
  BOTTOM w0.076: UH1.AF8 162.03,82.81 162.03,82.98 162.32,83.19 162.45,83.19 162.55,83.09 v2(162.55,83.08)
  BOTTOM w0.213: v2(222.56,38.59) 222.56,38.57 221.43,37.44 221.43,37.11 220.07,35.76 JDIMM2.156
DDR_B_CKE0: length 99.2
  IN5 w0.076: 153.65,73.17 153.65,78.34 153.68,78.37 153.68,81.11 154.32,81.74 v2(154.32,83.07)
  IN5 w0.145: 153.65,73.17 154.28,72.54 154.28,72.01 154.11,71.84 153.63,71.84 153.47,71.67 153.47,71.43 153.63,71.26 154.11,71.26 154.28,71.09 154.28,70.85 154.11,70.68 153.63,70.68 153.47,70.51 153.47,70.27 153.63,70.1 154.11,70.1 154.28,69.93 154.28,69.69 154.11,69.52 153.63,69.52 153.47,69.35 153.47,69.11 153.63,68.94 154.11,68.94 154.28,68.77 154.28,68.53 154.11,68.36 153.63,68.36 153.47,68.19 153.47,67.95 153.63,67.79 154.11,67.79 154.28,67.62 154.28,67.2 154.11,67.03 153.63,67.03 153.47,66.86 153.47,66.62 153.63,66.45 154.11,66.45 154.28,66.28 154.28,66.04 154.11,65.88 153.63,65.88 153.47,65.71 153.47,65.47 153.63,65.3 154.11,65.3 154.28,65.13 154.28,63.92 174.55,43.65 178.3,43.65 178.54,43.42 178.54,42.68 178.64,42.57 179.01,42.57 179.12,42.68 179.12,43.42 179.29,43.59 179.53,43.59 179.7,43.42 179.7,42.57 179.8,42.46 180.17,42.46 180.27,42.57 180.27,43.42 180.44,43.59 180.68,43.59 180.85,43.42 180.85,42.57 180.96,42.46 181.33,42.46 181.43,42.57 181.43,43.42 181.6,43.59 181.84,43.59 182.01,43.42 182.01,42.57 182.19,42.39 201.47,42.39 201.91,41.95 204.7,39.16 v2(204.7,39.14)
  BOTTOM w0.089: UH1.AT8 v2(154.32,83.07)
  BOTTOM w0.213: v2(204.7,39.14) 205.25,39.14 205.83,39.73 205.83,41.1 206.32,41.59 JDIMM2.109
DDR_B_CKE1: length 99
  IN5 w0.076: v2(154.32,84.37) 153.82,83.88 153.82,82.63 152.34,81.14 152.34,73.85 153.02,73.17
  IN5 w0.145: 153.02,73.17 153.02,64.67 153.83,63.85 153.83,63.73 171.73,45.84 171.73,45.6 171.01,44.88 171.01,44.64 171.18,44.47 171.42,44.47 172.14,45.19 172.38,45.19 172.54,45.02 172.54,44.78 171.83,44.06 171.83,43.82 172,43.65 172.24,43.65 172.36,43.78 172.51,43.78 173.52,42.76 174.47,42.76 174.85,43.15 175.22,43.15 175.37,43 175.37,42.53 175.51,42.38 175.91,42.38 176.06,42.53 176.06,43.03 176.23,43.2 176.47,43.2 176.64,43.03 176.64,42.18 176.81,42.01 177.05,42.01 177.22,42.18 177.22,43.03 177.39,43.2 177.63,43.2 177.8,43.03 177.8,42.18 178.04,41.94 179.47,41.94 179.61,41.79 179.61,40.81 179.76,40.67 180.02,40.67 180.17,40.81 180.17,41.79 180.31,41.94 201.28,41.94 201.46,41.76 201.46,41.76 202.35,40.87 202.35,40.35 204.21,38.49 204.21,38.11 204.48,37.84 v2(204.64,37.84)
  BOTTOM w0.089: UH1.AT10 v2(154.32,84.37)
  BOTTOM w0.213: JDIMM2.110 206.57,35.77 204.64,37.71 v2(204.64,37.84)
DDR_B_CLK0: length 96.5
  IN5 w0.076: 165.6,69.58 165.6,69.65 165.59,69.67 165.59,71.78 162.81,74.56 162.81,75.38 159.72,78.47 159.72,81.29 159.08,81.93 157.95,81.93 157.61,82.27 157.61,83.35 v2(157.98,83.72)
  IN5 w0.097: 165.6,69.58 165.6,65.37 170.18,60.79 170.21,60.79 170.99,60.79 171.04,60.74 171.49,60.28 171.69,60.28 172.34,60.93 172.69,60.93 172.94,60.68 172.94,60.32 172.3,59.68 172.3,59.48 172.44,59.34 172.64,59.34 173.28,59.98 173.64,59.98 173.89,59.73 173.89,59.38 173.83,59.32 173.27,58.77 173.27,58.63 179.82,52.08 208.69,52.08 215.66,45.11 215.66,42.57 215.41,42.32 215.25,42.32 215.11,42.18 215.11,41.98 215.25,41.84 215.41,41.84 215.66,41.59 215.66,40.97 215.63,40.94 215.63,40.17 215.37,39.91 215.09,39.91 214.99,39.81 v2(214.99,39.6)
  BOTTOM w0.089: UH1.AM9 v2(157.98,83.72)
  BOTTOM w0.14: JDIMM2.137 213.32,40.87 214.34,39.86 214.74,39.86 v2(214.99,39.6)
DDR_B_CLK1: length 98.4
  IN5 w0.076: v2(157.98,82.42) 157.98,82.5 158.05,82.58 158.24,82.58 158.39,82.43 158.87,82.43 159.93,81.37 159.93,78.5 162.98,75.44 162.98,74.62 166.42,71.18 166.42,69.58
  IN5 w0.097: 166.42,69.58 166.42,66.25 166.42,65.35 170.34,61.43 172.95,61.43 174.8,59.58 174.8,59.38 174.22,58.8 174.22,58.45 174.47,58.2 174.83,58.2 175.41,58.78 175.61,58.78 175.75,58.63 175.75,58.43 175.17,57.85 175.17,57.5 175.42,57.25 175.77,57.25 176.35,57.83 176.55,57.83 176.69,57.69 176.69,57.49 176.11,56.91 176.11,56.5 180.03,52.58 209.03,52.58 216.16,45.45 216.16,38.24 216.16,37.35 215.61,36.79 215.04,36.79 v2(214.64,37.19)
  BOTTOM w0.089: UH1.AM7 157.52,82.22 157.72,82.42 v2(157.98,82.42)
  BOTTOM w0.14: JDIMM2.138 213.58,36.28 214.24,36.95 214.35,36.95 214.43,37.03 214.48,37.03 v2(214.64,37.19)
DDR_B_CLK#0: length 96.5
  IN5 w0.076: 165.42,69.58 165.42,69.65 165.43,69.67 165.43,71.71 162.65,74.49 162.65,75.31 159.55,78.4 159.55,81.21 159.01,81.76 157.88,81.76 157.44,82.2 157.44,83.88 157.36,83.95 157.14,83.95 157.06,83.88 v2(157.06,83.72)
  IN5 w0.097: 165.42,69.58 165.42,65.29 170.1,60.61 170.28,60.61 170.28,60.61 170.91,60.61 171.42,60.1 171.77,60.1 172.42,60.74 172.61,60.74 172.76,60.6 172.76,60.4 172.11,59.76 172.11,59.4 172.36,59.15 172.72,59.15 173.36,59.8 173.56,59.8 173.7,59.65 173.7,59.46 173.39,59.14 173.09,58.84 173.09,58.55 179.75,51.9 208.62,51.9 215.48,45.04 215.48,42.65 215.33,42.51 215.17,42.51 214.92,42.26 214.92,41.9 215.17,41.65 215.33,41.65 215.48,41.51 215.48,41.05 215.45,41.02 215.45,40.25 215.29,40.09 215.11,40.09 214.99,40.22 v2(214.99,40.41)
  BOTTOM w0.089: UH1.AN9 156.61,83.56 156.84,83.72 v2(157.06,83.72)
  BOTTOM w0.14: v2(214.99,40.41) 214.71,40.13 214.45,40.13 213.6,40.99 213.6,41.8 213.83,42.02 JDIMM2.139
DDR_B_CLK#1: length 98.3
  IN5 w0.076: 166.61,69.58 166.61,69.6 166.6,69.61 166.6,69.76 166.59,69.77 166.59,71.25 163.14,74.69 163.14,75.51 160.1,78.56 160.1,81.44 158.94,82.59 158.46,82.59 v2(157.98,83.07)
  IN5 w0.097: v2(214.61,36.6) 215.69,36.6 216.35,37.27 216.35,37.73 216.35,45.52 209.1,52.77 180.11,52.77 176.3,56.58 176.3,56.83 176.88,57.41 176.88,57.77 176.63,58.02 176.28,58.02 175.69,57.44 175.5,57.44 175.35,57.58 175.35,57.78 175.93,58.36 175.93,58.71 175.68,58.96 175.33,58.96 174.75,58.38 174.55,58.38 174.41,58.52 174.41,58.72 174.99,59.3 174.99,59.66 173.03,61.62 170.41,61.62 166.61,65.42 166.61,65.55 166.61,65.55 166.61,66.18 166.61,66.18 166.61,69.58
  BOTTOM w0.089: UH1.AM8 v2(157.98,83.07)
  BOTTOM w0.14: JDIMM2.140 214.08,35.67 213.85,35.89 213.85,36.17 214.36,36.67 214.54,36.67 v2(214.61,36.6)
DDR_B_CS#0: length 95.3
  IN5 w0.076: 170.51,69.58 170.51,70.31 165.5,75.31 165.5,78.04 164.92,78.63 164.07,78.63 163.22,79.48 163.22,79.97 162.48,80.7 162.48,81.78 162.03,82.23 162.03,83.97 162.41,84.35
  IN5 w0.145: 170.51,69.58 170.51,67.17 171.48,66.2 173.14,66.2 173.75,65.59 176.04,65.59 176.15,65.48 181.34,60.29 182.73,60.29 184.76,58.26 186.98,58.26 188.01,57.24 210.34,57.24 221.65,45.92 221.65,42.71 221.3,42.36 221.3,39.49 v2(220.7,38.89) ; v2(162.53,84.34) 162.52,84.35 162.41,84.35
  BOTTOM w0.076: v2(162.53,84.34) 162.45,84.34 UH1.AF11
  BOTTOM w0.213: JDIMM2.149 218.32,39.81 219.24,38.89 v2(220.7,38.89)
DDR_B_CS#1: length 99.3
  IN5 w0.076: v2(163.46,81.8) 164.4,80.86 164.92,80.86 166.18,79.6 166.18,75.71 169.66,72.22 172.72,72.22
  IN5 w0.145: v2(224.07,39.58) 225.61,41.12 225.61,45.92 212.97,58.56 212.82,58.56 211.68,59.69 210.79,59.69 210.03,60.46 191.9,60.46 190.99,61.36 189.79,61.36 189.19,60.77 185.48,60.77 178.41,67.85 178.17,67.85 177.83,67.52 177.59,67.52 177.42,67.69 177.42,67.93 177.76,68.26 177.76,68.5 177.59,68.67 177.35,68.67 177.02,68.34 176.78,68.34 176.61,68.51 176.61,68.75 176.94,69.08 176.94,69.32 176.74,69.51 176.5,69.51 176.14,69.15 175.9,69.15 175.73,69.32 175.73,69.56 176.09,69.92 176.09,70.16 175.92,70.33 175.68,70.33 175.32,69.97 175.08,69.97 174.91,70.14 174.91,70.38 175.27,70.74 175.27,70.98 175.1,71.15 174.86,71.15 174.5,70.79 174.26,70.79 174.09,70.96 174.09,71.2 174.46,71.56 174.46,71.8 174.03,72.22 172.72,72.22
  BOTTOM w0.076: v2(163.46,81.8) 163.3,81.8 UH1.AE7
  BOTTOM w0.213: JDIMM2.157 220.32,42.02 221.02,41.33 222.05,41.33 223.8,39.58 v2(224.07,39.58)
DDR_B_D0: length 57.8
  IN1 w0.076: v2(165.07,74.45) 164.5,73.88 164.5,70.96
  IN1 w0.097: 164.5,70.96 164.5,70.07 164.39,69.96 163.73,69.96 163.62,69.85 163.62,69.69 163.73,69.57 164.39,69.57 164.5,69.46 164.5,69.3 164.39,69.19 163.73,69.19 163.62,69.07 163.62,68.91 163.73,68.8 164.39,68.8 164.5,68.69 164.5,68.53 164.39,68.41 163.73,68.41 163.62,68.3 163.62,68.14 163.73,68.03 164.39,68.03 164.5,67.92 164.5,67.76 164.39,67.64 163.73,67.64 163.62,67.53 163.62,67.37 163.73,67.26 164.39,67.26 164.5,67.14 164.5,66.97 164.41,66.87 163.79,66.87 163.68,66.76 163.68,66.6 163.79,66.48 164.33,66.48 164.49,66.32 164.49,66.19 164.39,66.09 163.77,66.09 163.66,65.98 163.66,65.82 163.77,65.7 164.33,65.7 164.49,65.55 164.49,65.41 164.39,65.32 163.77,65.32 163.66,65.21 163.66,65.05 163.77,64.93 164.33,64.93 164.5,64.76 164.5,64.54 164.39,64.43 164.22,64.43 164.12,64.33 164.12,64.14 164.22,64.04 164.39,64.04 164.5,63.93 164.5,54.59 178.41,40.68 v2(178.96,40.68)
  BOTTOM w0.076: UH1.AB1 165.56,78.17 165.56,74.94 v1(165.46,74.83) v2(165.07,74.45)
  BOTTOM w0.14: JDIMM2.3 179.83,41.05 179.45,40.68 v2(178.96,40.68)
DDR_B_D1: length 58.4
  IN1 w0.076: 163.81,72.74 163.81,74 v2(164.71,74.91)
  IN1 w0.097: v2(181.46,38.9) 179.76,38.9 164.44,54.22 164.44,54.23 164.2,54.46 164.2,63.51 163.23,64.48 163.23,70.54 163.35,70.65 164.09,70.65 164.2,70.76 164.2,70.92 164.09,71.04 163.35,71.04 163.23,71.15 163.23,71.31 163.35,71.42 164.09,71.42 164.2,71.54 164.2,71.7 164.09,71.81 163.35,71.81 163.23,71.92 163.23,72.08 163.35,72.2 164.09,72.2 164.2,72.31 164.2,72.47 164.09,72.58 163.96,72.58 163.81,72.74
  BOTTOM w0.076: 164.82,75.02 165.27,75.46 v1(165.27,76.16) 165.34,76.24 165.34,77.99 165.26,78.07 165.26,78.56 UH1.AB2
  BOTTOM w0.102: v2(164.71,74.91) 164.82,75.02
  BOTTOM w0.14: JDIMM2.7 180.83,42.03 180.58,41.78 180.58,39.32 180.84,39.07 181.29,39.07 v2(181.46,38.9)
DDR_B_D2: length 57.3
  IN1 w0.076: 166.49,68.97 166.49,72.45 166.72,72.69 166.72,73.95 165.87,74.8 165.87,78.96 v2(166.72,79.81)
  IN1 w0.097: v2(183.81,40.88) 183.71,40.78 183.05,40.78 183.05,40.8 181.78,42.07 180.47,42.07 177.74,44.8 177.74,44.96 177.98,45.19 177.98,45.35 177.87,45.47 177.71,45.47 177.47,45.23 177.31,45.23 177.2,45.34 177.2,45.5 177.43,45.74 177.43,45.9 177.32,46.01 177.16,46.01 176.92,45.78 176.76,45.78 176.6,45.94 176.6,46.1 176.87,46.37 176.87,46.53 176.76,46.64 176.6,46.64 176.33,46.37 176.17,46.37 176.05,46.48 176.05,46.64 176.32,46.91 176.32,47.07 176.21,47.19 176.05,47.19 175.78,46.92 175.62,46.92 175.51,47.03 175.51,47.19 175.78,47.46 175.78,47.62 175.66,47.73 175.5,47.73 175.24,47.46 175.08,47.46 174.96,47.58 174.96,47.74 175.23,48.01 175.23,48.17 175.12,48.28 174.96,48.28 174.69,48.01 174.53,48.01 174.42,48.12 174.42,48.28 174.68,48.55 174.68,48.71 172.73,50.66 172.73,51.42 169.04,55.12 168.28,55.12 167.27,56.13 167.27,56.59 166.49,57.37 166.49,68.97
  BOTTOM w0.076: UH1.AA4 v2(166.72,79.81)
  BOTTOM w0.14: v2(183.81,40.88) 183.91,40.88 184.33,41.3 JDIMM2.21
DDR_B_D3: length 58
  IN1 w0.076: v2(166.67,80.39) 166.64,80.39 165.71,79.46 165.71,74.73 166.56,73.88 166.56,72.76 166.19,72.39 166.19,69.27
  IN1 w0.097: v2(183.81,39.61) 183.18,40.24 183.02,40.24 182.57,39.78 182.41,39.78 182.29,39.9 182.29,40.06 182.75,40.51 182.75,40.67 181.65,41.77 180.34,41.77 173.78,48.33 173.78,48.49 174.01,48.72 174.01,48.88 173.9,48.99 173.74,48.99 173.51,48.76 173.35,48.76 173.24,48.88 173.24,49.04 173.47,49.26 173.47,49.42 173.35,49.54 173.19,49.54 172.97,49.31 172.81,49.31 172.43,49.68 172.43,51.3 168.92,54.82 167.3,54.82 166.19,55.93 166.19,69.27
  BOTTOM w0.076: v2(166.67,80.39) 166.61,80.44 166.53,80.43 166.31,80.59 UH1.AA5
  BOTTOM w0.14: v2(183.81,39.61) 183.65,39.77 183.63,39.77 183.38,40.02 183.38,40.04 183.33,40.1 JDIMM2.17
DDR_B_D4: length 57.8
  IN1 w0.076: v2(164.65,77) 165.01,76.65 165.01,75.91 164.33,75.23 164.33,74.86 162.86,73.38 162.86,71.84
  IN1 w0.097: 162.86,71.84 162.86,64.21 163.9,63.16 163.9,54.34 164.14,54.1 164.14,54.09 164.5,53.73 164.5,53.72 177.2,41.03 177.2,38.34 178.17,37.37 181.11,37.37 v2(181.44,37.7)
  BOTTOM w0.076: v2(164.65,77) 165.01,77.36 165.01,77.86 164.93,77.93 164.93,79.81 164.99,79.87 164.99,80.01 165.54,80.57 UH1.AB5
  BOTTOM w0.14: JDIMM2.8 181.08,37.33 v2(181.44,37.7)
DDR_B_D5: length 58.3
  IN1 w0.076: 162.56,71.55 162.56,73.32 164.03,74.79 164.03,75.49 164.19,75.66 164.19,75.91 v2(164.65,76.37)
  IN1 w0.097: v2(179.61,36.58) 179.13,37.06 178.04,37.06 176.89,38.22 176.89,40.91 164.06,53.74 164.06,53.75 163.84,53.97 163.84,53.98 163.6,54.21 163.6,61.1 163.49,61.21 162.67,61.21 162.56,61.33 162.56,61.49 162.67,61.6 163.49,61.6 163.6,61.71 163.6,61.87 163.49,61.98 162.67,61.98 162.56,62.1 162.56,62.26 162.67,62.37 163.49,62.37 163.6,62.48 163.6,62.84 162.56,63.89 162.56,71.55
  BOTTOM w0.076: UH1.AB4 165.49,80.14 165.1,79.74 165.1,78 165.17,77.93 165.17,76.89 v2(164.65,76.37)
  BOTTOM w0.14: JDIMM2.4 180.08,36.12 v2(179.61,36.58)
DDR_B_D6: length 57.6
  IN1 w0.076: v2(166.72,78.53) 166.04,77.84 166.04,74.87 166.89,74.02 166.89,72.14 166.79,72.03 166.79,68.67
  IN1 w0.097: 166.79,68.67 166.79,57.49 167.57,56.72 167.57,56.28 168.43,55.42 169.16,55.42 173.03,51.55 173.03,50.81 178.55,45.29 178.55,45.13 178.27,44.85 178.27,44.69 178.39,44.58 178.55,44.58 178.82,44.86 178.98,44.86 179.1,44.74 179.1,44.58 178.82,44.31 178.82,44.15 178.93,44.03 179.09,44.03 179.37,44.31 179.53,44.31 179.64,44.2 179.64,44.04 179.36,43.76 179.36,43.6 179.52,43.44 179.68,43.44 179.81,43.57 179.95,43.57 180.09,43.44 180.09,43.3 179.96,43.17 179.96,43.01 180.59,42.37 183.5,42.37 184.23,41.64 184.23,38.76 v2(183.8,38.33)
  BOTTOM w0.076: UH1.AA2 v2(166.72,78.53)
  BOTTOM w0.14: JDIMM2.20 184.08,36.46 184.25,36.64 184.25,37.88 v2(183.8,38.33)
DDR_B_D7: length 57.5
  IN1 w0.076: v2(166.72,77.89) 166.2,77.37 166.2,74.94 167.09,74.05 167.09,68.37
  IN1 w0.097: 167.09,68.37 167.09,57.62 167.87,56.84 167.87,56.42 168.57,55.72 169.29,55.72 173.33,51.67 173.33,50.95 181.62,42.67 183.64,42.67 184.54,41.77 184.54,36.32 184.38,36.16 182.98,36.16 182.8,36.35 182.8,36.8 182.98,36.98 183.69,36.98 v2(183.81,36.86)
  BOTTOM w0.076: UH1.AA1 v2(166.72,77.89)
  BOTTOM w0.14: v2(183.81,36.86) 183.08,36.13 JDIMM2.16
DDR_B_D8: length 55.7
  IN1 w0.076: 168.12,67.49 168.12,73.56 167.24,74.43 167.24,76.1 v2(166.72,76.62)
  IN1 w0.097: 168.12,67.49 168.12,58.98 171.58,55.52 171.74,55.52 172.16,55.93 172.32,55.93 172.43,55.82 172.43,55.66 172.02,55.24 172.02,55.08 172.13,54.97 172.29,54.97 172.7,55.38 172.86,55.38 172.97,55.27 172.97,55.11 172.56,54.7 172.56,54.54 172.68,54.42 172.84,54.42 173.25,54.84 173.41,54.84 173.63,54.62 173.63,54.46 173.48,54.31 173.48,54.17 173.62,54.04 173.75,54.04 173.9,54.18 174.06,54.18 183.21,45.04 183.21,44.31 183.45,44.08 184.17,44.08 186.16,42.09 186.16,41.17 185.87,40.88 v2(185.76,40.88)
  BOTTOM w0.076: UH1.V5 167.45,80.18 167.45,80.02 167.45,79.37 167.45,78.72 167.45,77.34 v2(166.72,76.62)
  BOTTOM w0.14: JDIMM2.25 185.33,41.22 185.66,40.88 v2(185.76,40.88)
DDR_B_D9: length 56.6
  IN1 w0.076: v2(167.6,75.2) 167.6,74.31 168.42,73.49 168.42,67.49
  IN1 w0.097: v2(185.77,39.61) 185.78,39.61 186.47,40.3 186.47,42.19 172.12,56.55 171.96,56.55 171.54,56.14 171.38,56.14 171.27,56.25 171.27,56.41 171.68,56.82 171.68,56.98 171.57,57.1 171.41,57.1 171,56.68 170.84,56.68 170.73,56.8 170.73,56.96 171.14,57.37 171.14,57.53 171.03,57.64 170.87,57.64 170.45,57.23 170.29,57.23 168.42,59.11 168.42,67.49
  BOTTOM w0.076: v2(167.6,75.2) 167.6,76.28 167.78,76.45 167.78,78.44 167.78,78.56 UH1.V2
  BOTTOM w0.14: JDIMM2.24 185.08,39.12 185.57,39.61 v2(185.77,39.61)
DDR_B_D10: length 55.1
  IN1 w0.076: v2(169.24,77.91) 168.81,77.47 168.81,76.14 171.36,73.6 171.36,67.49
  IN1 w0.097: v2(189.33,36.93) 190.48,38.07 190.48,42.7 189.14,44.03 188.66,44.03 188.14,44.56 188.14,44.67 185.31,47.49 185.21,47.49 178.22,54.48 178.22,54.64 178.29,54.72 178.29,54.88 178.18,54.99 178.02,54.99 177.94,54.92 177.78,54.92 177.67,55.03 177.67,55.19 177.75,55.27 177.75,55.43 177.64,55.54 177.48,55.54 177.4,55.46 177.24,55.46 177.12,55.57 177.12,55.73 177.2,55.81 177.2,55.97 177.09,56.09 176.93,56.09 176.85,56.01 176.69,56.01 176.58,56.12 176.58,56.28 176.66,56.36 176.66,56.52 171.36,61.82 171.36,67.49
  BOTTOM w0.076: UH1.U1 v2(169.24,77.91)
  BOTTOM w0.14: JDIMM2.42 189.57,36.68 v2(189.33,36.93)
DDR_B_D11: length 55.5
  IN1 w0.076: 171.06,67.49 171.06,73.66 168.55,76.17 168.55,77.85 v2(169.24,78.54)
  IN1 w0.097: 171.06,67.49 171.06,61.7 175.04,57.71 175.04,57.55 174.97,57.48 174.97,57.32 175.09,57.2 175.25,57.2 175.32,57.28 175.48,57.28 175.59,57.16 175.59,57 175.52,56.93 175.52,56.77 175.63,56.66 175.79,56.66 175.86,56.73 176.02,56.73 176.14,56.62 176.14,56.46 176.06,56.39 176.06,56.21 185.08,47.19 185.19,47.19 187.84,44.54 187.84,44.44 188.54,43.73 189.02,43.73 190.17,42.58 190.17,39.03 v2(189.33,38.2)
  BOTTOM w0.076: UH1.U2 v2(169.24,78.54)
  BOTTOM w0.14: v2(189.33,38.2) 188.86,37.73 188.86,35.75 188.57,35.47 JDIMM2.38
DDR_B_D12: length 56.3
  IN1 w0.076: 168.81,67.49 168.81,73.34 168.03,74.12 v2(168.03,74.77)
  IN1 w0.097: v2(185.77,38.34) 186.17,38.75 186.17,39.42 186.78,40.03 186.78,42.31 170.82,58.27 170.66,58.27 170.45,58.06 170.29,58.06 170.17,58.18 170.17,58.33 170.39,58.55 170.39,58.71 170.23,58.87 170.07,58.87 169.7,58.49 169.54,58.49 169.42,58.61 169.42,58.77 169.8,59.14 169.8,59.3 169.68,59.41 169.52,59.41 169.15,59.04 168.99,59.04 168.88,59.15 168.88,59.31 169.25,59.68 169.25,59.84 168.81,60.29 168.81,67.49
  BOTTOM w0.076: UH1.V1 168.03,78.16 v1(168.03,75.53) v2(168.03,74.77)
  BOTTOM w0.14: JDIMM2.29 186.33,41.81 186.48,41.66 186.48,38.94 185.88,38.34 v2(185.77,38.34)
DDR_B_D13: length 56.1
  IN1 w0.076: 167.82,67.64 167.82,73.62 166.77,74.68 166.77,75.42 166.76,75.42 166.76,75.72 166.77,75.72 v2(166.77,76.03)
  IN1 w0.097: v2(185.75,37.07) 185.69,37.07 185.27,37.49 185.27,42.55 184.04,43.78 183.32,43.78 182.91,44.19 182.91,44.91 174.87,52.95 174.71,52.95 174.55,52.79 174.41,52.79 174.28,52.93 174.28,53.07 174.44,53.22 174.44,53.38 174.32,53.5 174.16,53.5 173.75,53.08 173.59,53.08 167.82,58.86 167.82,67.64
  BOTTOM w0.076: UH1.V4 167.61,79.69 167.61,78.65 167.61,76.87 v2(166.77,76.03)
  BOTTOM w0.14: v2(185.75,37.07) 186.08,36.75 JDIMM2.28
DDR_B_D14: length 55.6
  IN1 w0.076: 170.51,72.34 170.51,73.62 168.17,75.97 168.17,79.39 v2(169.24,80.46)
  IN1 w0.097: 170.51,72.34 170.46,72.28 170.46,60.97 170.7,60.72 170.86,60.72 170.94,60.8 171.1,60.8 171.21,60.69 171.21,60.53 171.13,60.45 171.13,60.29 171.25,60.18 171.41,60.18 171.49,60.26 171.65,60.26 171.76,60.14 171.76,59.98 171.68,59.91 171.68,59.75 171.79,59.63 171.95,59.63 172.03,59.71 172.19,59.71 172.31,59.6 172.31,59.44 172.23,59.36 172.23,59.2 172.34,59.09 172.5,59.09 172.58,59.17 172.74,59.17 172.85,59.05 172.85,58.89 172.77,58.81 172.77,58.65 184.83,46.59 184.94,46.59 187.24,44.3 187.24,44.19 188.6,42.83 188.6,42.32 188.71,42.21 189,42.21 189.11,42.1 189.11,41.94 189,41.82 188.71,41.82 188.6,41.71 188.6,40.61 188.69,40.52 189.24,40.52 189.33,40.61 v2(189.33,40.74)
  BOTTOM w0.076: UH1.U5 v2(169.24,80.46)
  BOTTOM w0.14: v2(189.33,40.74) 188.95,40.74 188.32,41.36 JDIMM2.37
DDR_B_D15: length 55.6
  IN1 w0.076: v2(169.24,79.81) 168.36,78.93 168.36,76.12 170.76,73.73 170.76,67.49
  IN1 w0.097: 170.76,67.49 170.76,61.57 173.46,58.87 173.46,58.71 173.38,58.63 173.38,58.47 173.49,58.36 173.65,58.36 173.73,58.44 173.89,58.44 174,58.33 174,58.17 173.92,58.09 173.92,57.93 174.04,57.81 174.2,57.81 174.28,57.89 174.44,57.89 174.55,57.78 174.55,57.62 174.47,57.54 174.47,57.38 184.96,46.89 185.07,46.89 187.54,44.42 187.54,44.31 188.41,43.43 188.89,43.43 189.87,42.46 189.87,40 v2(189.33,39.47)
  BOTTOM w0.076: UH1.U4 v2(169.24,79.81)
  BOTTOM w0.14: v2(189.33,39.47) 189.54,39.47 189.78,39.7 189.78,41.55 189.32,42.01 JDIMM2.41
DDR_B_D16: length 68.7
  IN2 w0.076: v2(166.2,85.02) 165.85,84.67 165.85,84.2 166.04,84.02 166.44,84.02 166.6,83.86 166.6,82.84 166.73,82.72 166.73,82.04 166.09,81.4 166.09,74.97 167.45,73.61 167.45,72.53
  IN2 w0.097: 167.45,72.53 167.45,61.92 169.7,59.68 169.7,59.52 169.56,59.38 169.56,59.22 169.67,59.1 169.83,59.1 169.97,59.24 170.13,59.24 170.24,59.13 170.24,58.97 170.1,58.83 170.1,58.67 170.22,58.56 170.38,58.56 170.52,58.7 170.68,58.7 170.79,58.58 170.79,58.42 170.65,58.28 170.65,58.12 170.76,58.01 170.92,58.01 171.06,58.15 171.22,58.15 171.34,58.04 171.34,57.88 171.19,57.74 171.19,57.58 171.31,57.46 171.47,57.46 171.61,57.61 171.77,57.61 171.88,57.49 171.88,57.33 171.74,57.19 171.74,57.03 171.95,56.82 172.11,56.82 172.25,56.96 172.41,56.96 172.53,56.85 172.53,56.69 172.39,56.55 172.39,56.38 172.5,56.27 172.66,56.27 172.8,56.41 172.96,56.41 173.07,56.3 173.07,56.14 172.93,56 172.93,55.84 173.05,55.73 173.21,55.73 173.35,55.87 173.51,55.87 173.62,55.75 173.62,55.59 173.48,55.45 173.48,55.29 173.59,55.18 173.75,55.18 173.89,55.32 174.05,55.32 174.17,55.21 174.17,55.05 174.02,54.91 174.02,54.75 174.14,54.63 174.3,54.63 174.44,54.77 174.6,54.77 174.71,54.66 174.71,54.5 174.57,54.36 174.57,54.2 183.29,45.48 183.89,45.48 190.87,45.48 194.4,41.95 v2(194.4,41.29)
  BOTTOM w0.076: v2(166.2,85.02) 165.88,84.7 UH1.AA11
  BOTTOM w0.14: JDIMM2.63 194.83,41.64 194.48,41.29 v2(194.4,41.29)
DDR_B_D17: length 69.1
  IN2 w0.076: v2(166.21,84.37) 166.37,84.37 166.76,83.98 166.76,82.91 166.89,82.78 166.89,81.97 166.26,81.33 166.26,75.3 167.79,73.77 167.79,72.53
  IN2 w0.097: v2(194.4,37.22) 194.96,37.79 194.96,42.78 191.96,45.78 184.01,45.78 183.41,45.78 176.25,52.95 176.25,53.11 176.28,53.14 176.28,53.28 176.14,53.41 176.01,53.41 175.98,53.38 175.82,53.38 175.7,53.49 175.7,53.65 175.84,53.79 175.84,53.95 175.73,54.07 175.57,54.07 175.43,53.93 175.27,53.93 175.16,54.04 175.16,54.2 175.3,54.34 175.3,54.5 167.79,62.01 167.79,72.53
  BOTTOM w0.076: UH1.AA10 v2(166.21,84.37)
  BOTTOM w0.14: JDIMM2.62 194.57,37.04 v2(194.4,37.22)
DDR_B_D18: length 69.6
  IN2 w0.076: v2(165.29,85.02) 164.75,84.48 164.75,83.28 164.33,82.86 164.33,82.58 163.92,82.17 163.92,80.93 163.79,80.8 163.79,78.95 163.42,78.58 163.42,77.56 162.74,76.87 162.74,72.53
  IN2 w0.097: 162.74,72.53 162.74,71.69 162.85,71.57 162.88,71.57 163,71.46 163,71.3 162.88,71.19 162.85,71.19 162.74,71.07 162.74,70.91 162.85,70.8 162.88,70.8 163,70.69 163,70.53 162.88,70.41 162.85,70.41 162.74,70.3 162.74,70.14 162.85,70.03 162.88,70.03 163,69.92 163,69.76 162.88,69.64 162.85,69.64 162.74,69.53 162.74,69.37 162.85,69.26 162.88,69.26 163,69.14 163,68.98 162.88,68.87 162.85,68.87 162.74,68.76 162.74,68.6 162.85,68.48 162.88,68.48 163,68.37 163,68.21 162.88,68.1 162.85,68.1 162.74,67.98 162.74,61.58 182.44,41.88 189.36,41.88 189.74,41.5 189.74,39.08 v2(191.15,37.67)
  BOTTOM w0.076: UH1.AC11 v2(165.29,85.02)
  BOTTOM w0.14: v2(191.15,37.67) 190.72,37.67 190.57,37.53 JDIMM2.46
DDR_B_D19: length 69
  IN2 w0.076: 163.04,72.53 163.04,75.78 163.59,76.33 163.59,78.51 163.62,78.54 164.72,79.64 164.72,83.02 164.91,83.21 164.91,83.99 v2(165.29,84.37)
  IN2 w0.097: 163.04,72.53 163.3,72.27 163.3,62.57 163.41,62.46 163.95,62.46 164.07,62.35 164.07,62.19 163.95,62.07 163.41,62.07 163.3,61.96 163.3,61.72 163.39,61.62 163.97,61.62 164.07,61.53 164.07,60.68 182.56,42.18 189.54,42.18 190.04,41.69 190.04,39.87 190.97,38.94 v2(191.15,38.94)
  BOTTOM w0.076: v2(165.29,84.37) 164.97,84.05 UH1.AC10
  BOTTOM w0.14: JDIMM2.50 191.57,36.5 191.73,36.66 191.73,37.95 191.72,37.96 191.72,38.47 191.25,38.94 v2(191.15,38.94)
DDR_B_D20: length 69.5
  IN2 w0.076: v2(166.21,82.42) 166.21,82.03 165.88,81.69 165.88,81.65 165.76,81.54 165.76,74.79 166.77,73.78 166.77,72.53
  IN2 w0.097: 166.77,72.53 166.77,71.67 166.66,71.55 166.43,71.55 166.32,71.44 166.32,71.28 166.43,71.17 166.66,71.17 166.77,71.05 166.77,70.89 166.66,70.78 166.43,70.78 166.32,70.67 166.32,70.51 166.43,70.39 166.66,70.39 166.77,70.28 166.77,70.12 166.66,70.01 166.43,70.01 166.32,69.89 166.32,69.73 166.43,69.62 166.66,69.62 166.77,69.51 166.77,69.35 166.66,69.24 166.43,69.24 166.32,69.12 166.32,68.96 166.43,68.85 166.66,68.85 166.77,68.74 166.77,68.58 166.66,68.46 166.43,68.46 166.32,68.35 166.32,68.19 166.43,68.08 166.66,68.08 166.77,67.96 166.77,67.8 166.66,67.69 166.43,67.69 166.32,67.58 166.32,67.42 166.43,67.31 166.66,67.31 166.77,67.19 166.77,67.03 166.66,66.92 166.43,66.92 166.32,66.81 166.32,61.61 183.04,44.88 183.45,44.88 190.6,44.88 193.55,41.93 193.55,40.35 193.79,40.11 193.79,39.31 194.4,38.69 v2(194.42,38.69)
  BOTTOM w0.076: UH1.AA7 v2(166.21,82.42)
  BOTTOM w0.14: JDIMM2.58 193.57,36.06 193.82,36.3 193.82,37.22 194.03,37.43 194.03,38.3 v2(194.42,38.69)
DDR_B_D21: length 69.4
  IN2 w0.076: 167.11,72.53 167.11,73.68 165.93,74.86 165.93,81.47 166.56,82.11 166.56,82.62 v2(166.18,83)
  IN2 w0.097: v2(194.4,40.02) 194.37,40.02 193.89,40.49 193.89,42.01 190.72,45.18 183.77,45.18 183.16,45.18 169,59.34 169,59.5 169.14,59.64 169.14,59.8 169.03,59.92 168.87,59.92 168.73,59.78 168.57,59.78 168.41,59.94 168.41,60.1 168.55,60.24 168.55,60.4 168.44,60.51 168.28,60.51 168.14,60.37 167.98,60.37 167.87,60.48 167.87,60.64 168.01,60.78 168.01,60.94 167.89,61.06 167.73,61.06 167.59,60.91 167.43,60.91 167.11,61.24 167.11,61.92 167,62.03 166.78,62.03 166.66,62.14 166.66,62.3 166.78,62.42 167,62.42 167.11,62.53 167.11,62.81 167,62.92 166.73,62.92 166.61,63.03 166.61,63.19 166.73,63.31 167,63.31 167.11,63.42 167.11,63.58 167,63.69 166.73,63.69 166.61,63.81 166.61,63.97 166.73,64.08 167,64.08 167.11,64.19 167.11,64.35 167,64.47 166.73,64.47 166.61,64.58 166.61,64.74 166.73,64.85 167,64.85 167.11,64.96 167.11,65.12 167,65.24 166.73,65.24 166.61,65.35 166.61,65.51 166.73,65.62 167,65.62 167.11,65.74 167.11,65.9 167,66.01 166.73,66.01 166.61,66.12 166.61,66.28 166.73,66.4 167,66.4 167.11,66.51 167.11,72.53
  BOTTOM w0.076: UH1.AA8 v2(166.18,83)
  BOTTOM w0.14: JDIMM2.59 193.83,40.4 194.21,40.02 v2(194.4,40.02)
DDR_B_D22: length 69.1
  IN2 w0.076: v2(165.27,83.07) 165.27,82.96 164.89,82.58 164.89,79.57 163.75,78.44 163.75,76.26 163.62,76.12 163.62,72.53
  IN2 w0.097: 163.62,72.53 163.62,66.12 163.73,66.01 164.25,66.01 164.37,65.9 164.37,65.74 164.25,65.62 163.73,65.62 163.62,65.51 163.62,65.35 163.73,65.24 164.25,65.24 164.37,65.13 164.37,64.97 164.25,64.85 163.73,64.85 163.62,64.74 163.62,64.58 163.73,64.47 164.25,64.47 164.37,64.35 164.37,64.19 164.25,64.08 163.73,64.08 163.62,63.97 163.62,63.81 163.73,63.69 164.25,63.69 164.37,63.58 164.37,63.42 164.25,63.31 163.73,63.31 163.62,63.19 163.62,63.03 163.73,62.92 164.25,62.92 164.37,62.81 164.37,60.8 182.68,42.48 189.72,42.48 190.34,41.87 190.34,40.39 191.13,39.6 v2(191.13,39.6)
  BOTTOM w0.076: UH1.AC8 v2(165.27,83.07)
  BOTTOM w0.14: JDIMM2.45 190.32,42.1 190.56,41.86 190.56,40.16 v2(191.13,39.6)
DDR_B_D23: length 69.1
  IN2 w0.076: 164.57,72.53 163.92,73.18 163.92,78.37 163.95,78.4 165.05,79.5 165.05,82.21 v2(165.27,82.42)
  IN2 w0.097: 164.57,72.53 164.67,72.44 164.67,71.6 164.55,71.49 164.03,71.49 163.91,71.38 163.91,71.22 164.03,71.11 164.55,71.11 164.67,70.99 164.67,70.83 164.55,70.72 164.03,70.72 163.91,70.61 163.91,70.45 164.03,70.33 164.55,70.33 164.67,70.22 164.67,70.06 164.55,69.95 164.03,69.95 163.91,69.83 163.91,69.67 164.03,69.56 164.55,69.56 164.67,69.45 164.67,69.29 164.55,69.17 164.03,69.17 163.91,69.06 163.91,68.9 164.03,68.79 164.55,68.79 164.67,68.68 164.67,68.52 164.55,68.4 164.03,68.4 163.91,68.29 163.91,68.13 164.03,68.02 164.55,68.02 164.67,67.9 164.67,67.74 164.55,67.63 164.03,67.63 163.91,67.52 163.91,67.36 164.03,67.24 164.55,67.24 164.67,67.13 164.67,66.97 164.55,66.86 164.03,66.86 163.91,66.75 163.91,66.59 164.03,66.47 164.55,66.47 164.67,66.36 164.67,60.93 182.81,42.78 189.85,42.78 190.64,41.99 190.64,41.36 v2(191.13,40.86)
  BOTTOM w0.076: UH1.AC7 v2(165.27,82.42)
  BOTTOM w0.14: JDIMM2.49 191.32,42.07 191.58,41.81 191.58,41.18 191.27,40.86 v2(191.13,40.86)
DDR_B_D24: length 75.5
  IN2 w0.076: 170.01,72.53 170.01,72.75 170.24,72.99 170.24,73.89 170.16,73.98 169.48,73.98 169.39,74.07 169.39,74.2 169.48,74.29 170.16,74.29 170.24,74.38 170.24,74.55 169.68,75.12 169.55,75.12 168.97,74.54 168.86,74.54 168.76,74.65 168.76,74.76 169.33,75.34 169.33,75.46 169.25,75.55 169.12,75.55 168.51,74.95 168.39,74.95 168.3,75.04 168.3,75.16 168.9,75.77 168.9,75.89 168.81,75.98 168.69,75.98 168.08,75.38 167.96,75.38 167.87,75.47 167.87,75.59 168.47,76.2 168.47,76.32 168.38,76.41 168.26,76.41 167.84,76 167.72,76 167.63,76.09 167.63,76.22 168.04,76.63 168.04,76.76 167.5,77.3 167.5,82.44 168.04,82.97 v2(168.04,83.07)
  IN2 w0.097: 170.01,72.53 170.01,71.89 169.2,71.08 169.2,64.84 169.32,64.72 170,64.72 170.11,64.61 170.11,64.45 170,64.34 169.32,64.34 169.2,64.23 169.2,64.07 169.32,63.95 170,63.95 170.11,63.84 170.11,63.68 170,63.57 169.32,63.57 169.2,63.45 169.2,62.48 184.57,47.11 193.72,47.11 193.9,46.94 193.9,46.78 193.65,46.52 193.65,46.39 193.78,46.25 193.92,46.25 194.17,46.5 194.33,46.5 194.45,46.39 194.45,46.23 194.19,45.98 194.19,45.84 194.33,45.7 194.47,45.7 194.72,45.96 194.88,45.96 196.29,44.54 196.29,43.23 196.51,43.02 v2(196.51,41.43)
  BOTTOM w0.076: UH1.W8 v2(168.04,83.07)
  BOTTOM w0.14: v2(196.51,41.43) 196.83,41.75 JDIMM2.71
DDR_B_D25: length 75.7
  IN2 w0.076: 170.41,72.53 170.41,74.73 167.74,77.39 167.74,82.13 v2(168.04,82.42)
  IN2 w0.097: v2(196.51,40.16) 196.95,40.6 196.95,43.72 196.81,43.86 196.81,44.46 193.85,47.41 184.69,47.41 170.41,61.7 170.41,64.92 170.3,65.03 169.62,65.03 169.5,65.15 169.5,65.31 169.62,65.42 170.3,65.42 170.41,65.53 170.41,65.69 170.3,65.81 169.62,65.81 169.5,65.92 169.5,66.08 169.62,66.19 170.3,66.19 170.41,66.3 170.41,66.46 170.3,66.58 169.62,66.58 169.5,66.69 169.5,66.85 169.62,66.96 170.3,66.96 170.41,67.08 170.41,67.24 170.3,67.35 169.62,67.35 169.5,67.46 169.5,67.62 169.62,67.74 170.3,67.74 170.41,67.85 170.41,68.05 170.31,68.14 169.69,68.14 169.57,68.26 169.57,68.42 169.69,68.53 170.24,68.53 170.39,68.68 170.39,68.82 170.3,68.91 169.69,68.91 169.57,69.03 169.57,69.19 169.69,69.3 170.24,69.3 170.39,69.45 170.39,69.59 170.3,69.69 169.69,69.69 169.57,69.8 169.57,69.96 169.69,70.07 170.24,70.07 170.39,70.23 170.39,70.36 170.3,70.46 169.69,70.46 169.57,70.57 169.57,70.73 169.69,70.85 170.24,70.85 170.41,71.01 170.41,71.17 170.22,71.36 170.22,71.6 170.41,71.79 170.41,72.53
  BOTTOM w0.076: UH1.W7 v2(168.04,82.42)
  BOTTOM w0.14: v2(196.51,40.16) 196.08,40.16 195.83,40.41 JDIMM2.67
DDR_B_D26: length 76.6
  IN2 w0.076: v2(168.95,84.37) 169.32,84 169.32,82.83 169.76,82.38 169.76,77.53 173.32,73.97 173.32,73.36 172.66,72.7 172.66,72.53
  IN2 w0.097: v2(200.85,39.43) 201.63,40.21 201.63,40.67 201.63,40.68 201.63,41.05 201.76,41.18 201.87,41.18 201.97,41.28 201.97,41.47 201.87,41.57 201.76,41.57 201.65,41.68 201.65,41.84 201.76,41.95 202.35,41.95 202.46,42.07 202.46,42.23 202.35,42.34 201.76,42.34 201.65,42.45 201.65,42.61 201.76,42.73 202.35,42.73 202.46,42.84 202.46,43 202.35,43.11 201.76,43.11 201.65,43.23 201.65,43.39 201.76,43.5 202.35,43.5 202.46,43.61 202.46,43.77 202.35,43.88 201.76,43.88 201.65,44 201.65,45.21 197.2,49.66 185.62,49.66 172.66,62.63 172.66,72.53
  BOTTOM w0.076: UH1.V10 v2(168.95,84.37)
  BOTTOM w0.14: v2(200.85,39.43) 199.86,38.44 199.86,37.17 199.08,36.39 JDIMM2.80
DDR_B_D27: length 76.2
  IN2 w0.076: v2(168.95,85.02) 169.48,84.49 169.48,83 169.93,82.55 169.93,77.6 173.48,74.04 173.48,73.29 173.04,72.85 173.04,72.53
  IN2 w0.097: 173.04,72.53 173.04,62.66 185.75,49.96 197.32,49.96 202.83,44.45 202.83,41.55 202.72,41.44 202.46,41.44 202.35,41.33 202.35,41.17 202.46,41.05 202.72,41.05 202.83,40.94 202.83,40.14 v2(200.85,38.16)
  BOTTOM w0.076: UH1.V11 v2(168.95,85.02)
  BOTTOM w0.14: JDIMM2.83 199.83,42.02 200.04,41.81 200.98,41.81 201.03,41.76 201.05,41.76 201.3,41.52 201.3,41.49 201.33,41.46 201.33,38.64 v2(200.85,38.16)
DDR_B_D28: length 76
  IN2 w0.076: v2(168.06,85.06) 167.49,84.49 167.49,82.97 167.17,82.65 167.17,75.77 166.9,75.51 166.9,75.03 168.56,73.38 168.56,72.53
  IN2 w0.097: 168.56,72.53 168.56,62.27 177.01,53.82 177.01,53.22 183.71,46.52 184.32,46.52 184.32,46.52 192.27,46.52 195.7,43.09 195.7,37.31 195.81,37.2 196.2,37.2 196.32,37.08 196.32,36.92 196.2,36.81 195.81,36.81 195.7,36.7 195.7,36.47 195.81,36.36 196.14,36.36 196.25,36.25 196.25,36.09 196.14,35.97 195.81,35.97 195.7,35.86 195.7,35.5 195.79,35.41 196.54,35.41 196.64,35.5 196.64,37.52 196.54,37.62 v2(196.38,37.62)
  BOTTOM w0.076: UH1.W11 167.7,84.7 v2(168.06,85.06)
  BOTTOM w0.14: v2(196.38,37.62) 195.57,36.81 JDIMM2.66
DDR_B_D29: length 76.1
  IN2 w0.076: 168.9,72.74 168.9,72.81 168.9,72.82 168.9,73.29 167.07,75.12 167.07,75.44 167.33,75.71 167.33,82.58 167.67,82.92 167.67,84 v2(168.04,84.37)
  IN2 w0.097: 168.9,72.74 168.9,72.49 169.02,72.38 169.46,72.38 169.57,72.27 169.57,72.11 169.46,71.99 169.02,71.99 168.9,71.88 168.9,62.35 177.84,53.41 177.84,53.25 177.7,53.11 177.7,52.95 177.82,52.84 177.98,52.84 178.12,52.98 178.28,52.98 178.39,52.87 178.39,52.71 178.25,52.57 178.25,52.41 178.36,52.29 178.52,52.29 178.66,52.43 178.82,52.43 178.94,52.32 178.94,52.16 178.8,52.02 178.8,51.86 178.91,51.75 179.07,51.75 179.21,51.89 179.37,51.89 179.48,51.77 179.48,51.61 179.34,51.47 179.34,51.31 179.45,51.2 179.61,51.2 179.76,51.34 179.92,51.34 180.03,51.23 180.03,51.07 179.89,50.93 179.89,50.77 180,50.65 180.16,50.65 180.3,50.79 180.46,50.79 180.7,50.55 180.7,50.39 180.56,50.25 180.56,50.09 180.68,49.98 180.84,49.98 180.98,50.12 181.14,50.12 181.25,50.01 181.25,49.85 181.11,49.71 181.11,49.55 181.22,49.43 181.38,49.43 181.52,49.57 181.68,49.57 181.8,49.46 181.8,49.3 181.66,49.16 181.66,49 181.77,48.89 181.93,48.89 182.07,49.03 182.23,49.03 182.34,48.91 182.34,48.75 182.2,48.61 182.2,48.45 182.31,48.34 182.47,48.34 182.62,48.48 182.78,48.48 182.89,48.37 182.89,48.21 182.75,48.07 182.75,47.91 182.86,47.79 183.02,47.79 183.16,47.93 183.32,47.93 183.43,47.82 183.43,47.66 183.29,47.52 183.29,47.36 183.41,47.25 183.57,47.25 183.71,47.39 183.87,47.39 184.44,46.81 192.77,46.81 194.22,45.37 194.93,45.37 196,44.3 196,39.28 v2(196.38,38.89)
  BOTTOM w0.076: UH1.W10 v2(168.04,84.37)
  BOTTOM w0.14: v2(196.38,38.89) 196.55,38.89 197.02,38.42 197.02,37.77 196.91,37.67 196.91,37.42 196.6,37.11 196.59,37.11 196.57,37.1 JDIMM2.70
DDR_B_D30: length 75.5
  IN2 w0.076: v2(168.95,82.42) 168.82,82.29 168.82,77.01 172.06,73.78 172.06,72.53
  IN2 w0.097: 172.06,72.53 172.06,62.38 185.37,49.06 194.99,49.06 195.98,48.07 196.14,48.07 196.49,48.42 196.65,48.42 196.77,48.31 196.77,48.15 196.42,47.8 196.42,47.64 196.53,47.52 196.69,47.52 197.04,47.87 197.2,47.87 197.31,47.76 197.31,47.6 196.96,47.25 196.96,47.09 197.08,46.98 197.24,46.98 197.59,47.33 197.75,47.33 197.86,47.21 197.86,47.05 197.51,46.7 197.51,46.54 197.62,46.43 197.78,46.43 198.13,46.78 198.29,46.78 198.41,46.67 198.41,46.51 198.06,46.16 198.06,46 198.17,45.88 198.33,45.88 198.68,46.23 198.84,46.23 198.95,46.12 198.95,45.96 198.6,45.61 198.6,45.45 198.72,45.34 198.88,45.34 199.22,45.69 199.38,45.69 199.57,45.5 199.57,45.34 199.22,44.99 199.22,44.83 199.33,44.72 199.49,44.72 199.84,45.07 200,45.07 200.37,44.7 200.37,37.38 v2(200.85,36.89)
  BOTTOM w0.076: UH1.V7 v2(168.95,82.42)
  BOTTOM w0.14: JDIMM2.84 200.08,36.12 v2(200.85,36.89)
DDR_B_D31: length 76.1
  IN2 w0.076: v2(168.95,83.07) 168.95,82.94 169.6,82.3 169.6,77.41 173.12,73.89 173.12,73.54 172.36,72.78 172.36,72.53
  IN2 w0.097: v2(200.85,40.7) 201.24,40.7 201.33,40.8 201.33,41.77 201.22,41.89 200.88,41.89 200.76,42 200.76,42.16 200.88,42.27 201.22,42.27 201.33,42.38 201.33,42.61 201.22,42.72 200.78,42.72 200.67,42.83 200.67,42.99 200.78,43.11 201.22,43.11 201.33,43.22 201.33,43.38 201.22,43.49 200.78,43.49 200.67,43.61 200.67,43.77 200.78,43.88 201.22,43.88 201.33,43.99 201.33,44.43 201.14,44.63 201.14,44.79 201.31,44.96 201.31,45.12 201.2,45.24 201.04,45.24 200.86,45.06 200.7,45.06 200.59,45.17 200.59,45.33 200.77,45.51 200.77,45.67 200.65,45.78 200.49,45.78 200.32,45.6 200.16,45.6 200.04,45.72 200.04,45.88 200.22,46.06 200.22,46.22 200.11,46.33 199.95,46.33 199.77,46.15 199.61,46.15 199.4,46.36 199.4,46.52 199.57,46.7 199.57,46.86 199.46,46.98 199.3,46.98 199.12,46.8 198.96,46.8 198.85,46.91 198.85,47.07 199.03,47.25 199.03,47.41 198.91,47.52 198.75,47.52 198.58,47.34 198.42,47.34 198.3,47.46 198.3,47.62 198.48,47.79 198.48,47.95 198.37,48.07 198.21,48.07 198.03,47.89 197.87,47.89 197.76,48 197.76,48.16 197.94,48.34 197.94,48.5 197.82,48.61 197.66,48.61 197.48,48.44 197.32,48.44 197.21,48.55 197.21,48.71 197.39,48.89 197.39,49.05 197.28,49.16 197.12,49.16 196.94,48.98 196.78,48.98 196.4,49.36 185.5,49.36 172.36,62.5 172.36,72.53
  BOTTOM w0.076: UH1.V8 v2(168.95,83.07)
  BOTTOM w0.14: v2(200.85,40.7) 200.85,40.7 199.59,40.7 198.83,41.46 JDIMM2.79
DDR_B_D32: length 91.7
  IN1 w0.076: 172.69,68.34 172.69,72.97 171.03,74.62 v2(171.03,75.43)
  IN1 w0.097: v2(226.28,38.42) 226.28,38.47 225.87,38.87 225.87,39.47 221.88,43.47 206.45,43.47 205.9,42.92 203.36,42.92 202.8,43.48 202.57,43.48 202.46,43.37 202.46,43.03 202.35,42.92 202.19,42.92 202.07,43.03 202.07,43.37 201.96,43.48 201.8,43.48 201.69,43.37 201.69,43.03 201.57,42.92 201.41,42.92 201.3,43.03 201.3,43.37 201.19,43.48 201.03,43.48 200.91,43.37 200.91,43.03 200.8,42.92 200.64,42.92 200.53,43.03 200.53,43.37 200.42,43.48 200.26,43.48 200.14,43.37 200.14,43.03 200.03,42.92 199.87,42.92 199.76,43.03 199.76,43.37 199.64,43.48 199.48,43.48 199.37,43.37 199.37,43.03 199.26,42.92 199.1,42.92 198.98,43.03 198.98,43.37 198.87,43.48 194.14,43.48 194.07,43.42 193.63,43.42 193.51,43.54 191.96,43.54 191.4,44.1 191.39,44.1 172.69,62.8 172.69,68.34
  BOTTOM w0.076: v2(171.03,75.43) 171.03,75.99 170.59,76.43 170.59,77.06 170.35,77.3 170.35,77.94 170.29,78 170.29,78.56 UH1.R2
  BOTTOM w0.14: v2(226.28,38.42) 225.65,39.04 225.65,39.69 223.32,42.02 JDIMM2.169
DDR_B_D33: length 91.4
  IN1 w0.076: 174.5,69.85 174.47,69.87 174.47,73.37 170.97,76.88 170.97,79.52 171.75,80.31 v2(171.75,80.46)
  IN1 w0.097: v2(229.01,36.82) 227.91,37.91 227.91,41.2 226.97,42.15 226.97,43 226.86,43.11 226.77,43.11 226.67,43.21 226.67,43.4 226.77,43.5 226.86,43.5 226.97,43.61 226.97,44.59 225.31,46.24 192.01,46.24 174.63,63.62 174.63,69.71 174.5,69.85
  BOTTOM w0.076: UH1.P5 v2(171.75,80.46)
  BOTTOM w0.14: JDIMM2.186 227.58,35.9 228.5,36.82 v2(229.01,36.82)
DDR_B_D34: length 91.2
  IN1 w0.076: v2(170.13,76.33) 170.13,75.29 172.39,73.03 172.39,68.35
  IN1 w0.097: v2(224.08,36.38) 224.92,36.38 225.57,37.03 225.57,39.33 222.28,42.62 198.62,42.62 198.51,42.73 198.51,43 198.4,43.12 198.24,43.12 198.12,43 198.12,42.73 198.01,42.62 197.85,42.62 197.74,42.73 197.74,43 197.62,43.12 197.46,43.12 197.35,43 197.35,42.73 197.24,42.62 197.08,42.62 196.97,42.73 196.97,43 196.85,43.12 196.69,43.12 196.58,43 196.58,42.73 196.47,42.62 196.31,42.62 196.19,42.73 196.19,43 196.08,43.12 195.92,43.12 195.81,43 195.81,42.73 195.69,42.62 195.53,42.62 195.42,42.73 195.42,43 195.31,43.12 195.15,43.12 195.04,43 195.04,42.73 194.92,42.62 194.76,42.62 194.65,42.73 194.65,43 194.54,43.12 193.51,43.12 193.39,43.24 191.83,43.24 191.67,43.4 191.66,43.4 172.39,62.67 172.39,68.35
  BOTTOM w0.076: UH1.R4 170.28,79.84 170.28,78.98 170.13,78.83 170.13,76.33 v2(170.13,76.33)
  BOTTOM w0.14: JDIMM2.170 223.58,35.87 v2(224.08,36.38)
DDR_B_D35: length 91.2
  IN1 w0.076: v2(171.75,79.81) 171.13,79.19 171.13,76.97 174.77,73.33 174.77,70.23 174.83,70.17
  IN1 w0.097: 174.83,70.17 174.93,70.07 174.93,63.74 192.13,46.54 225.44,46.54 227.31,44.68 227.31,44.05 227.42,43.93 227.65,43.93 227.75,43.84 227.75,43.64 227.65,43.55 227.42,43.55 227.31,43.43 227.31,42.24 228.21,41.33 228.21,38.87 v2(229,38.09)
  BOTTOM w0.076: UH1.P4 v2(171.75,79.81)
  BOTTOM w0.14: v2(229,38.09) 228.73,38.09 226.58,35.94 JDIMM2.182
DDR_B_D36: length 91.8
  IN1 w0.076: 172.09,68.35 172.09,73.1 169.68,75.5 v2(169.68,76.78)
  IN1 w0.097: 172.09,68.35 172.09,62.54 191.67,42.95 191.69,42.95 191.71,42.94 193.07,42.94 193.3,42.7 193.3,42.43 193.41,42.32 193.57,42.32 193.69,42.43 193.69,42.7 193.8,42.82 193.96,42.82 194.07,42.7 194.07,42.43 194.19,42.32 207.19,42.32 207.3,42.21 207.3,41.92 207.42,41.81 207.58,41.81 207.69,41.92 207.69,42.21 207.8,42.32 207.96,42.32 208.07,42.21 208.07,41.92 208.19,41.81 208.35,41.81 208.46,41.92 208.46,42.21 208.57,42.32 208.73,42.32 208.85,42.21 208.85,41.92 208.96,41.81 209.12,41.81 209.23,41.92 209.23,42.21 209.35,42.32 209.74,42.32 209.86,42.21 209.86,41.92 209.97,41.81 210.13,41.81 210.24,41.92 210.24,42.21 210.35,42.32 210.51,42.32 210.63,42.21 210.63,41.92 210.74,41.81 210.9,41.81 211.01,41.92 211.01,42.21 211.13,42.32 222.16,42.32 225.08,39.39 225.08,37.46 225.16,37.38 v2(225.16,37.3)
  BOTTOM w0.076: UH1.R5 169.96,80.18 169.96,77.32 169.68,77.04 v2(169.68,76.78)
  BOTTOM w0.14: JDIMM2.174 224.58,35.61 225.16,36.2 v2(225.16,37.3)
DDR_B_D37: length 91.3
  IN1 w0.076: v2(171.75,78.51) 171.72,78.51 171.3,78.08 171.3,77.06 175.03,73.32 175.03,70.45 175.07,70.41
  IN1 w0.097: v2(229,39.36) 228.51,39.84 228.51,41.45 228.07,41.9 228.07,42.38 228.18,42.49 228.84,42.49 228.96,42.6 228.96,42.76 228.84,42.88 228.18,42.88 228.07,42.99 228.07,43.15 228.18,43.26 228.84,43.26 228.96,43.37 228.96,43.53 228.84,43.65 228.18,43.65 228.07,43.76 228.07,44.64 225.82,46.89 192.21,46.89 175.23,63.87 175.23,70.25 175.07,70.41
  BOTTOM w0.076: UH1.P2 v2(171.75,78.51)
  BOTTOM w0.14: JDIMM2.183 226.83,42.09 227.13,41.79 227.41,41.79 227.73,41.47 227.73,41.27 227.94,41.05 227.94,40.14 228.73,39.36 v2(229,39.36)
DDR_B_D38: length 91.9
  IN1 w0.076: 172.99,68.33 172.99,72.9 171.35,74.54 171.35,74.89 v2(171.46,75)
  IN1 w0.097: v2(226.28,39.69) 226.13,39.69 222.05,43.76 208.34,43.76 208.22,43.89 208.22,44.48 208.1,44.6 207.94,44.6 207.83,44.48 207.83,43.89 207.72,43.78 206.34,43.78 205.78,43.22 203.48,43.22 202.92,43.78 199.4,43.78 199.28,43.89 199.28,44.48 199.17,44.6 199.01,44.6 198.9,44.48 198.9,43.89 198.79,43.78 198.63,43.78 198.51,43.89 198.51,44.48 198.4,44.6 198.24,44.6 198.13,44.48 198.13,43.89 198.01,43.78 196.49,43.78 196.38,43.89 196.38,44.43 196.27,44.54 196.11,44.54 196,44.43 196,43.89 195.88,43.78 194.53,43.78 194.43,43.88 194.43,44.48 194.32,44.6 194.16,44.6 194.05,44.48 194.05,43.81 193.95,43.72 193.76,43.72 193.66,43.81 193.66,44.48 193.55,44.6 193.39,44.6 193.27,44.48 193.27,43.94 193.18,43.84 192.08,43.84 172.99,62.93 172.99,68.33
  BOTTOM w0.076: UH1.R1 170.57,77.49 170.86,77.21 170.86,76.55 171.44,75.97 171.44,75.02 v2(171.46,75)
  BOTTOM w0.14: v2(226.28,39.69) 224.32,41.64 JDIMM2.173
DDR_B_D39: length 91.1
  IN1 w0.076: v2(171.75,77.87) 171.75,76.85 175.32,73.28
  IN1 w0.097: v2(229,40.63) 229.23,40.63 229.46,40.86 229.46,43.67 228.58,44.55 228.58,44.71 228.74,44.87 228.74,45.03 228.63,45.14 228.47,45.14 228.31,44.99 228.15,44.99 228.04,45.1 228.04,45.26 228.19,45.41 228.19,45.58 228.08,45.69 227.92,45.69 227.76,45.53 227.6,45.53 227.49,45.64 227.49,45.8 227.65,45.96 227.65,46.12 227.53,46.23 227.37,46.23 227.22,46.08 227.06,46.08 226.94,46.19 226.94,46.35 227.1,46.51 227.1,46.67 226.99,46.78 226.83,46.78 226.67,46.62 226.51,46.62 226.4,46.74 226.4,46.9 226.55,47.05 226.55,47.21 226.44,47.33 226.28,47.33 226.12,47.17 225.96,47.17 225.94,47.19 225.35,47.19 225.23,47.3 225.23,47.54 225.12,47.65 224.96,47.65 224.85,47.54 224.85,47.3 224.74,47.19 224.58,47.19 224.46,47.3 224.46,47.54 224.35,47.65 224.19,47.65 224.08,47.54 224.08,47.3 223.96,47.19 223.8,47.19 223.69,47.3 223.69,47.54 223.58,47.65 223.42,47.65 223.3,47.54 223.3,47.3 223.19,47.19 223.03,47.19 222.92,47.3 222.92,47.54 222.81,47.65 222.65,47.65 222.53,47.54 222.53,47.3 222.42,47.19 222.14,47.19 222.03,47.3 222.03,47.54 221.91,47.65 221.75,47.65 221.64,47.54 221.64,47.3 221.53,47.19 192.33,47.19 175.53,63.99 175.53,70.46 175.32,70.67 175.32,73.28
  BOTTOM w0.076: UH1.P1 v2(171.75,77.87)
  BOTTOM w0.14: JDIMM2.187 227.83,41.86 228.04,41.64 228.04,41.3 228.19,41.15 228.19,41.12 228.68,40.63 v2(229,40.63)
DDR_B_D40: length 98.4
  IN1 w0.076: 175.69,75.12 174.3,76.51 v2(173.1,76.51)
  IN1 w0.097: 175.69,75.12 176.86,73.95 176.86,64.54 192.01,49.4 203.61,49.4 204.44,48.57 209.31,48.57 209.42,48.68 209.42,49.28 209.54,49.4 209.7,49.4 209.81,49.28 209.81,48.68 209.92,48.57 210.08,48.57 210.2,48.68 210.2,49.28 210.31,49.4 210.47,49.4 210.58,49.28 210.58,48.68 210.7,48.57 210.86,48.57 210.97,48.68 210.97,49.28 211.08,49.4 211.24,49.4 211.36,49.28 211.36,48.68 211.47,48.57 211.63,48.57 211.74,48.68 211.74,49.28 211.85,49.4 212.01,49.4 212.13,49.28 212.13,48.68 212.24,48.57 212.4,48.57 212.51,48.68 212.51,49.28 212.63,49.4 212.79,49.4 212.9,49.28 212.9,48.68 213.01,48.57 213.17,48.57 213.29,48.68 213.29,49.28 213.4,49.4 226.25,49.4 227.08,48.57 227.76,47.89 228.82,46.83 231.6,44.05 231.6,40.26 v2(230.94,39.6)
  BOTTOM w0.076: UH1.M4 172.64,79.27 172.64,77.83 172.84,77.63 172.84,77.38 173.1,77.13 v2(173.1,76.51)
  BOTTOM w0.14: v2(230.94,39.6) 230.74,39.6 229.67,40.68 229.67,41.14 229.42,41.38 229.42,41.39 229.17,41.64 229.17,41.64 228.83,41.98 JDIMM2.191
