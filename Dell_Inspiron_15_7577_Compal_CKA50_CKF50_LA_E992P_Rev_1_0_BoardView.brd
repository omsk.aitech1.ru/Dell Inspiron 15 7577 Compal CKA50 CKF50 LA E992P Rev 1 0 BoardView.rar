# Allegro board Dell_Inspiron_15_7577_Compal_CKA50_CKF50_LA_E992P_Rev_1_0_BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PROC_DETECT#: length 5.4
  TOP w0.14: v2(274.68,42.51) 274.33,42.16 v1(273.41,42.16) 271.83,42.16 271.29,42.7 RH89.1
  BOTTOM w0.076: UH2.Y44 275.39,42.69 274.98,42.69 274.8,42.51 v2(274.68,42.51)
PROCHOT: length 16
  TOP w0.14: UE1.83 313.88,16.19 v2(313.58,15.88) ; UE6.2 313.35,24.89 313.86,24.39 v1(314.36,24.39) 314.61,24.63 314.61,25.12 314.83,25.35 RE27.2 315.35,25.13 v2(315.35,24.67)
  IN2 w0.097: v2(315.35,24.67) 314.69,24.67 314.26,24.24 314.26,22.33 314.87,21.72 314.87,16.98 313.77,15.88 v2(313.58,15.88)
PROCHOT_CHG: length 2.6
  TOP w0.203: PU700.10 31.83,38.87 31.57,38.61 31.41,38.61 v2(31.33,38.53)
  BOTTOM w0.14: v2(31.33,38.53) v1(30.81,38.53)
  BOTTOM w0.254: v2(31.33,38.53) 31.61,38.81 PR729.2
PROJECT_ID1: length 8.1
  BOTTOM w0.14: UH2.L44 275.11,47.44 273.61,48.94 272.09,48.94 RH558.1 RH557.2 v1(270.7,52.35)
PROJECT_ID2: length 7
  BOTTOM w0.14: UH2.L43 275.81,47.15 274.75,47.15 273.48,48.42 v1(271.69,48.42) RH561.2 RH562.1
PS_ID: length 320.5
  TOP w0.127: v2(39.51,59.4) v1(39.51,60.1)
  TOP w0.14: v2(302,9.12) UE1.36
  TOP w0.254: v2(39.51,59.4) 41.07,59.4 PR2.1 PR1.2
  IN1 w0.097: v2(50.06,27.18) 51.02,26.22 61.46,26.22 61.83,26.58 79.52,26.58 79.79,26.31 79.83,26.31 80.76,25.38 89.03,25.38 91.3,27.65 103.8,27.65 104.43,28.29 105.63,28.29 106.91,27 121.81,27 122.41,27.61 132.29,27.61 134.91,24.98 135.74,24.98 136.66,25.9 236.93,25.9 239.9,22.93 255.98,22.93 264.58,14.33 268.68,14.33 272.1,10.91 277.06,10.91 278.84,9.13 288.99,9.13 289.74,8.39 294.69,8.39 295.52,7.56 301.54,7.56 302,8.02 v2(302,9.12)
  IN4 w0.137: v2(39.51,59.4) 34.71,59.4 33.05,57.74 33.05,52.05 36.2,48.9 38.79,48.9 39.26,48.42 39.26,43.01 38.65,42.39 38.65,40.89 39.46,40.08 39.46,39.66 42.57,36.56 42.57,33.61 43.71,32.47 47.52,32.47 50.06,29.92 v2(50.06,27.18)
PSID: length 23.2
  TOP w0.254: v2(37.33,49.94) v4(38.33,49.94) 41.56,49.94 42.83,51.21 PD1.2 44.6,51.21 44.93,51.53 PL3.2
  IN1 w0.254: v2(37.33,49.94) 36.01,49.94 31.87,54.08 v2(31.87,56.64)
  BOTTOM w0.254: PJPDC1.1 31.67,56.64 v2(31.87,56.64)
PSID-0: length 5.4
  TOP w0.254: PQ1.1 44.74,53.79 44.18,53.22 PL3.1 42.94,52.81 v1(42.91,52.78) 41.86,51.73 PR3.2
PSID-1: length 5.1
  TOP w0.254: PR3.1 PR5.2 v1(40.41,53.72) 40.41,54.73 41.7,56.01 PQ2.2
PSID-3: length 3.5
  TOP w0.127: PR1.1 43.8,59.17 v1(44.55,59.92)
  TOP w0.254: PR1.1 43.8,56.78 PQ1.3
PTP_DIS#: length 3
  TOP w0.14: RE57.2 317.33,18.69 v1(316.5,18.69) 316.06,18.69 315.76,18.99 UE1.90
PTP_DIS#_R: length 201.4
  TOP w0.14: v2(147.5,33.44) v1(148.25,33.44) ; RE57.1 318.87,18.95 v2(319.13,18.7)
  IN2 w0.097: v2(160.69,23.78) 160.69,26.51 154.6,32.6 v2(154.6,33.26)
  IN3 w0.124: v2(160.69,23.78) 161.45,23.78 162.58,24.91 208.39,24.91 210.13,23.17 224.54,23.17 226.54,25.17 236.98,25.17 239.44,22.72 255.11,22.72 264.34,13.49 269.63,13.49 272.76,10.36 275.44,10.36 276.36,9.44 291.24,9.44 291.87,10.07 291.87,10.78 292.29,11.19 300.07,11.19 300.68,11.8 305.9,11.8 308.88,14.78 308.88,15.14 311.94,18.2 311.94,19.12 312.22,19.4 318.43,19.4 v2(319.13,18.7)
  IN4 w0.137: v2(147.5,33.44) 147.5,33.44 148.13,32.81 154.15,32.81 v2(154.6,33.26)
  BOTTOM w0.14: JTP.3 147.45,33.39 v2(147.5,33.44) ; v2(154.6,33.26) 154.6,33.05 156.44,31.21 RE123.2
PTP_INT#: length 219.9
  TOP w0.14: v2(294.74,5) 294.83,5.09 RE61.2 ; DH1.1 283.72,26.44 284.01,26.15 v1(284.01,25.54) 284.01,25.1 284.44,24.67 v2(284.44,23.67)
  IN2 w0.097: v2(284.44,23.67) 283.71,22.94 283.71,15.13 283.78,15.07 283.78,8.94 285.12,7.6 287.43,7.6 288.27,6.76 292.71,6.76 294.47,5 v2(294.74,5)
  IN3 w0.124: v2(294.74,5) 292.1,7.65 274.38,7.65 270.75,11.28 264.75,11.28 262.62,13.41 262.62,14.13 255.91,20.84 252.32,20.84 251.13,22.04 239.05,22.04 236.74,24.35 226.68,24.35 224.72,22.39 209.94,22.39 208.11,24.23 162.87,24.23 161.11,22.47 140.22,22.47 v2(140.18,22.51)
  BOTTOM w0.14: v2(140.18,22.51) 141.71,24.03 141.71,28.03 139.36,30.38 127.51,30.38 126.99,29.86 QE13.1
PTP_INT#_R: length 28.9
  TOP w0.14: v2(146.21,30.61) 147.16,30.61 v4(147.17,30.63)
  BOTTOM w0.14: JTP.4 146.45,30.37 v2(146.21,30.61) 145.36,31.46 125.45,31.46 124.63,30.63 124.63,28.29 124.89,28.02 RE87.2 125.79,28.02 QE13.3
PWM1: length 3.4
  TOP w0.203: PU6000.11 160.14,141.06 160.8,141.71 v1(161.11,141.71) 161.24,141.71 161.96,140.99 PR6041.1
PWM1_GT: length 39.8
  TOP w0.203: v2(134.15,136.11) 134.15,136.2 134.48,136.53 PU5000.12
  IN2 w0.254: v2(114.59,117) 114.31,117 114.01,117.3 114.01,127.92 115.7,129.61 115.7,131.82 121.51,137.63 124.12,137.63 124.55,137.2 129.53,137.2 129.98,136.75 132.52,136.75 132.97,136.3 133.96,136.3 v2(134.15,136.11)
  BOTTOM w0.127: v2(114.59,117) v1(114.06,117)
  BOTTOM w0.254: v2(114.59,117) 114.67,117.07 PR5202.1
PWM1_VCORE: length 13.1
  TOP w0.203: PU5000.25 141.09,136.53 141.29,136.33 141.29,136.04 v2(141.17,135.92)
  IN1 w0.254: v2(141.17,135.92) 141.33,135.76 141.33,134.86 142.01,134.18 145.03,134.18 147.23,131.98 149.02,131.98 149.39,131.61 v2(149.39,131.28)
  BOTTOM w0.14: v2(141.17,135.92) 141.17,135.61 v1(141.44,135.33)
  BOTTOM w0.254: PR5102.1 v2(149.39,131.28)
PWM2: length 1.8
  TOP w0.203: PU6000.10 161.86,139.94 162.01,140.1 PR6045.1
PWM2_GT: length 30.8
  TOP w0.203: v2(133.83,135.36) 133.96,135.23 135.55,135.23 135.67,135.36 PU5000.13
  IN2 w0.254: v2(133.83,135.36) 133.71,135.23 120.12,135.23 116.41,131.52 116.41,125.86 115.67,125.12 v2(114.9,125.12)
  BOTTOM w0.127: v2(114.9,125.12) 114.77,125.12 114.11,124.46 v1(114.11,124.23)
  BOTTOM w0.254: PR5213.1 114.93,125.1 114.91,125.12 v2(114.9,125.12)
PWM2_VCORE: length 9.2
  TOP w0.14: v1(142.4,134.68) 142.13,134.95 v2(141.96,134.95)
  TOP w0.203: PU5000.26 141.34,136.93 141.66,136.61 141.66,135.26 v2(141.96,134.95)
  BOTTOM w0.254: v2(141.96,134.95) 141.75,134.74 141.75,132.35 141.43,132.03 140.23,132.03 139.99,131.79 PR5114.1
PWM3: length 1.8
  TOP w0.203: PU6000.9 161.77,139.54 162.1,139.21 PR6053.2
PWM3_VCORE: length 20.9
  TOP w0.14: v2(156.57,130.28) 156.52,130.23 156.43,130.23 v1(155.96,129.76)
  TOP w0.203: PU5000.27 141.37,137.33 141.99,136.71 141.99,136.2 v2(142.18,136.01)
  IN1 w0.254: v2(156.57,130.28) 156.2,130.28 155.83,130.65 153.19,130.65 148.6,135.23 144.72,135.23 143.94,136.01 v2(142.18,136.01)
  BOTTOM w0.254: PR5126.1 157.38,130.58 157.07,130.28 v2(156.57,130.28)
PWM_SA: length 38.8
  TOP w0.14: v2(166.03,127.41) 165.53,127.41 v1(165.42,127.52)
  TOP w0.203: v2(141.81,141.11) 141.81,141 141.35,140.53 PU5000.35
  TOP w0.254: PR5224.2 166.13,127.31 v2(166.03,127.41)
  IN4 w0.254: v2(166.03,127.41) 164.88,127.41 161.89,130.41 161.89,139.3 160.17,141.02 151.91,141.02 150.51,142.42 144.08,142.42 142.77,141.11 v2(141.81,141.11)
PWR_DEBUG#_XDP: length 5.4
  TOP w0.14: RH526.2 RH528.1 199.24,58.44 199.14,58.54 v1(199.14,58.88) v2(199.52,59.26)
  BOTTOM w0.14: JXDP1.45 199.87,60.27 199.53,59.93 199.53,59.26 v2(199.52,59.26)
PWRBTN#_XDP: length 10.1
  TOP w0.14: CH206.1 RH530.1 201.14,59.31 v2(201.25,59.41) 201.41,59.58 201.76,59.58 202.86,58.49 203.37,58.49 203.49,58.36 203.87,58.36 204,58.23 RH529.2 v1(205.23,57.95)
  BOTTOM w0.14: JXDP1.41 200.87,60.21 201.25,59.83 v2(201.25,59.41)
REFADJ: length 4.7
  TOP w0.14: PR6039.1 v1(163.87,133.77)
  TOP w0.203: PU6000.40 160.14,135.26 160.38,135.03 161.41,135.03 162.18,134.25 162.37,134.25 PR6039.1
REFIN: length 2.9
  TOP w0.203: PU6000.1 161.35,136.34 162.04,135.65 PR6043.1 PR6052.1
REFIN_1: length 6.7
  TOP w0.254: v2(163.53,132.92) 163.46,132.86 PR6039.2 ; v2(164.36,136.22) PC6015.1 163.55,135.6 PR6043.2 PR6064.2
  BOTTOM w0.254: v2(164.36,136.22) 163.53,135.38 v1(163.53,134.65) v2(163.53,132.92)
REFIN_2: length 0.9
  TOP w0.254: PR6052.2 163.55,134.71 PR6062.1
REGN_CHG: length 12.6
  TOP w0.254: v2(34.33,45.41) 34.67,45.41 PR28.1
  IN4 w0.254: v2(34.33,45.41) 37.1,42.63 37.1,38.91 v2(38.08,37.94)
  BOTTOM w0.14: PR718.1 34.13,44.02 34.13,45.2 v2(34.33,45.41) ; v2(38.08,37.94) 37.52,37.94 v1(37.44,38.01)
REMOTE1+: length 153.1
  TOP w0.127: QTH1.1 186.06,123.54 v4(185.46,122.94)
  TOP w0.254: QTH1.2 v2(187.38,124.62) 187.38,124.19 QTH1.1
  IN1 w0.254: v2(187.38,124.62) 189.22,122.77 192.15,122.77 193.67,121.26 193.67,115.74 191.82,113.89 189.09,113.89 187.11,111.92 183.87,111.92 183.11,111.15 176.7,111.15 175.92,111.93 159.47,111.93 159.32,111.78 140.48,111.78 134.89,106.19 134.89,102.94 134.38,102.43 134.38,97.22 133.96,96.8 133.96,95.99 126.49,88.52 115.1,88.52 111.76,85.18 108.64,85.18 107.47,84.01 107.47,80.54 104.86,77.93 104.02,77.32 103.76,77.18 103.4,76.95 103.28,76.9 102.61,76.61 101.23,76.16 98.21,76.16 96.14,74.09 96.14,73.62 96.48,73.28 96.48,70.69 95.95,70.16 95.95,67.01 95.58,66.64 v2(94.92,66.64)
  BOTTOM w0.254: CTH3.1 CTH4.1 92.47,66.86 92.47,67.19 92.57,67.28 UTH1.2 94.28,67.28 v2(94.92,66.64)
REMOTE1-: length 150.8
  TOP w0.127: v4(185.66,126.81) 186.08,126.4 QTH1.3
  TOP w0.254: v2(186.08,124.62) QTH1.3
  IN1 w0.254: v2(95.09,67.21) 95.43,67.55 95.43,74.13 97.97,76.67 101.09,76.67 102.67,77.19 103.17,77.4 103.5,77.61 103.75,77.75 104.53,78.32 106.96,80.75 106.96,84.22 108.43,85.69 111.55,85.69 115.13,89.28 126.5,89.28 132.25,95.02 132.25,95.81 133.87,97.43 133.87,102.64 134.38,103.15 134.38,106.4 140.27,112.29 159.1,112.29 159.25,112.44 176.17,112.44 176.95,111.66 182.9,111.66 183.66,112.42 186.9,112.42 188.88,114.4 191.61,114.4 193.16,115.95 193.16,121.05 191.94,122.27 189.01,122.27 187.04,124.23 186.46,124.23 v2(186.08,124.62)
  BOTTOM w0.254: CTH3.2 CTH4.2 92.48,67.78 UTH1.3 94.29,67.78 94.78,67.29 95.01,67.29 v2(95.09,67.21)
REMOTE2+: length 232.2
  IN1 w0.254: v2(233.15,49.3) 237.47,44.99 237.47,35.08 236.3,33.91 177.61,33.91 174.28,37.24 172,37.24 168.95,34.19 126.79,34.19 126.72,34.13 125.07,34.13 125.01,34.19 102.46,34.19 99.61,37.05 92.18,37.05 91.8,37.43 v2(91.8,37.62)
  IN2 w0.254: v2(94.91,67.9) 95.09,68.07 95.42,68.07 95.61,67.88 95.61,65.33 94.89,64.61 93.49,64.61 91.21,62.33 91.21,38.2 v2(91.8,37.62)
  BOTTOM w0.127: v1(89.13,68.19) 89.23,68.09 CTH5.1
  BOTTOM w0.254: QTH2.1 239.23,70.88 QTH2.2 237.79,70.69 237.79,62.49 235.12,59.82 235.12,51.92 233.4,50.21 233.4,49.56 v2(233.15,49.3) ; CTH5.1 CT114.1 92.06,68.28 UTH1.4 94.31,68.28 94.69,67.9 v2(94.91,67.9)
REMOTE2-: length 231
  IN1 w0.254: v2(232.44,49.29) 236.96,44.78 236.96,35.29 236.09,34.42 177.82,34.42 174.49,37.75 171.78,37.75 168.73,34.7 126.53,34.7 126.47,34.64 125.32,34.64 125.26,34.7 102.72,34.7 99.86,37.56 v2(92.43,37.56)
  IN2 w0.254: v2(94.78,68.51) 94.86,68.58 95.63,68.58 96.18,68.03 96.18,65.18 95.1,64.1 93.7,64.1 91.72,62.12 91.72,38.42 92.43,37.7 v2(92.43,37.56)
  BOTTOM w0.127: CTH5.2 90.06,69 v1(89.36,69.7)
  BOTTOM w0.254: v2(232.44,49.29) 232.44,49.36 232.89,49.81 232.89,50.89 234.61,52.61 234.61,60.03 237.28,62.7 237.28,71.84 237.62,72.18 QTH2.3 ; v2(94.78,68.51) 94.51,68.78 UTH1.5 92.08,68.78 CT114.2 CTH5.2
RESET_N: length 2.3
  BOTTOM w0.076: 364.28,70.26 364.26,70.28 UT4.F11
  BOTTOM w0.14: 364.28,70.26 364.81,70.26 365.25,69.81 RT102.1
RESET_OUT#: length 2.8
  TOP w0.14: RE135.1 316.83,12.98 v1(316.42,12.57) 316.03,12.19 UE1.73
REXT_8713: length 2.6
  BOTTOM w0.14: UI3.7 10.69,46.91 10.91,46.69 11.02,46.69 v1(11.6,46.12) RI23.2
RF_+1.35V: length 4.8
  TOP w0.14: PR804.1 238.15,52.39 v1(239.87,52.39)
  TOP w0.254: PR804.1 237.33,53.22 237.33,53.36 236.31,54.37 PU800.5
RING2: length 20.6
  TOP w0.127: v2(365.29,14.25) v4(364.44,14.25)
  TOP w0.203: v2(343.65,16.08) 343.65,16.34 343.85,16.54 HDA1.17
  IN3 w1.016: 345.92,14.13 352.63,14.13 353.28,13.48 360.71,13.48 361.01,13.78 364.25,13.78
  vias: v2(343.65,15.48) v2(365.47,13.63)
RING2_R: length 10.3
  TOP w0.102: v2(367.59,16.53) v4(366.93,16.53)
  BOTTOM w1.016: 369.29,16.22 376.62,16.22 377.89,14.95 JHP1.4
ROM_CS#: length 33.5
  TOP w0.089: v2(198.74,82.93) 199.36,82.93 199.72,83.29 200.53,83.29 v1(201.78,82.04) 201.85,81.97 v2(201.85,81.45)
  IN2 w0.089: 198.55,83.12 v2(198.74,82.93)
  IN2 w0.097: v2(187.4,78.16) 187.17,78.38 187.17,83.85 188.95,85.63 191.59,85.63 v2(191.66,85.56) 192.86,86.77 195.24,86.77 198.03,83.98 198.03,83.63 198.55,83.12
  BOTTOM w0.114: UG9.BJ4 v2(201.85,81.45)
  BOTTOM w0.14: v2(187.4,78.16) 186.98,77.74 UG13.1 ; v2(191.66,85.56) 188.65,85.56 187.36,84.28 RG74.2
ROM_SCLK: length 10.5
  IN3 w0.089: 198.55,80.55 199.03,80.55 199.43,80.94 199.73,80.94 199.94,80.73 199.94,80.47 200.04,80.37 200.77,80.37 v2(201.15,80.75)
  IN3 w0.124: 198.55,80.55 195.88,80.55 v2(195.44,80.1)
  BOTTOM w0.089: UG9.BK3 v2(201.15,80.75)
  BOTTOM w0.14: RG86.1 RG89.2 194.56,79.57 194.55,79.58 RG75.2 195.43,80.1 v2(195.44,80.1) 195.5,80.03 v1(195.5,79.45)
ROM_SI: length 17.5
  IN3 w0.089: v2(202.35,79.02) 202.17,78.84 200.19,78.84 199.21,79.82 198.55,79.82
  IN3 w0.124: 198.55,79.82 198.19,79.82 198.06,79.68 195.21,79.68 194.98,79.91 194.98,80.46 v2(195.39,80.86)
  BOTTOM w0.089: v2(202.35,79.02) 202.29,79.09 202.22,79.09 201.78,79.53 201.78,80.17 201.59,80.35 UG9.BK2
  BOTTOM w0.14: RG77.2 195.2,81.05 v2(195.39,80.86) 195.86,80.39 195.86,77.89 v1(195.55,77.58) 195.39,77.42 194.81,77.42 RG84.1 RG87.2
ROM_SO: length 15.6
  IN2 w0.089: v2(201.15,81.45) 201.59,81.89 201.59,82.32 201.33,82.58 199.87,82.58 198.6,81.31 198.55,81.31
  IN2 w0.097: 198.55,81.31 193.6,81.31 191.69,83.22 v2(191.69,83.4)
  BOTTOM w0.114: UG9.BK4 v2(201.15,81.45)
  BOTTOM w0.14: v2(191.69,83.4) 191.23,83.86 RG88.2 RG76.1 189.28,83.86 RG85.1
RREF: length 5.8
  BOTTOM w0.127: v1(12.76,32.12) 12.05,31.41 RI3.1
  BOTTOM w0.254: UR1.2 15.04,30.47
  BOTTOM w0.305: 15.04,30.47 15.04,30.84 14.73,31.14 12.43,31.14 RI3.1
RTCRST_ON: length 12.3
  TOP w0.14: RH571.1 289.92,11.08 289.92,9.87 290.12,9.67 QH6.2 290.7,9.07 291.81,7.97 293.85,7.97 294.98,9.09 v1(296.7,9.09) 297.28,9.09 297.57,9.39 UE1.31
RTD3_CIO_PWR_EN: length 115.6
  TOP w0.14: v2(277.66,45.84) v1(276.88,45.84)
  IN3 w0.124: v2(277.66,45.84) 277.7,45.88 277.7,48.01 278.7,49.02 278.9,49.02 281.93,52.05 284.98,52.05 285.56,51.46 285.94,51.46 286.34,51.86 295.69,51.86 296.86,53.04 299.47,53.04 300.93,51.58 300.93,49 301.59,48.34 303.65,48.34 304.84,47.15 305.4,47.15 305.91,47.65 305.91,48.38 307.68,50.16 313.86,50.16 315.63,48.38 318.65,48.38 326.43,56.16 334.87,56.16 335.67,55.37 341.64,55.37 345.23,51.78 345.23,47.33 346.24,46.33 351.58,46.33 352.53,47.28 357.23,47.28 358.81,48.86 358.81,50.79 358.81,50.79 358.81,51.4 358.94,51.53 358.94,51.53 359.7,52.29 359.7,55.29 360.74,56.32 v2(362.81,56.32)
  BOTTOM w0.076: UH2.R39 277.91,45.59 v2(277.66,45.84)
  BOTTOM w0.14: v2(362.81,56.32) 362.79,56.35 RT16.2
RTD3_CIO_PWR_EN_R: length 2.6
  BOTTOM w0.076: UT1.F1 360.16,56.95 360.76,56.35 361.23,56.35
  BOTTOM w0.14: RT36.1 RT16.1 361.23,56.35
RTD3_USB_PWR_EN_R: length 2.4
  TOP w0.14: RT37.1 359.26,56.92 v2(358.4,57.78) 358.67,57.78 v1(359,58.12)
  BOTTOM w0.076: UT1.D4 v2(358.4,57.78)
RTM_CSCL: length 6.7
  TOP w0.14: UP2.29 329.98,45.84 329.09,46.73 v1(329.09,48.54) 329.09,49.06 328.64,49.51 328.64,50.28 RP48.1
RTM_CSDA: length 7.2
  TOP w0.14: RP49.1 329.01,50.8 329.01,49.75 329.44,49.32 v1(329.44,47.16) 329.44,46.84 330.04,46.24 UP2.28
RTM_DCIN_ENB: length 4.4
  TOP w0.14: v1(338.23,42.89) 338.94,42.89 RP33.2 339.26,44.14 RP39.2 338.94,44.16 338.62,43.84 UP2.3
RTM_EQ: length 6.8
  TOP w0.14: UP2.5 338.4,44.64 338.75,44.99 339,44.99 339.08,45.07 339.75,45.07 340,45.32 340,45.84 v1(340.46,46.31) 340.82,46.66 341.25,46.66 341.64,47.06 RP40.2 341.67,47.11 RP34.2
RTM_HDMI_ID: length 5.7
  TOP w0.14: UP2.32 329.77,44.64 329.67,44.54 v2(329.03,44.54)
  BOTTOM w0.14: v2(329.03,44.54) 328.33,43.84 RP36.2 RP43.2
RTM_I2C_ADDR: length 3.6
  TOP w0.14: UP2.31 v1(329.58,45.04) 328.83,45.04 328.52,44.73 RP38.2 RP41.2
RTM_PDB: length 5.7
  TOP w0.14: RP44.2 341.52,46.19 341.39,46.32 340.97,46.32 340.24,45.59 340.24,45.22 339.85,44.83 339.35,44.83 339.19,44.67 338.81,44.67 338.38,44.24 v1(338.16,44.24) UP2.4
RTM_PRE: length 8.5
  TOP w0.14: RP42.2 RP37.2 329.35,51.35 329.35,50.07 v1(329.59,49.83) 329.79,49.63 329.79,46.93 330.08,46.64 UP2.27
RTM_RST#: length 3.6
  TOP w0.14: CP27.1 RP35.2 328.77,43.84 329.17,43.44 v1(329.64,43.44) UP2.35
RUNPWROK: length 4.9
  TOP w0.14: UE1.48 306.8,8.57 306.68,8.69 306.68,9.4 v2(306.24,9.85)
  BOTTOM w0.14: RE62.1 306.71,8.14 v1(306.71,9.27) 306.71,9.38 v2(306.24,9.85)
SATA_LED_EN: length 117.5
  TOP w0.127: v1(228.26,57.71) 228.26,57.9 227.74,58.42 v2(227.73,58.42)
  TOP w0.254: v2(227.73,58.42) 227.35,58.42 RE146.2 227.02,58.09 RE152.1 225.75,57.26 225.26,57.75 QE21.5 QE21.6
  IN1 w0.254: v2(308.98,11.32) 308.98,12.77 307.2,14.54 305.41,14.54 301.77,18.19 301.77,18.71 301.46,19.01 300.24,19.01 299.8,18.57 297.94,18.57 297.14,19.37 288.65,19.37 287.27,17.99 285.35,17.99 284.75,17.39 280.93,17.39 280.37,17.95 277.32,17.95 276.58,18.69 273.23,18.69 269.98,21.95 269.98,24.22 268.96,25.24 265.15,25.24 261.14,29.24 261.14,29.85 261.75,30.46 261.75,32.65 260.59,33.81 249.56,33.81 248.03,35.33 248.03,39.64 242.61,45.06 242.61,45.82 233.06,55.36 231.1,55.36 228.97,57.5 228.65,57.5 v2(227.73,58.42)
  BOTTOM w0.254: RE132.2 308.76,11.1 v2(308.98,11.32)
SATA_PRX_DTX_N1B: length 61.5
  TOP w0.14: v2(246.52,23.47) 246.36,23.64 246.36,24.2 CS25.1
  IN2 w0.104: v2(278.03,51.02) 278.18,51.02 278.25,50.95 278.25,50.62 278.2,50.57 278.14,50.52 275.84,50.52 275.51,50.84 271.07,50.84 269.15,48.92 268.18,48.92 264.49,45.23 264.49,33.9 265.66,32.72 265.66,31.92 266.36,31.22 266.36,25.74 265.58,24.96 265.58,24.62 263.72,22.76 261.31,22.76 260.66,23.41 252.35,23.41 251.99,23.05 246.31,23.05 246.26,23.11 246.26,23.21 246.34,23.29 246.34,23.42 246.42,23.5 246.5,23.5 v2(246.52,23.47)
  BOTTOM w0.076: UH2.D39 278.17,50.87 v2(278.03,51.02)
SATA_PRX_DTX_N1B_RC: length 8.6
  TOP w0.14: v2(246.83,26.11) 246.66,26.28 246.43,26.28 246.11,26.6 246.11,27.01 246.51,27.4 246.51,27.58 246.38,27.72 246.04,27.72 v3(245.8,27.47) 245.59,27.27 245.59,26.51 CS25.2
  BOTTOM w0.14: JHDD1.5 246.6,27.5 246.73,27.37 247.12,27.37 247.54,26.96 247.54,26.53 247.26,26.25 246.98,26.25 v2(246.83,26.11)
SATA_PRX_DTX_P1B: length 61.6
  TOP w0.14: v2(245.94,23.47) 246.1,23.64 246.1,24.2 CS26.1
  IN2 w0.104: v2(245.94,23.47) 245.99,23.42 245.99,23.36 246.06,23.28 246.06,23.03 246.23,22.86 252.07,22.86 252.43,23.22 260.58,23.22 261.23,22.57 263.8,22.57 265.77,24.54 265.77,24.88 266.56,25.66 266.56,31.3 265.86,32 265.86,32.8 264.68,33.98 264.68,45.15 268.26,48.73 269.23,48.73 271.15,50.65 275.43,50.65 275.76,50.33 278.22,50.33 278.58,50.68 v2(278.66,50.68)
  BOTTOM w0.076: v2(278.66,50.68) 278.66,50.34 278.73,50.27 UH2.E37
SATA_PRX_DTX_P1B_RC: length 8.6
  TOP w0.14: CS26.2 245.93,25.57 245.93,25.81 245.34,26.4 245.34,27.37 245.94,27.97 246.48,27.97 246.76,27.69 246.76,27.3 246.37,26.9 246.37,26.7 246.54,26.53 246.68,26.53 v2(246.83,26.69)
  BOTTOM w0.14: JHDD1.6 246.1,27.64 246.62,27.12 247.02,27.12 247.28,26.85 247.28,26.63 247.16,26.51 247.02,26.51 v2(246.83,26.69)
SATA_PRX_SSDTX_N0A: length 49.4
  IN2 w0.104: v2(271.72,15.62) 270.82,15.62 269.85,16.6 269.85,19.66 267.94,21.57 267.94,22.66 269.28,24 269.28,29.44 269.46,29.61 269.46,32.39 269.22,32.63 269.22,36.63 268.58,37.27 268.58,37.77 268.58,37.77 268.58,37.93 268.58,37.93 268.58,38.43 268.58,38.43 268.58,43.86 271.19,46.47 279.06,46.47 280.13,47.54 280.28,47.54 280.83,48.1 280.83,48.38 281,48.54 281.4,48.95 v2(281.4,49.02)
  BOTTOM w0.076: UH2.G31 281.54,49.02 v2(281.4,49.02)
  BOTTOM w0.14: JNGFF2.43 272.79,15.28 272.43,15.64 271.74,15.64 v2(271.72,15.62)
SATA_PRX_SSDTX_P0A: length 49.4
  IN2 w0.104: v2(281.4,48.34) 281.34,48.41 281.13,48.41 281.03,48.3 281.03,48.02 280.36,47.35 280.21,47.35 279.14,46.28 271.27,46.28 268.77,43.78 268.77,38.35 268.77,38.35 268.77,38.01 268.77,38.01 268.77,37.69 268.77,37.69 268.77,37.35 269.41,36.71 269.41,32.71 269.65,32.47 269.65,29.53 269.47,29.36 269.47,23.92 268.13,22.58 268.13,21.65 270.04,19.74 270.04,16.68 270.9,15.82 271.34,15.82 271.5,15.98 271.5,16.3 271.6,16.4 271.87,16.4 271.96,16.3 v2(271.96,16.16)
  BOTTOM w0.076: UH2.H31 281.62,48.34 v2(281.4,48.34)
  BOTTOM w0.14: v2(271.96,16.16) 271.96,16.03 272.1,15.89 272.54,15.89 272.84,15.59 273.03,15.59 273.22,15.78 JNGFF2.41
SATA_PTX_DRX_N1B: length 61.8
  TOP w0.14: v2(248.96,23.47) 249.13,23.65 249.13,23.91 249.3,24.07 249.3,24.3 CS27.1
  IN2 w0.104: v2(278.32,54.79) 278.32,55.34 277.94,55.72 276.81,55.72 276.33,55.23 275.25,55.23 272.56,52.54 269.35,52.54 263.28,46.47 263.28,33.4 264.46,32.22 264.46,31.42 264.7,31.18 264.7,28.41 260.61,24.32 249.19,24.32 248.96,24.08 v2(248.96,23.47)
  BOTTOM w0.076: UH2.B38 278.52,51.69 278.52,52.35 278.38,52.5 278.38,53.33 277.91,53.8 277.91,54.32 277.98,54.38 278.42,54.38 278.49,54.45 278.49,54.62 v2(278.32,54.79)
SATA_PTX_DRX_N1B_RC: length 7.1
  TOP w0.14: v2(248.74,26.11) 248.74,26.12 248.9,26.27 249.16,26.27 249.47,26.58 249.47,27.19 249.57,27.3 249.99,27.3 250.12,27.17 v3(250.12,26.94) 250.12,26.73 249.41,26.02 249.41,25.88 CS27.2
  BOTTOM w0.14: v2(248.74,26.11) 248.62,26.23 248.28,26.23 248.15,26.36 248.15,26.38 248.02,26.51 248.02,27.02 247.71,27.33 247.71,27.47 247.6,27.59 JHDD1.3
SATA_PTX_DRX_P1B: length 61.7
  TOP w0.14: CS28.1 249.56,24.22 249.56,23.97 249.39,23.8 249.39,23.64 v2(249.56,23.47)
  IN2 w0.104: v2(249.56,23.47) 249.64,23.56 249.64,23.68 249.54,23.78 249.23,23.78 249.15,23.86 249.15,24 249.27,24.12 260.69,24.12 264.9,28.33 264.9,31.26 264.65,31.5 264.65,32.3 263.48,33.48 263.48,46.39 269.43,52.35 272.64,52.35 275.33,55.04 276.41,55.04 276.89,55.52 277.86,55.52 278.13,55.26 278.13,55.17 277.74,54.79 v2(277.73,54.79)
  BOTTOM w0.076: UH2.C38 278.36,51.35 278.36,52.29 278.21,52.43 278.21,53.26 277.73,53.74 v2(277.73,54.79)
SATA_PTX_DRX_P1B_RC: length 7.1
  TOP w0.14: v2(248.74,26.69) 248.91,26.53 249.06,26.53 249.21,26.68 249.21,27.3 249.46,27.55 250.11,27.55 250.37,27.28 250.37,26.63 249.66,25.91 249.66,25.74 CS28.2
  BOTTOM w0.14: JHDD1.2 248.1,27.66 247.97,27.52 247.97,27.41 248.26,27.12 248.26,26.61 248.39,26.48 248.53,26.48 v2(248.74,26.69)
SATA_PTX_SSDRX_N0A: length 61.4
  IN2 w0.104: v2(272.26,14.63) 272.67,14.63 273,14.96 273,22.19 271.73,23.46 271.73,28.58 271.45,28.86 271.45,33.45 272.13,34.12 272.13,38.4 272.96,39.24 272.96,42.06 273.92,43.02 281.91,43.02 284.39,45.5 284.39,50.78 282.93,52.24 282.93,52.86 282.17,53.62 281.88,53.62 v2(281.85,53.65)
  BOTTOM w0.076: v2(281.85,53.65) 282.45,53.65 282.64,53.47 282.64,52.54 282.26,52.16 282.26,51.36 282.05,51.16 UH2.C31
  BOTTOM w0.14: v2(272.26,14.63) 272.25,14.63 272,14.87 271.67,14.87 271.57,14.76 271.57,14.63 271.53,14.6 271.21,14.6 271.07,14.74 271.07,14.9 270.7,15.27 269.47,15.27 268.74,14.54 268.74,13.96 268.88,13.82 269.08,13.82 269.65,14.39 CD53.1
SATA_PTX_SSDRX_N0A_C: length 3.4
  BOTTOM w0.14: JNGFF2.47 272.89,14.28 272.77,14.15 270.87,14.15 CD53.2
SATA_PTX_SSDRX_P0A: length 61.3
  IN2 w0.104: v2(272.26,15.21) 272.26,15.2 272.52,14.93 272.7,14.93 272.81,15.04 272.81,15.57 272.7,15.67 272.53,15.67 272.42,15.78 272.42,15.98 272.53,16.09 272.7,16.09 272.81,16.19 272.81,22.11 271.54,23.38 271.54,28.5 271.26,28.78 271.26,33.53 271.94,34.2 271.94,38.48 272.77,39.32 272.77,42.14 273.84,43.21 281.83,43.21 284.2,45.58 284.2,50.7 282.74,52.16 282.74,52.78 282.22,53.3 282.04,53.3 281.85,53.1 v2(281.85,53.07)
  BOTTOM w0.076: v2(281.85,53.07) 281.85,53.15 282.19,53.49 282.39,53.49 282.47,53.4 282.47,52.61 282.09,52.23 282.09,51.49 282.02,51.41 281.88,51.41 281.8,51.49 281.8,51.63 UH2.B31
  BOTTOM w0.14: v2(272.26,15.21) 272.24,15.19 271.13,15.19 270.8,15.52 269.36,15.52 268.48,14.64 268.48,13.86 268.77,13.57 CD51.1
SATA_PTX_SSDRX_P0A_C: length 3.5
  BOTTOM w0.14: JNGFF2.49 272.89,13.78 272.77,13.9 270.89,13.9 CD51.2
SCL_CHG: length 2.2
  TOP w0.203: PU700.12 31.99,38.07 31.52,37.61 30.71,37.61 PR731.2
SD_CD#: length 30.2
  TOP w0.14: JREAD1.10 v2(18.39,53.25)
  IN1 w0.097: v2(18.71,27.84) 19.14,28.28 19.14,30.59 20.29,31.73 20.29,40.61 21.63,41.96 21.63,48.29 19.65,50.28 19.65,51.99 v2(18.39,53.25)
  BOTTOM w0.14: UR1.10 18.52,27.65 v2(18.71,27.84)
SD_CLK: length 26.9
  TOP w0.14: v2(16.64,43.75) 17.1,44.2 JREAD1.5
  IN1 w0.097: v2(16.64,43.75) 13.45,40.55 13.45,40.54 12.71,39.8 12.71,37.54 11.1,35.93 11.1,27.64 12.87,25.87 v2(12.87,23.32)
  BOTTOM w0.14: RI53.2 CR4.1 v2(12.87,23.32)
SD_CLK_R: length 1.6
  BOTTOM w0.14: UR1.18 14.54,24.25 RI53.1
SD_CMD: length 28.3
  TOP w0.14: JREAD1.2 v2(18.32,37.82)
  IN1 w0.097: v2(18.32,37.82) 18.32,38.34 18.1,38.56 16.54,38.56 16.43,38.46 16.43,38.13 16.53,38.04 17.6,38.04 17.69,37.94 17.69,37.68 17.6,37.58 16.51,37.58 16.41,37.49 16.41,37.19 16.51,37.09 18.64,37.09 18.73,36.99 18.73,36.74 18.64,36.64 16.48,36.64 16.38,36.54 16.38,36.3 16.51,36.17 18.61,36.17 18.79,35.98 18.79,33.31 13.48,27.99 13.48,27.14 v2(12.89,26.56)
  BOTTOM w0.14: UR1.20 13.21,27.15 12.89,26.84 v2(12.89,26.56)
SD_D0: length 29.6
  TOP w0.14: JREAD1.7 v2(18.33,50.25)
  IN1 w0.097: v2(17.25,24.92) 17.31,24.98 17.31,30.19 19.33,32.21 19.33,40.49 17.46,42.37 17.46,48.42 17.74,48.69 17.74,48.69 17.88,48.84 18.33,49.29 v2(18.33,50.25)
  BOTTOM w0.14: UR1.13 17.04,25.13 v2(17.25,24.92)
SD_D1: length 29.9
  TOP w0.14: JREAD1.8 18.33,51.95 v2(18.37,51.91)
  IN1 w0.097: v2(18.37,51.91) 18.92,51.36 18.92,49.21 17.94,48.22 17.94,42.56 19.81,40.69 19.81,31.93 18.67,30.79 18.67,29.39 18.2,28.92 18.2,27.05 v2(18.71,26.54)
  BOTTOM w0.14: v2(18.71,26.54) 18.59,26.65 UR1.12
SD_D2: length 28.2
  TOP w0.14: v2(17.1,34.38) JREAD1.9
  IN1 w0.097: v2(11.61,27.84) 11.61,29.89 12.21,30.49 12.87,30.49 12.97,30.59 12.97,30.78 12.87,30.88 12.21,30.88 12.11,30.97 12.11,31.16 12.21,31.26 13.08,31.26 13.17,31.36 13.17,31.55 13.08,31.65 12.21,31.65 12.11,31.74 12.11,31.94 12.21,32.03 13.08,32.03 13.17,32.13 13.17,32.32 13.08,32.42 12.21,32.42 12.11,32.52 12.11,32.71 12.21,32.81 13.08,32.81 13.17,32.9 13.17,33.1 13.08,33.19 12.21,33.19 12.11,33.29 12.11,33.48 12.21,33.58 13.08,33.58 13.17,33.67 13.17,33.87 13.08,33.96 12.21,33.96 12.11,34.06 12.11,34.25 12.21,34.35 13.08,34.35 13.17,34.45 13.17,34.64 13.08,34.74 12.21,34.74 12.11,34.83 12.11,35.34 12.21,35.44 16.05,35.44 v2(17.1,34.38)
  BOTTOM w0.14: v2(11.61,27.84) 12.42,28.65 UR1.23
SD_D3: length 28
  TOP w0.14: v2(18.31,35.7) 17.93,35.32 JREAD1.1
  IN1 w0.097: v2(12.89,27.85) 12.89,28.08 13.82,29 13.82,29.14 13.58,29.37 13.58,29.51 13.72,29.65 13.86,29.65 14.09,29.41 14.23,29.41 14.51,29.7 14.51,29.83 13.84,30.5 13.84,30.64 13.97,30.78 14.11,30.78 14.78,30.11 14.92,30.11 15.05,30.24 15.05,30.38 14.38,31.05 14.38,31.19 14.52,31.32 14.66,31.32 15.33,30.65 15.46,30.65 15.6,30.79 15.6,30.93 14.93,31.6 14.93,31.73 15.06,31.87 15.2,31.87 15.87,31.2 16.01,31.2 16.15,31.33 16.15,31.47 15.47,32.14 15.47,32.28 15.61,32.42 15.75,32.42 16.42,31.74 16.56,31.74 16.69,31.88 16.69,32.04 15.49,33.25 15.49,33.38 15.62,33.52 15.76,33.52 16.98,32.3 17.11,32.3 17.36,32.55 17.36,32.69 16.38,33.66 16.38,33.8 16.52,33.93 16.66,33.93 17.63,32.96 17.77,32.96 18.31,33.5 v2(18.31,35.7)
  BOTTOM w0.14: v2(12.89,27.85) 13.19,28.15 UR1.22
SD_WP: length 32.4
  TOP w0.14: JREAD1.11 18.79,54.45 v2(19.04,54.21)
  IN1 w0.097: v2(18.71,27.15) 19.34,27.79 19.34,30.51 20.49,31.65 20.49,40.53 21.83,41.87 21.83,48.38 19.85,50.36 19.85,53.39 v2(19.04,54.21)
  BOTTOM w0.14: v2(18.71,27.15) UR1.11
SDA_CHG: length 4.7
  TOP w0.14: PR730.2 30.53,38.78 30.13,39.18 29.06,39.18 28.93,39.31 v1(28.55,39.31)
  TOP w0.203: PU700.11 31.94,38.47 31.52,38.05 31.16,38.05 PR730.2
SDREG: length 3.1
  BOTTOM w0.127: CR7.2 16.88,24.23 v1(16.98,24.13)
  BOTTOM w0.254: UR1.16 15.54,25.24
  BOTTOM w0.381: 15.54,25.24 15.54,24.24 CR7.2
SIO_EXT_SCI#: length 4.6
  TOP w0.14: v2(283.68,33.72) 283.22,33.26 v1(283.22,33.01) 283.22,32.54 282.4,31.71 281.9,31.71 RH10.2
  BOTTOM w0.089: v2(283.68,33.72) 283.68,33.72 283.68,33.72 283.59,33.81 283.14,33.81 UH2.AV29
SIO_EXT_WAKE#: length 48.3
  TOP w0.14: v2(305.79,24.67) 305.79,24.15 305.6,23.95 UE1.116 ; v2(274.07,37.11) 274.07,37.51 v1(274.26,37.7)
  IN1 w0.097: v2(274.07,37.11) 274.54,37.11 275.13,36.52 275.13,31.61 276.55,30.2 276.55,29.66 277.22,28.99 280.45,28.99 282.38,27.06 282.79,27.06 283.12,27.4 289.54,27.4 290.17,28.03 293.65,28.03 293.98,28.36 297.86,28.36 298.17,28.04 298.17,27.13 298.42,26.88 299.35,26.88 299.72,26.51 305.08,26.51 306.11,25.48 306.11,24.98 v2(305.79,24.67)
  BOTTOM w0.114: 274.37,37.11 275.41,36.07 UH2.AN44
  BOTTOM w0.14: RH91.2 273.81,37.37 v2(274.07,37.11) 274.37,37.11
SIO_PWRBTN#: length 171.2
  TOP w0.14: UE1.52 308.4,8.36 308.09,8.66 v2(308.09,10.22) ; v2(267.98,23.4) v1(269.52,23.4) ; RH530.2 201.14,56.54 v2(201.85,55.83)
  IN1 w0.097: v2(308.09,10.22) 308.09,10.3 306.66,11.73 305.97,11.73 303.83,13.87 293.36,13.87 292.77,13.28 291.48,13.28 291.16,12.96 291.16,12.58 289.47,10.89 v2(289.47,10.53) ; v2(267.98,23.4) 267.37,23.4 266.1,24.67 264.94,24.67 260.56,29.04 260.56,30.07 261.19,30.7 261.19,32.43 260.36,33.25 249.79,33.25 249.33,33.25 247.48,35.1 247.48,37.71 247.23,37.95 246.72,37.95 246.24,38.43 246.24,39.68 242.29,43.63 241.26,43.63 231.45,53.44 229.35,53.44 228.42,54.37 203.32,54.37 v2(201.85,55.83)
  IN2 w0.097: v2(289.47,10.53) 289.47,10.51 289.74,10.77 289.74,16.61 291.43,18.3 291.43,18.62 292.04,19.23 292.04,22.08 290.62,23.5 290.62,28.24 290.95,28.57 290.95,31.49 291.15,31.69 291.15,34.52 290.67,35 v2(290.62,35)
  IN5 w0.097: v2(267.98,23.4) 268.84,23.4 269.41,23.96 270.52,25.08 270.52,28.76 272.23,30.47 277.64,30.47 281.42,34.25 281.42,34.83 281.93,35.33 284.14,35.33 284.57,34.9 285.16,34.9 285.69,35.44 286.51,35.44 287.05,34.9 288.68,34.9 289.46,35.68 289.94,35.68 v2(290.62,35)
  BOTTOM w0.089: v2(290.62,35) 290.83,35 UH2.AT13
SIO_SLP_S0#: length 29.3
  IN5 w0.097: v2(297.06,14.92) 296.47,15.51 295.98,15.51 294.1,17.39 294.1,20.89 292.92,22.07 288.24,22.07 288.2,22.03 285.69,22.03 285.46,22.27 284.25,22.27 283.62,22.9 283.62,24.48 283.85,24.7 283.85,28.49 v2(284.14,28.78)
  BOTTOM w0.076: UH2.BC26 284.32,31.18 284.09,30.95 284.09,30.71 284.14,30.67 v2(284.14,28.78)
  BOTTOM w0.14: RTPM3.1 296,14.26 RTPM11.1 297.06,14.54 v2(297.06,14.92)
SIO_SLP_S0#_R: length 3.3
  BOTTOM w0.14: v1(295.82,13.35) 295.82,13.53 RTPM3.2 294.51,13.94 UTPM1.29
SIO_SLP_S3#: length 797.2
  TOP w0.14: v2(260.77,31.08) 260.85,31.16 UZ1.3 ; v2(261.7,29.55) 261.68,29.55 261.68,31.37 261.65,31.41 UZ1.5 ; UZ21.2 298.72,30.28 299.28,30.84 299.83,30.84 300.57,30.1 303.75,30.1 303.89,30.24 303.89,31.51 v2(303.94,31.56) ; RZ108.1 277.47,66.06 DZ2.1 276.97,66.89 v2(276.77,67.09) ; v2(220.09,55.02) 220.16,54.96 RZ112.1 ; v2(243.84,49.44) 238.52,49.44 237.53,48.45 232.4,48.45 231.55,49.3 v2(228.93,49.3) 227.21,49.3 226.96,49.55 UZ16.3 ; QZ2.2 334.16,35.79 v2(334.16,36.46) ; v1(116.37,62.04) v2(116.37,62.97) 116.37,64.26 PR210.1
  IN1 w0.097: v2(260.77,31.08) 260.05,30.36 260.05,28.87 262.23,26.69 v2(262.23,24.48) ; v2(303.94,31.56) 303.2,32.3 297.35,32.3 296.9,31.85 294.79,31.85 293.73,32.92 291.21,32.92 v2(290.58,33.55)
  IN2 w0.097: v2(86.51,29.52) 87.49,30.5 95.97,30.5 96.18,30.7 96.18,32.83 99.08,35.73 99.08,40.5 116.37,57.78 v2(116.37,62.97) ; v2(303.94,31.56) 303.94,31.58 306.12,33.76 306.12,38.13 305.37,38.88 305.37,44.75 308.47,47.85 308.47,52.04 305.84,54.67 302.99,54.67 301.48,56.18 297.99,56.18 294,60.16 292,60.16 290.21,61.96 290.21,62.09 288.25,64.05 283.04,64.05 280.01,67.09 v2(276.77,67.09) ; v2(355.51,39.59) 355.96,39.14 358.75,39.14 361.61,42 361.61,43.27 362.6,44.26 362.6,46.1 363.27,46.77 364.29,46.77 365.37,47.86 365.37,54.69 364.67,55.39 v2(364.67,56.28) ; v2(260.77,31.08) 260.77,32.38 259.92,33.23 254.31,33.23 251.85,30.77 245.72,30.77 244.74,31.75 244.74,33.99 248.04,37.29 248.04,39.14 247.1,40.08 247.1,46.18 v2(243.84,49.44)
  IN3 w0.124: v2(261.7,29.55) 261.62,29.47 261.62,28.15 263.28,26.48 264.95,26.48 266.08,25.35 276.06,25.35 v2(277.79,27.08) ; v2(220.09,55.02) 220.09,55.72 220.42,56.05 222.45,56.05 222.77,56.37 224.21,56.37 224.79,55.78 224.79,53.44 v2(228.93,49.3) ; v2(125.57,110.38) 125.58,110.38 125.91,110.06 128.23,110.06 130.3,112.12 158.02,112.12 158.48,112.58 167.16,112.58 167.4,112.81 176.08,112.81 176.78,112.12 181.1,112.12 182.1,111.11 185.12,111.11 189.21,107.03 190.21,107.03 192.96,104.27 192.96,90.36 v2(194.98,88.34) 195.02,88.34 195.59,88.92 198.55,88.92 200.57,86.9 204.7,86.9 205.33,86.26 205.33,79.97 207.21,78.1 211.27,78.1 211.96,78.79 217.95,78.79 223.5,73.24 223.98,73.24 225.83,71.39 228.41,71.39 229.86,69.94 236.07,69.94 236.4,70.27 237.42,71.29 244.69,71.29 245.39,70.59 268.5,70.59 272,67.09 v2(276.77,67.09) ; v2(262.23,24.48) 260.62,24.48 256.23,28.86 254.37,28.86 253.34,29.89 248.92,29.89 248.72,29.7 245.83,29.7 245.4,29.26 223.42,29.26 222.21,28.06 210.23,28.06 209.74,28.54 191.03,28.54 190.38,29.2 156.23,29.2 155.78,28.75 137.16,28.75 136.05,29.85 114.93,29.85 113.77,28.69 87.34,28.69 v2(86.51,29.52)
  IN4 w0.137: v2(303.94,31.56) 303.94,31.73 304.28,32.07 305.31,32.07 308.03,34.79 316.78,34.79 317.23,34.34 328.01,34.34 328.84,35.18 333.21,35.18 334.05,36.02 334.05,36.35 v2(334.16,36.46) 334.96,35.66 344.13,35.66 345.71,37.25 348.38,37.25 349.33,38.2 354.92,38.2 355.51,38.8 v2(355.51,39.59) ; v2(194.98,88.34) 194.87,88.46 194.87,89.45 194.27,90.05 194.27,95.16 184.24,105.2 v2(184.24,106.64) ; v2(116.37,62.97) 120.15,62.97 121.79,64.61 121.79,89.42 122.43,90.05 122.43,95.59 123.22,96.39 123.22,103.46 124,104.24 124,105.3 123.51,105.79 123.51,109.53 124.36,110.38 v2(125.57,110.38)
  IN5 w0.097: v2(277.79,27.08) 277.79,28.88 278.52,29.62 278.52,30.68 281.78,33.94 282.65,33.94 282.89,34.18 284.19,34.18 284.35,34.01 284.93,34.01 285.2,34.29 286.84,34.29 287.12,34.01 290.12,34.01 v2(290.58,33.55)
  BOTTOM w0.102: UH2.AW15 290.56,33.55 v2(290.58,33.55)
  BOTTOM w0.14: QV2.2 83.56,31.51 85.55,29.52 v2(86.51,29.52) ; v2(364.67,56.28) 364.67,56.96 363.83,57.8 363.83,58.08 363.34,58.58 363.13,58.58 362.94,58.77 RT110.2 ; v2(184.24,106.64) 184.44,106.85 UZ9.4
SIO_SLP_S3#_AR: length 4.7
  BOTTOM w0.076: 361.23,57.81 361.04,57.63 359.66,57.63 UT1.D2
  BOTTOM w0.14: 361.23,57.81 361.43,57.81 361.62,58 361.63,58 361.7,58.07 361.76,58.07 RT30.2 RT110.1 361.89,58.92 v1(362.73,59.76)
SIO_SLP_S4#: length 248.4
  TOP w0.14: v2(181.4,60.92) 184.44,60.92 191.66,53.7 215.6,53.7 216.32,54.42 216.96,54.42 216.97,54.41 RZ111.1 ; RZ102.1 242.74,24.99 DZ1.1 243.17,24.41 243.6,23.98 v2(243.6,23.64) 243.6,23.13 244.41,22.32 v1(247.42,22.32) 250.68,22.32 252.91,20.08 256.53,20.08 257.9,18.71 257.9,16.75 v2(258.03,16.63)
  IN2 w0.097: v2(166.86,56.42) 175.74,47.54 175.74,38 176.95,36.79 176.95,34.38 175.93,33.37 v2(175.93,32.88) 175.93,31.33 172.44,27.84 172.44,23.46 172.95,22.95 179.86,22.95 181.06,24.16 184.57,24.16 186.09,25.68 225.15,25.68 226.23,26.76 237.59,26.76 239.88,24.48 242.76,24.48 v2(243.6,23.64) ; v2(258.03,16.63) 258.64,16.02 260.08,16.02 262.68,13.43 262.68,13.03 264.68,11.03 270.22,11.03 270.73,10.52 270.73,9.25 272.82,7.15 277.34,7.15 279.12,8.93 282.11,8.93 283.38,10.2 283.38,14.9 283.31,14.97 283.31,23.85 283.67,24.21 286.51,24.21 287.76,25.46 287.76,27.14 287.38,27.52 287.38,28.25 288.84,29.72 v2(289.66,29.72)
  BOTTOM w0.076: 290.03,30.21 290.03,30.16 289.66,29.79 v2(289.66,29.72)
  BOTTOM w0.102: 290.03,30.21 290.03,30.68 UH2.BD15
  BOTTOM w0.14: v2(166.86,56.42) 169.33,58.89 179.36,58.89 v2(181.4,60.92) ; PR25V00.1 v2(175.93,32.88)
SIO_SLP_S5#: length 3.6
  TOP w0.14: T4938.1 291.2,29.95 291.83,30.58 v2(291.83,31.42)
  BOTTOM w0.076: v2(291.83,31.42) 291.77,31.42 291.07,32.12 UH2.BA13
SLEEVE: length 18.5
  TOP w0.127: v1(345.25,14.46) 344.73,14.98 v2(344.73,15.48)
  TOP w0.203: HDA1.18 344.25,16.49 344.18,16.42 344.18,15.75 344.45,15.48 v2(344.73,15.48)
  IN4 w1.016: 346.3,14.25 346.61,14.56 350.11,14.56 351.2,13.46 358.72,13.46 360.01,14.75 360.47,14.75
  vias: v2(345.3,15.29) v2(361.09,14.79) v2(361.7,14.8)
SLEEVE_R: length 12.3
  TOP w0.127: v2(365.72,16.54) v4(364.99,16.54)
  IN2 w1.016: 368.21,4.92 367.48,5.65 367.48,14.85 366.51,15.81
  vias: v2(365.72,15.95)
SM_PG_CTRL: length 37
  TOP w0.254: v2(116.68,64.67) 116.68,64.9 PR211.1
  IN1 w0.097: v2(133.51,85.63) 133.33,85.63 132.37,84.67 128.29,84.67 123.26,79.65 123.26,68.2 119.75,64.69 116.7,64.69 v2(116.68,64.67)
  BOTTOM w0.14: v1(133.51,84.54) v2(133.51,85.63) RH93.2 133.52,86.27 UC1.4
SMBALERT#: length 4.2
  TOP w0.14: RH66.2 275.63,31.4 276.39,32.16 v2(276.39,32.35) 276.68,32.35 277.12,32.78 277.12,33.2 v1(276.68,33.63)
  BOTTOM w0.089: UH2.BB41 276.87,31.78 276.39,32.26 v2(276.39,32.35)
SMBCLK: length 13.2
  TOP w0.14: v2(268.87,28.39) 269.09,28.6 269.09,28.84 268.89,29.04 QH4.6 267.98,29.04 267.88,28.94 RH21.2 266.94,28.39 v1(266.37,28.39)
  IN5 w0.097: v2(276.01,32.9) 275.91,32.79 274.2,32.79 272.55,31.14 272.01,31.14 269.81,28.94 269.43,28.94 v2(268.87,28.39)
  BOTTOM w0.076: UH2.AW44 275.83,33.28 276.01,33.1 v2(276.01,32.9)
SMBDATA: length 7.1
  TOP w0.14: QH4.3 271.79,30.34 RH22.2 273.03,31.58 v1(273.03,31.89) 273.03,32.03 273.34,32.35 273.85,32.35 274.33,31.87 274.87,31.87 275.08,32.08 v2(275.67,32.08)
  BOTTOM w0.076: UH2.BB43 275.82,31.94 v2(275.67,32.08)
SML0_SMBCLK: length 6.8
  BOTTOM w0.076: UH2.AY44 275.63,32.67 275.28,33.02 275.03,33.02 274.75,32.74 274.23,32.74
  BOTTOM w0.14: v1(269.88,31.37) 269.9,31.35 RH62.2 272.09,31.35 273.34,32.6 274.09,32.6 274.23,32.74
SML0_SMBDATA: length 2.9
  TOP w0.14: v2(277.29,31.4) 277.29,31.2 276.59,30.51 RH63.2
  BOTTOM w0.089: v2(277.29,31.4) 277.39,31.4 UH2.BB39
SML0ALERT#: length 5
  TOP w0.14: v2(279.5,33.49) 279.21,33.19 RH64.2 278.41,32.78 v1(278.08,33.11)
  BOTTOM w0.076: v2(279.5,33.49) 279.5,32.81 279.15,32.46
  BOTTOM w0.089: UH2.BA40 279.15,32.46
SML1ALERT#: length 2.5
  TOP w0.14: v1(284.23,34.76) 283.73,34.76 v2(283.57,34.93) 283.57,35.2 RH65.2
  BOTTOM w0.089: UH2.AT27 283.92,34.58 v2(283.57,34.93)
SNB_1.0VS_VGAP: length 2.6
  BOTTOM w0.14: 123.55,95.42 123.97,95.42 125.35,94.03 v1(125.35,93.79)
SNB_GPU1: length 1.8
  TOP w0.14: PR6108.2 178.03,130.85 v4(178.92,129.96)
SNB_GPU2: length 3.3
  TOP w0.14: v1(180.66,142.28) PC6127.1
  TOP w0.508: PC6127.1 178.41,142.28 PR6115.2
SNB_GPU3: length 1.3
  TOP w0.14: v1(181.67,117.78) 181.33,118.13 PR6122.2
SNB_VCCIO: length 1.5
  BOTTOM w0.127: v1(119.98,101.16) 119.86,101.04 119.86,100.04 PC4013.1
SNUB_1.2V: length 2.4
  BOTTOM w0.127: PR202.2 v1(105.45,77.93)
SNUB_1VALWP: length 2
  TOP w0.14: PR104.2 257.4,42.22 v1(256.99,42.64)
SNUB_3V: length 1.6
  TOP w0.14: 63.15,44.82 62.62,44.82 v1(61.89,44.08)
SNUB_5V: length 1.6
  TOP w0.14: v1(62.47,42.62) 62.7,42.4 PC314.1
SPKR: length 90.9
  TOP w0.14: v1(338.57,7.5) 338.57,8.7 D1.3 340.11,9.17 v2(340.17,9.11)
  IN3 w0.124: v2(340.17,9.11) 339.01,9.11 336.04,12.08 336.04,21.39 337.22,22.57 337.22,25.94 335.32,27.84 v2(331.51,27.84)
  IN4 w0.137: v2(285.14,23.09) 285.41,23.36 288.42,23.36 288.68,23.62 290.51,23.62 291.54,22.6 298.89,22.6 299.06,22.43 299.06,22.43 300.51,20.98 304.88,20.98 305.21,21.31 305.21,21.63 306.77,23.2 307.16,23.2 307.63,23.68 307.63,25.61 308.45,26.42 308.81,26.42 310.02,27.63 323.25,27.63 324.35,28.72 328.22,28.72 329.1,27.84 v2(331.51,27.84)
  BOTTOM w0.076: 284.52,28.48 284.52,30.32 284.32,30.52 UH2.BD26
  BOTTOM w0.14: 284.52,28.48 284.52,27.83 RH82.2 285.6,26.74 285.6,25.21 286.23,24.58 286.23,24.02 285.31,23.09 v2(285.14,23.09)
SRN_CHG: length 1.8
  TOP w0.203: PU700.19 34.94,35.57 35.12,35.39 PR726.1
SRP_CHG: length 3.1
  TOP w0.14: v1(36.93,35.12) 36.5,34.69 PR724.1
  TOP w0.203: PR724.1 35.98,35.35 35.34,36 PU700.20
SS: length 3.3
  TOP w0.203: PR6018.1 153.07,135.9 153.29,136.12 153.29,136.14 153.35,136.19 153.36,136.19 153.38,136.21 153.46,136.21 PC6002.2 154.32,137.07 155.18,137.07 155.25,137.14 PU6000.28
SSD_CLK_REQ#: length 27.8
  TOP w0.14: v2(280.91,27.79) 281.09,27.97 v1(281.43,27.97) 281.67,27.97 282.17,27.47 282.17,27.23 282,27.05 RP3.8
  IN2 w0.097: v2(280.53,34.1) 280.53,33.63 280.26,33.35 280.26,32.11 281.18,31.19 281.18,29.32 280.91,29.05 v2(280.91,27.79) 280.91,26.93 278.99,25.01 278.99,22.61 279.5,22.1 279.5,20.35 278.93,19.78 278.93,15.23 279.88,14.28 v2(280.2,14.28)
  BOTTOM w0.089: UH2.AT33 280.66,34.39 280.66,34.22 v2(280.53,34.1)
  BOTTOM w0.14: JNGFF2.52 280.54,13.03 280.2,13.37 v2(280.2,14.28)
SSD_LED#: length 91.6
  TOP w0.127: v1(281.92,23.99) 282.32,23.59 v2(282.61,23.59)
  TOP w0.254: RH502.2 228.11,55.04 228.11,55.43 v2(227.64,55.9)
  IN1 w0.254: v2(282.61,23.59) 282.49,23.71 277.95,23.71 275.6,26.06 275.6,27.44 274.39,28.65 274.39,29.71 271.69,32.41 271.69,35.91 272.58,36.79 272.58,38.45 271.11,39.92 271.11,43.03 271.54,43.47 271.54,51.04 269.22,53.37 269.22,57.11 268.7,57.63 264.37,57.63 262.28,59.72 242.76,59.72 v2(242.04,59)
  IN2 w0.254: v2(242.04,59) 241.15,59 240.6,58.45 239.37,58.45 238.48,59.34 234.72,59.34 231.69,56.31 229.06,56.31 228.36,55.62 227.92,55.62 v2(227.64,55.9)
  BOTTOM w0.254: JNGFF2.10 282.55,23.53 v2(282.61,23.59)
SSD_PCIE_WAKE#: length 3.4
  BOTTOM w0.14: JNGFF2.54 283.46,12.53 RD8.1 283.88,12.61 v1(284.55,12.61)
STRAP0: length 3.9
  TOP w0.089: RG78.1 RG90.2
  TOP w0.114: v2(200.43,80.73) 200.9,80.26 v1(200.9,79.9) 200.9,78.59 RG90.2
  BOTTOM w0.089: UG9.BL3 v2(200.43,80.73)
STRAP1: length 6.5
  TOP w0.114: 199.18,78.19 199.18,80.86 199.41,81.09 v1(199.8,81.09) 200.09,81.09 v2(200.45,81.45)
  TOP w0.14: 199.18,78.19 199.18,78.05 RG79.1 RG91.2
  BOTTOM w0.114: UG9.BL4 v2(200.45,81.45)
STRAP2: length 10.2
  TOP w0.14: v2(199.09,75.36) v1(198.32,75.36)
  BOTTOM w0.089: UG9.BM4 199.24,80.94 199.18,80.94
  BOTTOM w0.14: 199.18,80.94 199.18,80.93 199.18,77.31 199.81,76.67 199.81,75.62 199.56,75.36 v2(199.09,75.36) 198.58,75.36 RG92.2 198.24,75.03 198.24,74.83 RG80.1
STRAP3: length 11.6
  BOTTOM w0.089: UG9.BM5 199.54,81.94 199.18,81.94
  BOTTOM w0.14: 199.18,81.94 197.57,81.94 196.48,80.85 196.48,78.04 197.91,76.61 197.91,75.83 RG93.2 197.72,75 RG81.1
STRAP4: length 4.4
  TOP w0.089: v2(201.15,82.15) 200.3,83 v1(200.05,83) 199.8,83 RG94.2 198.84,81.35 RG82.1
  BOTTOM w0.114: UG9.BK5 v2(201.15,82.15)
STRAP5: length 5.5
  TOP w0.114: RG95.2 RG83.1 202.87,79.74 203.15,80.02 v1(203.15,81.12) 203.15,81.45 v2(202.45,82.15)
  BOTTOM w0.114: UG9.BJ5 v2(202.45,82.15)
SUNB_1.8V: length 1.1
  TOP w0.127: PC18V10.1 v1(272.34,85.56)
SUSCLK: length 130.1
  TOP w0.14: RE106.2 300.44,25.21 v1(299.76,24.53) 298.91,23.68 298.3,23.68 297.92,24.06 295.43,24.06 294.28,22.91 293.36,22.91 292.94,23.32 v2(292.58,23.32) ; RN1.2 342.51,44.49 342.66,44.64 346.22,44.64 347.5,43.36 347.5,40.81 v2(346.27,39.58)
  IN2 w0.097: v2(290.65,36.05) 290.84,36.05 290.91,36.12 291.45,36.12 291.87,35.7 291.87,34.71 292.08,34.51 292.08,31.75 292.27,31.56 292.27,29.75 291.42,28.9 291.42,28.37 291.1,28.04 291.1,23.7 291.47,23.32 v2(292.58,23.32) 292.99,22.92 292.99,19.01 292.33,18.35 292.33,17.73 291.21,16.61 290.84,16.61 290.22,15.99 290.22,10.27 290.66,9.82 293.26,9.82 v2(293.38,9.95)
  IN4 w0.137: v2(290.65,36.05) 290.79,36.19 296.48,36.19 296.99,35.68 296.99,35.3 297.23,35.05 297.99,35.05 298.34,34.7 298.71,34.7 299.56,33.84 299.72,33.84 299.72,33.84 301.26,33.84 302.55,35.13 305.35,35.13 308.49,38.27 318.87,38.27 319.61,37.53 320.63,37.53 320.91,37.82 327.21,37.82 327.64,38.25 329,38.25 330.22,39.47 336.84,39.47 337.36,38.95 339.3,38.95 339.83,39.48 343.01,39.48 343.87,38.63 345.94,38.63 346.27,38.95 v2(346.27,39.58)
  BOTTOM w0.102: v2(290.65,36.05) 290.39,36.05 290.31,36.13 UH2.AN15
  BOTTOM w0.14: v2(293.38,9.95) 293.38,7.56 292.65,6.82 286.3,6.82 285.73,7.39 285.73,8.87 RD9.2
SUSCLK_R: length 5.8
  TOP w0.14: v2(340.97,42.46) 341.29,42.46 RN1.1
  BOTTOM w0.14: JNGFF1.42 338.13,45.55 340.4,43.27 340.4,43.03 v2(340.97,42.46)
SYS_PEX_RST_MON#: length 16.9
  IN1 w0.097: v2(204.02,79.81) 203.39,79.81 203.04,79.45 203.04,79 v2(200.97,76.93)
  IN4 w0.137: v2(196.12,72.74) 196.12,74.7 197.33,75.91 199.95,75.91 v2(200.97,76.93)
  BOTTOM w0.114: v2(204.02,79.81) 204.15,79.94 204.74,79.94 204.95,80.15 UG9.BE2
  BOTTOM w0.14: v2(200.97,76.93) 200.95,76.91 RG537.2 ; DG9.2 195.95,72.56 v2(196.12,72.74) 196.12,73.85 RG21.1
SYS_PWROK: length 170.4
  TOP w0.14: UE1.28 298.27,10.59 297.89,10.96 297.36,10.96 296.53,11.79 296.53,12.6 v2(296.65,12.72) ; v2(241.02,45.81) v4(241.02,46.55) ; RH524.1 v2(196.38,55.89) ; v2(297.66,31.65) 297.66,31.98 RH581.2
  IN1 w0.097: v2(241.02,45.81) 240.51,45.81 232.04,54.28 229.35,54.28 228.79,54.85 226.96,54.85 225.57,56.23 220.09,56.23 219.83,55.97 206.73,55.97 206.21,56.49 196.94,56.49 196.38,55.93 v2(196.38,55.89)
  IN2 w0.097: v2(297.66,31.65) 297.52,31.65 296.41,30.54 296.41,29.54 298.11,27.84 298.11,25.1 297.6,24.59 297.6,22.93 295.78,21.12 295.78,19.65 296.4,19.04 296.4,18.26 296.07,17.93 296.07,15.94 295.95,15.82 295.95,14.63 296.65,13.93 v2(296.65,12.72)
  IN4 w0.137: v2(297.66,31.65) 296.14,31.65 295.79,31.31 294.96,31.31 294.64,30.99 283.05,30.99 281.92,32.12 281.92,32.6 280.9,33.62 280.39,33.62 279.82,34.19 277.95,34.19 277.78,34.37 277.09,34.37 275.89,35.57 273.68,35.57 273.03,36.22 273.03,36.82 273.91,37.71 274.42,37.71 275.23,38.51 275.23,39.36 274.84,39.74 273.8,39.74 267.82,45.73 267.82,57.78 265.89,59.71 249.23,59.71 247.64,58.12 247.64,52.43 v2(241.02,45.81)
  BOTTOM w0.076: v2(297.66,31.65) 297.47,31.85 297.47,32.23 296.93,32.77 UH2.AY1
SYS_RESET#: length 139.3
  TOP w0.14: v2(199.01,65.08) 199.06,65.08 RH532.2 ; v2(297.6,33.18) 297.6,33.18 298.34,32.44 v1(298.34,32.15)
  IN2 w0.097: v2(297.6,33.18) 297.6,33.59 297.94,33.92 297.94,34.21 297.98,34.25 297.98,37.06 298.45,37.53 298.45,38.79 299.86,40.2 299.86,42.67 299.66,42.88 299.66,45.19 301.12,46.65 301.12,52.05 299.18,53.99 296.72,53.99 294.64,56.07 293,56.07 291.77,57.3 291.19,57.3 286.63,61.86 278.76,61.86 275.52,65.1 262.89,65.1 261.05,66.94 233.93,66.94 232.82,65.84 227.55,65.84 227.09,66.3 218.52,66.3 217.95,65.73 209.69,65.73 208.8,64.83 206.13,64.83 205.65,65.31 205.01,65.31 204.63,64.93 203.43,64.93 202.92,65.43 199.45,65.43 199.1,65.08 v2(199.01,65.08)
  BOTTOM w0.089: 298.01,32.71 297.6,33.11 v2(297.6,33.18) 296.94,33.18 296.8,33.32 UH2.AW1
  BOTTOM w0.14: 298.01,32.71 298.36,32.35 298.36,30.81 299.17,30 CH209.1 300.04,29.19 RH193.1
SYSPWR_PRES: length 3.9
  TOP w0.14: v2(303.53,21.62) 304,22.09 UE1.120
  BOTTOM w0.14: RE22.1 RE20.1 303.53,21.15 v2(303.53,21.62) v1(303.53,22.23)
TB_STAT#_CHG: length 15.8
  TOP w0.203: 32.87,34.29 32.87,35.03 33.74,35.9 PU700.16
  TOP w0.254: PQ706.2 40.75,31.62 39.88,30.75 38.67,30.75 38.34,31.08 38.34,31.31 PR722.1 37.91,31.54 37.91,30.97 37.63,30.69 36.41,30.69 35.9,30.18 34.66,30.18 v1(33.63,31.21) 32.87,31.97 32.87,34.29
TBT_A_AUX_N: length 6.1
  TOP w0.14: CT44.2 352.56,47.68 v3(352.92,47.68) 353.16,47.68 353.61,48.13 353.61,49.81 353.86,50.07 353.86,50.64 353.22,51.28 v2(353.18,51.28)
  BOTTOM w0.14: UT1.W15 353.51,50.95 v2(353.18,51.28)
TBT_A_AUX_N_C: length 52.3
  TOP w0.14: v2(343.19,48.86) 343.31,48.99 343.84,48.99 v3(344.51,48.32) 347.04,45.79 351.58,45.79 351.88,46.09 351.88,46.42 CT44.1
  IN1 w0.097: v2(357.01,73.12) 356.77,72.88 355.68,72.88 351.19,68.39 351.19,62.62 349.65,61.08 347.25,61.08 346.62,60.45 344.76,60.45 344.01,59.7 344.01,56.64 342.49,55.11 342.49,49.37 342.78,49.08 342.97,49.08 v2(343.19,48.86)
  BOTTOM w0.076: 358.5,72.3 358.55,72.3 358.82,72.03 359.06,72.03 359.31,71.78 UT4.J2
  BOTTOM w0.14: RT70.2 353.59,73.17 353.69,73.17 354.59,74.07 356.02,74.07 356.63,73.46 356.63,73.23 356.82,73.04 356.93,73.04 v2(357.01,73.12) 357.13,73 357.49,73 357.81,72.68 357.81,72.47 357.98,72.3 358.5,72.3
TBT_A_AUX_P: length 6.1
  TOP w0.14: v2(353.18,50.62) 353.22,50.66 353.41,50.66 353.56,50.51 353.56,50.19 353.3,49.94 v3(353.3,49.28) 353.3,48.26 353.03,47.99 352.43,47.99 352.1,47.65 351.75,47.65 351.43,47.34 CT43.2
  BOTTOM w0.14: UT1.Y15 353.38,50.16 353.26,50.16 353.16,50.26 353.16,50.6 v2(353.18,50.62)
TBT_A_AUX_P_C: length 52.4
  TOP w0.14: CT43.1 351.58,46.4 351.58,46.22 351.45,46.09 347.17,46.09 v3(346.7,46.56) 343.97,49.29 343.08,49.29 342.94,49.43 342.94,49.61 343.05,49.72 v2(343.19,49.72)
  IN1 w0.097: v2(357,72.46) 356.78,72.68 355.76,72.68 351.38,68.3 351.38,62.53 349.73,60.88 347.33,60.88 346.7,60.25 344.84,60.25 344.21,59.62 344.21,56.56 342.69,55.03 342.69,49.46 342.86,49.28 343.32,49.28 343.42,49.38 343.42,49.62 343.33,49.72 v2(343.19,49.72)
  BOTTOM w0.076: 358.5,71.99 358.54,71.99 358.61,71.92 358.61,71.81 358.67,71.75 358.9,71.75 UT4.J1
  BOTTOM w0.14: RT73.1 353.65,72.86 353.81,72.86 354.71,73.76 355.89,73.76 356.32,73.33 356.32,73.1 356.97,72.46 v2(357,72.46) 357,72.6 357.1,72.7 357.37,72.7 357.51,72.56 357.51,72.34 358,71.85 358.2,71.85 358.36,72 358.49,72 358.5,71.99
TBT_A_USB20_L_NB: length 6.1
  TOP w0.14: v2(373.93,70.84) 374.05,70.73 JUSBC1.A7
  BOTTOM w0.14: LT3.3 370.48,70.64 370.6,70.51 371.07,70.51 371.2,70.65 DT10.7 DT10.4 372.71,70.65 372.84,70.53 373.56,70.53 373.74,70.7 373.78,70.7 373.92,70.84 v2(373.93,70.84)
TBT_A_USB20_L_NT: length 8.6
  TOP w0.14: JUSBC1.B7 377.13,69.98 376.94,70.17 376.75,70.17 v2(376.64,70.06)
  IN5 w0.104: v2(376.64,70.06) 376.45,70.26 375.36,70.26 373.62,72 373.47,72 373.37,71.9 v2(373.37,71.83)
  BOTTOM w0.14: LT2.2 370.48,71.66 370.6,71.78 371.07,71.78 371.2,71.65 DT10.8 DT10.2 373.18,71.65 v2(373.37,71.83)
TBT_A_USB20_L_PB: length 6.1
  TOP w0.14: JUSBC1.A6 375.37,70.23 375.11,70.48 374.15,70.48 v2(373.93,70.26)
  BOTTOM w0.14: v2(373.93,70.26) 373.92,70.27 372.8,70.27 372.67,70.15 DT10.5 DT10.6 371.18,70.15 371.07,70.26 370.61,70.26 370.49,70.14 LT3.2
TBT_A_USB20_L_PT: length 8.5
  TOP w0.14: JUSBC1.B6 376.81,70.48 v2(376.64,70.65)
  IN5 w0.104: v2(376.64,70.65) 376.45,70.45 375.44,70.45 373.7,72.19 373.63,72.19 v2(373.39,72.42)
  BOTTOM w0.14: LT2.3 370.48,72.16 370.6,72.04 371.07,72.04 371.18,72.15 DT10.9 DT10.1 372.99,72.15 373.27,72.42 v2(373.39,72.42)
TBT_A_USB20_N: length 35.8
  IN4 w0.147: v2(360.54,74.18) 360.54,74.07 360.65,73.96 360.85,73.96 361,74.11 361,74.34 360.43,74.9 354.95,74.9 345.03,64.99 345.03,60.83 348.42,57.44 350.9,57.44 v2(351.25,57.78)
  BOTTOM w0.076: v2(360.54,74.18) 360.63,74.18 360.84,73.98 360.84,73.17 360.69,73.03 360.69,72.71 360.74,72.63 UT4.K5
  BOTTOM w0.102: UT1.D20 350.94,58.09 v2(351.25,57.78)
TBT_A_USB20_NB: length 14.9
  IN5 w0.104: v2(367.96,70.64) 368.7,70.64 368.96,70.37 368.96,69.65 368.4,69.09 367.69,69.09 366.14,70.63 366.14,72.25 365.43,72.96 364.08,72.96 363.97,72.86 362.2,72.86 361.94,73.12 v2(361.94,73.78)
  BOTTOM w0.076: v2(361.94,73.78) 362.03,73.78 362.09,73.71 362.09,73.41 362.17,73.33 362.17,73.14 362.09,73.07 361.89,73.07 361.84,73.02 361.84,72.89 UT4.L7
  BOTTOM w0.14: LT3.4 368.56,70.64 368.44,70.51 368.08,70.51 v2(367.96,70.64)
