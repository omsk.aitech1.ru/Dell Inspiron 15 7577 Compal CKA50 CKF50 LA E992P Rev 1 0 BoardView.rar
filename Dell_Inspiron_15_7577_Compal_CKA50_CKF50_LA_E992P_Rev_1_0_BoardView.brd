# Allegro board Dell_Inspiron_15_7577_Compal_CKA50_CKF50_LA_E992P_Rev_1_0_BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+1V8_MAIN: length 15.5
  TOP w0.508: LG5.1 v2(199.17,83.32) ; RG512.1 215.53,60.81 v2(215.55,60.79)
  IN4 w0.508: v2(213.97,73.12) 212.75,71.9 212.75,69.96 215.55,67.16 v2(215.55,60.79)
  vias: v1(213.84,82.55) v2(199.5,92.42) v2(205.95,100.25) v2(205.95,98.15) v2(206.65,101.05) v2(206.65,100.25) v2(206.64,98.15) v2(206.65,96.85) v2(206.65,98.95) v2(207.4,101.1) v2(207.41,99) v2(207.4,98.12) v2(207.4,96.9) v2(208.8,87) v2(208.8,86.31) v2(210.1,87) v2(210.15,86.25) v2(210.95,86.25) v2(211,87) v2(212.2,87) v2(212.25,86.25) v2(213.1,87) v2(213.05,86.25) v2(213.59,73.69) v2(214.22,73.69) v2(214.3,87) v2(214.35,86.25) v2(214.61,73.21) v2(214.86,73.82)
+1V_APLLEBB: length 3.9
  TOP w0.127: CH214.1 283.2,42.38 282.6,41.79 v1(282.6,40.93)
  TOP w0.508: v2(283.28,43.16) 283.2,43.09 CH214.1 283.21,42.43 RH544.2
  BOTTOM w0.254: UH2.V28 v2(283.28,43.16)
+1V_B+:
  vias: v1(249.56,44.06)
+1V_MPHY: length 2
  TOP w0.127: v4(281.33,44.26) 282.08,43.51 283.01,43.51
  vias: v2(284.83,43.84) v2(284.86,43.17) v2(285.6,43.94) v2(286.37,43.94)
+1V_MPHY_MPHYPLL: length 5.7
  TOP w0.127: CH180.1 v1(271.91,50.97)
  BOTTOM w0.203: v2(275.55,52.63) 276.04,52.63 v2(276.16,52.52) 276.03,52.39 UH2.A43 276.19,51.88 UH2.B43 275.71,51.05 UH2.C44 275.53,51.19 UH2.C45 274.49,51.19 v2(274.36,51.32)
+1V_PCH: length 147
  TOP w0.508: CH205.1 RH520.1 190.79,64.23 v2(191.05,63.97)
  IN1 w0.508: v2(287.16,37.27) 287.16,37.37 287.67,37.87 288.96,37.87 289.28,38.19 289.28,39.5 v2(289.79,40.01) 289.79,40.32 289.28,40.84 v2(288.7,40.84)
  IN2 w0.508: v2(240.01,59.11) 240.4,59.5 240.4,61.79 240.83,62.21 259.09,62.21 261.39,59.91 269.91,59.91 273.98,55.84 276.05,55.84 277.01,56.8 281.21,56.8 281.87,56.15 281.87,55.15 283.63,53.38 283.63,53.05 283.64,53.04 283.64,52.94 283.99,52.59 284.09,52.59 284.14,52.54 284.15,52.54 285.47,51.23 285.47,51.21 285.48,51.2 285.48,48.84 285.45,48.81 285.45,47.55 285.43,47.53 285.43,47.03 285.45,47.01 285.45,46.93 285.81,46.57 287.54,46.57 v2(288.24,45.88)
  BOTTOM w0.203: v2(287.16,37.27) 287.01,37.42 UH2.AL22
  BOTTOM w0.254: JXDP1.43 200.37,63.67 199.53,64.51 ; v2(288.21,45.2) 288.21,45.82 288.27,45.87 288.27,45.88 ; v2(288.21,45.2) 287.92,45.2 UH2.R19 287.54,44.81 UH2.U20 v2(287.15,43.94) ; v2(288.21,45.2) 288.38,45.03 UH2.R17 ; UH2.AC17 v2(288.7,40.84) ; v2(288.68,43.14) 289.09,43.55 UH2.V17 ; 199.53,64.51 199.46,64.58 198.69,64.58 198.21,64.1 196.83,64.1 196.28,63.55 193.31,63.55 192.89,63.97 v2(191.05,63.97) ; 199.53,64.51 199.87,64.85 199.87,65.37 200.32,65.81 200.32,66.64 200.37,66.69 JXDP1.44 ; 288.27,45.88 288.27,45.94 288.58,46.25 UH2.N17 ; 288.27,45.88 v2(288.24,45.88) ; UH2.AD15 v2(289.79,40.01)
  BOTTOM w0.279: JXDP1.43 200.37,58.71
  BOTTOM w0.508: v2(240.01,59.11) 238.6,57.7 236.68,57.7 236.26,57.28 236.26,50.92 234.01,48.67 214.86,48.67 206.03,57.5 201.59,57.5 200.37,58.71
  vias: v4(291.02,43.55)
+1V_PCH_AZPLL: length 3.3
  TOP w0.127: v2(288.23,36.46) 287.74,36.94 v1(287.74,37.2)
  TOP w0.508: v2(288.23,36.46) 288.34,36.46 288.68,36.79 LH2.2 288.94,35.91 CH203.1
  BOTTOM w0.152: UH2.AN19 288.12,36.46 v2(288.23,36.46)
+1V_PCH_CLK5: length 1.6
  BOTTOM w0.127: RH122.2 302.74,47.01 v1(303.75,48.02)
+1V_PCH_PRIM: length 9.5
  BOTTOM w0.203: UH2.Y23 v2(285.6,42.39) ; v2(285.6,42.39) 285.99,42 UH2.AA23 286.38,41.61 v2(286.38,41.58) 286.02,41.23 UH2.AC23 285.99,41.2 285.62,40.83 v2(285.62,40.8) 285.96,40.45 UH2.AE23 ; v2(285.6,42.39) UH2.Y25 v2(284.83,42.39) UH2.AA26 284.44,41.97 v2(284.83,41.58) 284.47,41.23 UH2.AC26 ; UH2.AC28 283.69,41.23 v2(284.05,41.58) 283.66,41.97 UH2.AA28
  BOTTOM w0.254: v2(284.83,40.8) 284.49,40.45 UH2.AE26 284.35,40.45 284.05,40.75 v2(284.05,40.8) ; v2(284.05,40.8) 284.05,40.84 UH2.AC26 ; v2(284.05,40.8) 284.01,40.8 283.69,41.11 283.69,41.2 UH2.AC28
  vias: v1(284.49,39.87) v2(285.6,38.52) v2(286.37,38.52) v2(287.15,38.52) v2(293.06,42.41) v2(293.81,42.41) v2(294.57,42.41) v2(294.74,45.76)
+1V_PCH_USBPLL: length 2.9
  TOP w0.127: CH202.1 297.14,35.92 v1(298.04,35.92)
  BOTTOM w0.203: UH2.AL5 294.82,37.48 v2(294.65,37.65) 294.82,37.82 UH2.AJ5
+1V_VCCDSW: length 3.5
  TOP w0.127: v1(284.23,36.08) 284.8,36.08 285.05,36.34 RH196.2
  TOP w0.508: v2(286.23,36.54) 286.03,36.34 RH196.2 ; v2(282.6,32.6) 282.52,32.53 CH176.1
  BOTTOM w0.203: v2(282.6,32.6) 282.81,32.39 UH2.BA29
+1VALW: length 63.9
  TOP w0.508: RH123.1 292.49,36.85 v2(292.13,36.85) 292.08,36.79 LH2.1
  IN3 w0.508: v2(292.25,47.78) 293.12,47.78 293.54,48.2 294.51,48.2 294.87,47.84 296.02,47.84 297.05,46.81 303.35,46.81 303.45,46.71 304.75,46.71 v2(304.92,46.55) ; v2(292.13,36.85) 296.45,36.85 296.57,36.97 297.91,36.97 298.31,36.57 298.31,35.85 298.78,35.38 299.43,35.38 301.13,37.08 v2(305.7,37.08)
  BOTTOM w0.508: RH122.1 304.25,46.71 304.75,46.71 v2(304.92,46.55) 304.92,46.52 305.31,46.13 305.31,42.79 305.44,42.66 305.44,41.37 305.46,41.35 305.46,40.72 306.41,39.76 306.41,37.79 v2(305.7,37.08) 305.7,34.09 309.89,29.9 312.46,29.9 313.22,29.14 313.22,26.43 314,25.66 314,22.33 RE116.1
  vias: v2(183.02,107.22) v2(183.3,107.75) v2(183.63,107.24) v2(183.94,107.75) v2(266.61,43.04) v2(266.61,42.46) v2(266.61,41.87) v2(266.61,41.24) v2(266.61,40.6) v2(266.61,39.97) v2(267.25,43.04) v2(267.25,42.46) v2(267.25,41.87) v2(267.25,41.24) v2(267.25,40.6) v2(267.25,39.97) v2(278.93,56.19) v2(278.93,55.6) v2(278.93,55.02) v2(279.8,53.88) v2(280.01,54.51) v2(280.39,56.08) v2(280.51,54.14) v2(280.96,55.72) v2(284.25,53.2) v2(284.29,54.99) v2(285.54,52.07) v2(291.85,46.09) v4(279.82,57.52)
+1VALWP: length 12.8
  TOP w0.254: v2(253.66,36.48) 253.53,36.48 253.39,36.34 PC114.1 PR106.1
  IN1 w0.254: v2(253.66,36.48) 253.85,36.29 258.48,36.29 262.23,40.03 v2(262.23,40.95)
  vias: v2(262.23,42.7) v2(262.23,42.12) v2(262.23,41.53) v2(262.81,42.7) v2(262.81,42.12) v2(262.81,41.53) v4(261.34,42.83)
+2.5V_MEM: length 116.9
  BOTTOM w1.016: 245.72,44.48 245.72,45.77 244.58,46.92 239.71,46.92 238.67,45.88 179.17,45.88 177.59,44.29 177.59,41.68 176.57,40.67 173.65,40.67 172.38,41.94 172.38,43.14
  BOTTOM w1.524: 170.47,42.32 170.47,41.99 170.57,41.89 170.57,40.97 170.64,40.97 173.82,37.79 173.82,35.35 170.28,31.8 165.95,31.8 165.62,32.13 162.1,32.13 160.78,30.81 160.78,26.42 161.97,25.23 161.97,23.84 163.49,22.32 166.09,22.32 166.16,22.38
  vias: v2(170.49,43.75) v2(171.08,43.73) v2(247.75,43.4) v2(247.75,42.76) v2(247.75,42.13) v4(172.15,44.94)
+2.5V_MEMP: length 0.9
  TOP w0.127: v2(162.15,28.6) v4(161.21,28.6)
+3.3V_ANA_PCIE: length 2.4
  TOP w0.127: v1(350.81,55.48) 350.97,55.63 CT85.1
  TOP w0.305: v2(352.54,55.17) 352.47,55.17 352.01,55.63 CT85.1
  BOTTOM w0.254: v2(352.54,55.17) UT1.L16
+3.3V_ANA_USB2: length 2.2
  TOP w0.127: v1(352.44,56.34) 352.63,56.34 353.11,55.86 CT86.1
  TOP w0.356: v2(353.19,55.17) 353.28,55.26 CT86.1
  BOTTOM w0.254: UT1.J16 v2(353.19,55.17)
+3.3V_FLASH: length 100.3
  TOP w0.127: v2(361.75,44.8) v4(361.75,45.53)
  TOP w0.508: v2(364.27,46.37) 363.86,46.37 363.51,46.71 363.51,47.72 v2(363.77,47.97)
  IN1 w1.016: 363.04,97.91 361.85,96.71 361.85,89.16
  IN2 w0.508: v2(361.75,44.8) 361.44,44.8 357.22,40.57 v2(356.24,40.57) ; v2(363.77,47.97) 364.31,47.97 364.76,48.42 364.76,49.96 363.7,51.02 363.7,52.76 363.67,52.8 363.67,53.93 362.06,55.53 362.06,65.48 362.71,66.13 362.71,67.67 363.53,68.48 364.25,68.48 v2(367.22,71.45)
  IN3 w0.508: v2(364.86,81.31) 364.12,81.31 355.97,73.15 355.97,70.69 v2(355.22,69.94) ; v2(364.27,46.37) 363.06,46.37 361.75,45.06 v2(361.75,44.8)
  IN4 w0.508: v2(362.88,88.34) 362.46,87.92 362.46,83.71 v2(364.86,81.31) 365.46,80.71 365.46,73.8 367.22,72.04 v2(367.22,71.45)
  BOTTOM w0.229: v2(355.22,69.94) 356.4,69.94 357.16,70.7 358.86,70.7 UT4.G1
  BOTTOM w0.254: 354.43,69.43 354.94,69.94 v2(355.22,69.94)
  BOTTOM w0.356: RT127.2 RT125.2 RT126.2 362.56,88.66 v2(362.88,88.34) ; v2(367.22,71.45) 367.22,70.95 RT74.1 ; CT45.1 RT51.1
  BOTTOM w0.508: v2(356.24,40.57) 355.96,40.29 UT2.8 ; RT48.1 v2(364.27,46.37) ; RT51.1 v2(361.75,44.8) ; RT49.2 RT50.2 362.62,47.48 363.12,47.97 v2(363.77,47.97)
  vias: v2(363.58,98.71) v2(364.07,98.31)
+3.3V_LC: length 46.7
  TOP w0.356: v2(360.4,48.86) 359.8,48.86 v4(359.74,48.92) 359.51,49.15 RT8.1
  TOP w0.381: CT46.1 357.13,52.51 v2(357.08,52.56)
  IN2 w0.508: v2(360.4,48.86) 360.64,48.86 361.77,49.99 361.77,52.82 361.23,53.37 361.23,56.92 360.36,57.79 360.36,60.92 360.4,60.96 360.4,63.91 360.86,64.37 360.86,65.66 360.26,66.26 359.22,66.26 358.88,66.6 358.88,66.61 358.81,66.67 358.81,67.34 359.28,67.81 359.28,72 360.02,72.74 363.01,72.74 364.47,74.2 364.47,76.04 v2(366.07,77.64)
  IN5 w0.508: v2(360.4,48.86) 358.89,48.86 358.02,49.72 356.87,49.72 356.46,50.13 356.46,51.08 357.19,51.81 357.19,52.44 v2(357.08,52.56)
  BOTTOM w0.203: UT1.R6 v2(357.08,52.56)
+3.3V_TBT_S0: length 2.2
  TOP w0.127: CT48.1 361.38,54.13 v1(361.68,53.83)
  BOTTOM w0.254: v2(353.86,52.56) 354.16,52.87 UT1.R13
  vias: v2(361.24,58.26)
+3.3V_TBT_SX: length 58.7
  TOP w0.356: CT47.1 357.52,58.63 RT32.1 357.61,58.54 357.61,57.51 357.63,57.48 357.63,57.05 RT94.1
  TOP w0.381: RT94.1 357.6,57.03 357.18,57.03 v2(357.08,57.14) ; CT47.1 357.52,59.73 357.32,59.94 357.32,60.49 RT97.2
  TOP w0.508: v2(363.13,58) 363.13,57.46 v4(363.41,57.18)
  IN1 w0.508: v2(359.77,62.32) 359.77,62.39 360.39,63.01 361.23,63.01 361.74,62.5 361.74,61.57 362.56,60.75 362.56,58.58 v2(363.13,58)
  IN3 w0.508: v2(354.51,72.31) 353.45,73.37 v2(351.89,73.37) ; v2(357.08,57.14) 357.09,57.13 357.31,57.13 357.7,57.52 357.7,57.94 358.15,58.39 359.32,58.39 360.53,57.18 361.72,57.18 362.55,58 v2(363.13,58) 363.13,56.87 363.42,56.58 v2(363.42,55.42) 363.42,53.39 364.09,52.72 364.95,52.72 v2(364.96,52.73)
  IN4 w0.508: v2(354.51,72.31) 354.51,71.95 353.52,70.96 352.59,70.96 351.96,70.32 351.96,68.54 352.39,68.11 353.24,68.11 357.86,63.49 359.12,63.49 359.77,62.84 v2(359.77,62.32)
  BOTTOM w0.254: UT1.F8 357.08,57.11 v2(357.08,57.14)
  BOTTOM w0.305: RT28.1 363.45,52.01 363.68,52.24 363.68,52.48
  BOTTOM w0.356: RT61.2 355.05,72.31 v2(354.51,72.31) ; RT26.1 363.68,52.48 364.72,52.48 364.96,52.72 v2(364.96,52.73) ; v2(351.89,73.37) RT70.1 ; RT30.1 362.73,58.19 362.92,58 v2(363.13,58) ; v2(363.42,55.42) 363.18,55.18 362.26,55.18 RT31.1 ; RT80.1 RT86.1 v2(359.77,62.32) ; RT29.1 363.01,51.53 363.23,51.76 RT28.1
  BOTTOM w0.381: RT33.1 362.27,56.87 363.04,56.87 363.36,56.55 363.36,56.52 363.42,56.45 v2(363.42,55.42) ; RT27.1 RT26.1
+3.3V_TBT_SX_R: length 4.8
  BOTTOM w0.076: UT4.H2 359.44,71.28 359.19,71.53 358.69,71.53
  BOTTOM w0.152: CT102.1 RT61.1 356.12,72.35 356.71,71.77 v1(356.86,71.77) 357.07,71.77 357.31,71.53 358.69,71.53
+3.3VDX_SSD: length 11.3
  BOTTOM w0.508: RD7.1 284.86,17.16 283.63,18.39 283.63,19.11 282.6,20.14 282.6,21.44 ; 279.22,10.05 283.07,10.05 283.63,10.61 RD8.2
  vias: v2(277.86,21.64) v2(277.86,21.06) v2(278.45,21.64) v2(278.45,21.06) v2(279.03,21.64) v2(279.03,21.06) v4(276.45,21.25) v4(278.3,23.17) v4(278.36,19.15)
+3V3_SYS: length 228.6
  TOP w0.508: v2(214.66,60.5) 214.14,61.03 RG514.1
  IN2 w0.508: v2(208.11,58.84) 211.67,58.84 213.33,60.5 v2(214.66,60.5)
  IN4 w0.508: v2(214.66,60.5) 215.19,59.97 216.14,59.97 218.67,62.5 218.67,63.62 219.56,64.51 219.56,69.05 220.77,70.26 v2(223.88,70.26)
  IN5 w0.508: v2(123.7,94.53) 123.69,94.52 123.08,94.52 122.04,93.47 122.04,88.14 122.54,87.63 122.54,59.15 141.37,40.33 141.37,35.89 142.6,34.66 166.59,34.66 166.91,34.98 168.19,34.98 168.36,35.16 171.63,35.16 172.06,34.73 177.84,34.73 177.94,34.62 225.3,34.62 226.64,35.97 229.02,35.97 229.62,36.56 229.62,42.88 231.76,45.02 231.76,50.68 v2(230.93,51.51)
  BOTTOM w0.381: UG11.4 224.88,72.08 224.46,71.65 224.32,71.65 223.87,71.2 223.87,70.97 CG61.1
  BOTTOM w0.508: CG61.1 v2(223.88,70.26) 223.88,69.81 226.49,67.21 228,67.21 229.17,66.04 229.17,61.78 226.4,59.01 226.4,53.88 227.76,52.52 229.93,52.52 v2(230.93,51.51) ; v2(123.7,94.53) PR10V1.1
  vias: v1(207.34,59.32)
+3V_DVDD: length 2.1
  TOP w0.203: HDA1.9 340.41,19.06 339.64,18.29
  vias: v1(339.88,15.42) v2(339.26,17.68) v2(339.26,17.05) v2(339.38,22.7) v2(340.02,22.7)
+3V_FPSW: length 18.9
  BOTTOM w0.508: C5235.1 226.4,26.27 225.49,25.36 RW4.2 225.08,24.63 225.08,23.4 224.68,22.99 223.11,22.99 222.61,23.5 v2(222.61,23.74) D5223.2 221.88,26.15 221.41,25.68 221.41,23.15 220.78,22.52 216.87,22.52 216.02,23.37
+3V_HDA: length 6.7
  TOP w0.127: v4(291.52,36.12) 291.83,35.8 291.83,34.74 292.16,34.41 292.16,33.54 292.02,33.4 RH543.2
  TOP w0.508: RH543.2 292.02,32.54 291.15,31.66 CH213.1 290.69,31.92 290.69,32.28 v2(290.66,32.31)
  BOTTOM w0.203: UH2.BA15 290.51,32.34 290.54,32.31 v2(290.66,32.31)
+3V_PCH_AZIO: length 3.5
  TOP w0.127: RH543.1 v1(291.11,33.94)
  TOP w0.508: LH1.2 290.05,31.64 290.05,32.61 289.96,32.7 CH200.1 289.97,32.92 RH543.1
+3V_PCH_DSW: length 128.8
  TOP w0.508: v2(250.04,32.79) v1(250.04,30.83) 251.05,29.81 252.21,29.81 252.81,29.21 v2(252.81,28.77) ; v2(205.91,55.91) 205.91,56.1 204.97,57.04 RH529.1 ; v2(290.16,42.42) 290,42.58 CH82.1
  IN3 w0.508: v2(252.81,28.77) 253.95,27.63 255.98,27.63 262.16,21.45 263.66,21.45 263.99,21.78 264.83,21.78 265.25,22.2 268.49,22.2 269.05,22.76 271.04,22.76 271.87,21.94 276.33,21.94 276.71,22.32 279.25,22.32 279.83,21.74 283.5,21.74 283.99,21.25 288.14,21.25 289.17,22.28 289.62,22.28 v2(290.44,23.09)
  BOTTOM w0.203: UH2.BA24 285.32,32.39 v2(285.73,32.8) ; UH2.W15 290.16,42.64 v2(290.16,42.42)
  BOTTOM w0.508: v2(289.29,23.13) 289.55,23.38 RH17.2 289.24,23.89 288.99,24.15 RH81.2 ; v2(205.91,55.91) 205.91,55.75 201.84,51.69 201.84,47.91 203.01,46.74 238.29,46.74 239.33,47.78 247.88,47.78 249.72,45.94 249.72,36.22 250.04,35.91 v2(250.04,32.79) ; v2(290.44,23.09) 290.49,23.14 RH181.2
+3V_PCH_SPI: length 16.3
  IN3 w0.508: v2(276.95,29.94) 276.92,29.94 276.85,29.87 276.85,28.78 276.35,28.27 274.49,28.27 273.75,29.01 273.75,29.85 272.84,30.76 272.01,30.76 270.1,32.67 268.26,32.67 v2(267.87,32.27)
  BOTTOM w0.127: v2(267.87,32.27) 267.31,32.27 v1(266.94,32.64)
  BOTTOM w0.203: UH2.BE43 UH2.BE42 UH2.BE41 277.03,30.01 v2(276.95,29.94)
  BOTTOM w0.508: RH493.2 268.55,32.27 v2(267.87,32.27)
+3V_ROM: length 140.2
  TOP w0.14: v4(304.43,39.91) v2(303.57,39.91)
  TOP w0.508: v2(198.18,64.76) 197.96,64.76 197.8,64.61 RH540.1 ; v2(303.57,39.91) 303.57,39.03 303.04,38.5 301.46,38.5 301.16,38.8 RH121.1 300.66,39.89 RH74.1 300.2,39.44 v2(300.39,39.25)
  IN2 w0.508: v2(303.57,39.91) 303.99,40.33 303.99,47.6 305.42,49.03 305.45,49.03 305.81,49.39 305.81,49.42 305.83,49.44 305.83,52.4 304.95,53.28 302.41,53.28 302.01,53.68 301.38,54.32 300.5,54.32 299.93,54.32 299.63,54.61 299.52,54.61 299.46,54.68 297.44,54.68 293.47,58.64 291.25,58.64 288.15,61.74 288.15,62.1 287.59,62.67 278.92,62.67 275.8,65.79 263.17,65.79 261.33,67.63 233.64,67.63 232.54,66.52 227.83,66.52 227.37,66.98 214.51,66.98 214.1,66.58 212.27,66.58 211.84,67 198.46,67 197.78,66.32 197.78,65.17 v2(198.18,64.76)
  BOTTOM w0.508: v2(300.39,39.25) 300.2,39.06 UH8.8
+3V_RTM: length 63.9
  TOP w0.203: CP26.1 330.3,50.5 330.3,48.4 330.74,47.97 331.28,47.97 331.52,47.73 331.65,47.73 331.85,47.93 UP2.24 ; UP2.1 337.44,43.04 338.57,41.91 339.22,41.91 CP25.1 v2(339.26,42.51) 339.47,42.51 RP33.1
  TOP w0.508: CP26.1 CP24.1 329.91,52.78 RP28.1 328.21,54.64 325.03,54.64 324.52,54.13 324.52,53.04 325.02,52.54 RP37.1 RP49.2 RP48.2 326.37,50.76 325.86,50.26 325.86,46.7 326.61,45.95 326.61,44.71 v1(326.18,44.28) 326.24,44.21 326.24,42.85 v2(326.31,42.78) 326.31,42.97 327.19,43.84 RP35.1 RP38.1 ; RP34.1 342.43,48.11 v2(342.43,48.73)
  IN3 w0.508: v2(342.43,48.73) 342.43,47.72 341.61,46.89 339.32,46.89 338.52,46.09 338.52,44.8 339.26,44.06 v2(339.26,42.51) 338.62,41.87 331.2,41.87 329.79,40.47 v2(329.35,40.47) 328.7,41.11 328.7,41.84 327.61,42.93 326.47,42.93 v2(326.31,42.78)
  BOTTOM w0.508: v2(329.35,40.47) 329.22,40.59 RP24.2 ; RP25.2 RP24.2 ; RP24.2 RP36.1
+3V_TPM: length 13.8
  IN5 w0.508: v2(291.87,17.85) 290.89,16.87 289.42,16.87 288.01,15.46 286.61,15.46
  BOTTOM w0.254: CTPM6.1 292.52,18.49 v2(291.87,17.85) 291.43,17.4 UTPM1.22
  BOTTOM w0.508: RTPM10.1 290.84,7.8 288.53,7.8 287.92,8.41 287.92,8.8 QTPM1.3
  vias: v2(285.19,11.2) v2(285.19,10.57) v2(285.98,14.67) v2(285.98,14.09) v4(285.95,12.88)
+3V_USBRD: length 57.2
  TOP w0.14: v4(20.31,48.89) 16.09,48.89 15.49,49.48 v2(15.49,49.62)
  IN2 w0.508: v2(15.49,49.62) 15.62,49.49 15.62,48.06 v2(15.41,47.84) 15.32,47.84 14.61,47.13 14.61,46.47 15.01,46.07 v2(15.41,46.07) 15.41,45.08 13.92,43.59 v2(13.44,43.59) ; v2(15.04,52.29) 15,52.33 15,52.34 14.86,52.48 13.16,52.48 v2(12.47,53.17) 8.15,53.17 6.2,51.21 4.8,51.21 v2(3.79,52.23) 3.15,52.23 2.71,51.78 2.71,49.49 v2(3.79,48.42) 3.79,47.72 3.28,47.21 3.28,46.12 v2(4.47,44.92) 5.31,44.92 5.83,45.44 v2(6.08,45.44)
  BOTTOM w0.254: UI3.13 7.08,48.12 6.71,47.74 6.71,47.26 ; 11.96,51.48 11.96,50.78 11.8,50.62 UI3.1
  BOTTOM w0.508: v2(15.41,47.84) RI16.2 ; v2(6.08,45.44) CI4.1 6.71,47.26 ; RI17.2 RI22.2 v2(3.79,52.23) ; v2(13.44,43.59) RI20.2 ; RI15.2 v2(15.04,52.29) 15.66,52.29 RI67.2 RI59.2 15.79,49.92 v2(15.49,49.62) RI19.2 ; v2(3.79,48.42) RI21.2 RI18.2 ; RI24.2 v2(4.47,44.92) ; v2(12.47,53.17) 12.22,53.42 CI3.1 11.6,51.84 11.96,51.48 ; v2(15.41,46.07) RI12.1
+3VALW: length 862.1
  TOP w0.254: 252.32,38.43 252.07,38.43 251.82,38.68 PU100.15
  TOP w0.381: v2(299.21,29.02) 299.37,28.87 UZ21.5 ; UC16.5 179.75,78.5 179.19,77.93 CC298.1
  TOP w0.406: RE150.2 291.86,10.73 291.63,10.51 v2(291,10.51)
  TOP w0.483: v2(277.32,41.18) 277.6,41.18 277.95,41.53 CH190.1
  TOP w0.508: 321.58,17.02 321.5,17.1 321.5,17.97 RE25.1 ; 321.58,17.02 v2(322.26,17.7) ; 321.58,17.02 RE12.1 ; v2(268.82,27.78) 267.74,27.78 RH21.1 ; v2(279.31,74.45) 279.31,71.53 274.23,66.45 267.65,66.45 261.86,60.66 261.86,50.12 260.6,48.86 258.89,48.86 258.2,48.17 258.2,44.81 259.49,43.53 262.99,43.53 263.58,42.94 263.58,39.61 263.12,39.16 v2(262.45,39.16) ; v2(276.33,31.39) 276.41,31.39 277.1,32.08 278.99,32.08 RH64.1 RH568.1 ; RZ96.1 277.34,36.6 v2(277.41,36.67) ; LH1.1 288.83,30.78 CH187.1 288.72,30.89 288.72,31.71 288.84,31.83 CH186.1 288.51,31.99 v2(288.15,32.34) ; v2(344.5,7.33) 344.89,7.72 RA17.2 ; PR206.1 v2(115.43,71.85) ; RH521.1 195.43,55.88 194.81,55.27 192.59,55.27 192.31,55.55 v2(192.31,55.9) ; RTH1.1 161.77,87.38 v2(161.77,87.72) ; v2(24.09,56.38) 26.23,58.51 v4(37.09,58.51) PR2.2 ; v2(303.05,40.26) 302.55,39.77 RH121.2 ; v2(37.31,34.7) 37.75,34.7 PR714.2 PR713.1 38,32.57 PR722.2 ; CH190.1 278.01,41.79 280.29,41.79 280.65,41.43 CH191.1 281.95,39.61 281.95,38.51 281.09,37.65 v2(281.09,36.6) RH130.1 RH65.1 ; RH66.1 RH63.1 CH192.1 273.8,31.38 v2(273.72,31.46) ; CH189.1 293.93,34.97 v2(294.45,35.49) ; CC298.1 178.07,77.93 v2(177.48,77.35) ; v2(267.77,31.02) 268.16,31.41 RH22.1 ; RH68.2 v2(269.25,41.81) ; v2(254.29,36.79) 254.29,37.11 254.22,37.19 PC108.1 254.13,37.58 PR108.1 252.32,38.43 ; PR6034.1 v2(164.76,130.08)
  IN1 w0.508: v2(279.31,74.45) 276.71,74.45 271.31,79.85 268.45,79.85 v2(268.14,80.17) ; v2(177.48,77.35) 178.7,77.35 180.65,75.4 180.65,70.62 181.18,70.09 181.18,68.85 184.66,65.37 185.6,65.37 189.33,61.64 189.33,60.23 192.31,57.25 v2(192.31,55.9) ; v2(164.76,130.08) 164.01,129.33 164.01,125.83 163.34,125.16 163.34,123.99 162.73,123.38 162.73,116.74 162.09,116.11 152.19,116.11 151.55,115.47 150.47,115.47 149.71,116.23 138.98,116.23 137.57,114.82 137.57,110.6 133.75,106.78 133.75,105.88 132.38,104.51 129.86,104.51 v2(129.69,104.68)
  IN2 w0.508: v2(294.91,18.89) 294.91,16.42 293.66,15.18 293.66,12.66 291.5,10.51 v2(291,10.51) ; v2(344.91,29.49) 343,29.49 342.3,28.79 339.07,28.79 337.92,27.65 337.92,9.06 339.65,7.33 v2(344.5,7.33) ; v2(20.45,52.01) 19.92,52.54 v2(18.38,52.54) 17.48,52.54 16.61,51.68 16.61,44.94 15.65,43.97 15.65,36.76 v2(10.58,31.69) ; v2(134.39,28.45) 140.04,34.1 171.45,34.1 v2(172.82,32.73)
  IN2 w0.762: 267.54,80.84 265.89,82.49 265.89,86.74 266.64,87.49 266.64,120.51 258.46,128.69 258.46,136.2 256.5,138.15 256.5,138.71
  IN2 w1.016: 354.24,67.78 354.24,66.39 355.72,64.91 357.05,64.91 358.12,63.85 358.12,63.21 ; 37.82,33.68 37.82,32.41 39.38,30.85 43.14,30.85 45.01,28.98 55.67,28.98 56.66,27.99
  IN3 w0.508: v2(295.87,4.49) 299,4.49 299.86,5.35 300.66,5.35 301.52,4.49 308.42,4.49 311.35,7.42 312.57,7.42 313.55,8.4 313.55,10.02 v2(312.95,10.62) 313.11,10.77 313.61,10.77 316.1,13.26 317.01,13.26 317.5,13.76 319.49,13.76 320.13,14.39 320.13,15.64 322.19,17.7 v2(322.26,17.7) 322.34,17.62 325.04,17.62 326.9,15.76 328.22,15.76 336.65,7.33 v2(344.5,7.33) ; v2(115.43,71.85) 114.56,70.97 114.56,66.6 113.58,65.62 97.19,65.62
  IN3 w2.032: 122.16,102.34 122.16,99.16 120.77,97.77 118.45,97.77 116.47,95.79 116.47,93.68 115.05,92.26 115.05,87.99 111.93,84.86 109.89,84.86 107.79,82.76 107.79,80.27 105.42,77.9 105.42,75.29 103.8,73.66 98.68,73.66 97.63,72.61 97.63,70.81 97.19,70.37 97.19,65.62 96.09,64.52 94.13,64.52 93.63,64.01 83.61,64.01 81.32,61.72 81.32,54.32
  IN4 w0.508: v2(144.82,87.21) 145.67,87.21 147.21,85.67 151.04,85.67 151.52,86.15 151.52,87.12 152.12,87.72 158.41,87.72 159.49,86.64 160.76,86.64 161.52,87.4 161.52,87.47 v2(161.77,87.72) 161.77,86.83 163.3,85.31 163.3,84.04 164.25,83.09 164.25,82.45 ; 165.33,81.69 170.85,81.69 171.49,81.05 174.85,81.05 175.36,80.55 175.36,79.47 v2(177.48,77.35)
  IN4 w1.016: 73.7,49.37 73.7,46.64 72.49,45.43 72.49,39.72 66.46,33.68 64.67,33.68 62.93,31.94 62.93,30.74 61.91,29.72 61.14,29.72 59.48,28.06 59.48,27.85 ; 36.17,34.57 34.71,33.11 27.19,33.11 26.54,33.76 23.84,33.76 19.85,37.75 19.85,40.06 17.58,42.33 17.58,47.79 21.31,51.53
  IN5 w0.508: v2(129.69,104.68) 130.34,104.68 130.79,104.23 133.7,104.23 137.14,100.8 137.14,96.23 137.83,96.23 139.17,94.9 139.17,93.74 136.43,90.99 136.43,90.1 135.66,89.34 135.66,88.42 136.17,87.91 138.15,87.91 139.04,88.8 143.23,88.8 v2(144.82,87.21) ; v2(303.05,40.26) 302.09,39.3 301.34,39.3 299.34,37.3 298.53,37.3 298.24,37.01 296.28,37.01 294.76,35.49 v2(294.45,35.49)
  IN5 w1.016: 311.13,25.94 312.08,25.94 313.41,24.6 313.41,23.59 312.78,22.95 310.24,22.95 309.67,22.38 ; 345.16,28.54 338.07,28.54 335.06,31.55 331.94,31.55 330.01,29.62 330.01,27.84 328.99,26.83 323.32,26.83 322.39,27.75 311.06,27.75
  BOTTOM w0.203: UH2.BC42 276.64,31.08 v2(276.33,31.39) 276.27,31.45 275.71,31.45 UH2.BC44 275.33,31.43 UH2.BC45 ; UH2.AJ41 277.05,38.11 277.34,37.82 277.34,37.82 v2(277.41,37.75) ; UH2.BC45 273.91,31.27 v2(273.72,31.46) ; UH2.BC45 UH2.BB45 UH2.BA45
  BOTTOM w0.254: UH2.AL41 277.1,37.04 277.41,36.73 v2(277.41,36.67) ; UH2.BC42 276.94,30.77 277.38,30.77 UH2.BD40 ; v2(277.32,41.18) 277.32,40.83 UH2.AD41
  BOTTOM w0.305: v2(288.15,32.34) UH2.BA20 ; v2(294.45,35.49) 294.45,35.74 UH2.AN5
  BOTTOM w0.508: v2(24.09,56.38) CL39.1 24.09,55.4 24.53,54.96 UL2.5 ; RI67.1 17.57,52.54 v2(18.38,52.54) ; RH92.1 RH82.1 v2(285.07,25.59) ; RE30.2 314.05,10.62 v2(312.95,10.62) ; RTPM10.2 291,9.08 290.86,9.22 RTPM1.2 290.86,10.37 v2(291,10.51) ; v2(299.21,29.02) 299.21,28.6 299.64,28.17 RH193.2 ; v2(267.77,31.02) 268.02,30.76 RH493.1 269.41,30.76 269.74,30.43 RH62.1 272.19,30.43 273.22,31.46 v2(273.72,31.46) ; RL41.2 21.34,51.12 v2(20.45,52.01) ; v2(134.39,28.45) 134.57,28.27 RZ33.1 RZ32.2 134.52,27.41 134.47,27.46 132.37,27.46 131.87,26.95 UE4.5 ; PR25V02.1 173.03,32.53 v2(172.82,32.73) ; RH91.1 v2(271.25,37.37) ; PR4008.2 v2(129.69,104.68)
  BOTTOM w0.762: 254.8,139.79 250.61,143.98 216.84,143.98
  vias: v2(21.58,52.17) v2(36.93,34) v2(57.71,27.89) v2(58.29,27.89) v2(70.71,51.78) v2(70.71,51.08) v2(70.71,50.38) v2(71.3,51.78) v2(71.3,51.08) v2(71.3,50.38) v2(71.88,51.78) v2(71.88,51.08) v2(71.88,50.38) v2(72.47,51.78) v2(72.47,51.08) v2(72.47,50.38) v2(73.08,51.78) v2(73.08,51.08) v2(73.08,50.38) v2(73.76,51.78) v2(73.76,51.08) v2(73.76,50.38) v2(86.02,54.96) v2(86.65,54.96) v2(88.37,54.7) v2(89.45,56.26) v2(126.4,101.43) v2(126.79,100.94) v2(126.79,100.36) v2(126.81,99.77) v2(176.95,33.49) v2(176.96,32.88) v2(215.98,144.03) v2(215.96,143.45) v2(256.06,139.36) v2(256.69,139.36) v2(263.12,30.32) v2(263.12,29.73) v2(263.12,29.15) v2(263.7,30.32) v2(263.7,29.73) v2(263.7,29.15) v2(264.01,28.6) v2(264.29,30.32) v2(264.29,29.73) v2(264.29,29.15) v2(268.39,80.8) v2(270.17,44.5) v2(295.92,29.92) v2(305.66,12.79) v2(306.3,12.79) v2(308.79,21.73) v2(308.97,21.17) v2(310.71,26.85) v2(311.29,26.85) v2(312.97,18.76) v2(343.64,37.7) v2(343.64,37.11) v2(345.54,29.49) v2(352.96,68.72) v2(353.22,69.24) v2(357.81,62.39) v2(358.42,62.28) v4(83.24,56.01) v4(344.2,37.47)
+3VALW_EC: length 107.1
  TOP w0.127: v4(316.82,6.94) 316.82,7.55 v2(316.07,8.29)
  TOP w0.203: v2(305.75,21.58) 305.94,21.77 305.94,22.09 306,22.14 UE1.115 ; UE1.19 300.54,14.19 301.13,14.77 301.64,14.77 301.94,14.47 301.94,14 300.74,12.79 v2(300.46,12.79) 300.26,12.99 UE1.22 ; v2(310.94,21.62) 310.8,21.75 UE1.103 ; v2(316.02,8.9) 315.93,8.99 UE1.65 ; v2(305.09,6.14) 305.08,6.14 304.8,6.42 UE1.43 ; 300.41,20.05 300.15,19.79 UE1.5 298.22,19.79 297.89,19.46 v2(297.89,19.3) ; v2(316.14,16.17) 315.76,15.79 UE1.82
  TOP w0.508: CE62.1 316.76,16.79 v2(316.14,16.17) ; RE139.2 319.32,18 320.14,17.17 RE12.2 CE89.1 320.14,14.15 v2(319.01,13.02) ; v2(307.31,28.79) 307.61,28.5 CE81.1 307.99,27.69 308.37,27.69 308.78,27.28 RE13.1 ; v2(318.5,20.64) RE140.2 ; 300.41,20.05 304.22,20.05 v2(305.75,21.58) ; RE130.1 293.96,7.1 RE53.2 294.64,8.05 295.07,8.49 v2(295.44,8.49) 295.94,8.49 296.38,8.04 RE141.2
  IN2 w0.508: v2(295.44,8.49) 296.05,8.49 297.45,9.88 298.08,9.88 299.52,11.32 299.52,11.85 v2(300.46,12.79)
  IN3 w0.508: v2(318.5,20.64) 318.5,20.34 318.1,19.93 312.13,19.93 310.94,21.12 v2(310.94,21.62) ; v2(295.44,8.49) 296.98,6.95 304.55,6.95 305.09,6.4 v2(305.09,6.14)
  IN5 w0.508: v2(305.75,21.58) 305.83,21.58 307.13,20.28 309.16,20.28 310.49,21.62 v2(310.94,21.62)
  BOTTOM w0.508: CE68.1 v2(316.7,9.52) 317.52,9.52 RE119.2 ; v2(327.61,11.92) 327.17,12.36 RE60.2 ; v2(321.26,12.98) 321.26,12.59 RE65.1 RE63.1 ; CE64.2 315.26,8.29 316.07,8.29 v2(316.07,8.29) ; CE66.1 305.09,21.11 305.57,21.59 305.75,21.59 v2(305.75,21.58) 305.75,21.66 305.74,21.67 RE125.1 ; v2(310.94,21.62) 310.94,22.05 CE63.2 312.03,22.56 312.98,23.51 312.98,24.93 312.09,25.82 310.28,25.82 v2(307.31,28.79) ; RE64.1 RE118.1 319.01,12.41 v2(319.01,13.02) ; v2(297.89,19.3) 298.16,19.03 RE43.2 ; CE67.1 304.72,6.85 305.09,6.48 v2(305.09,6.14) ; v2(300.46,12.79) 300.32,12.93 CE65.1 CE79.1 299.32,14.27 298.98,14.61 298.98,15.93 RE46.2 RE45.2 RE44.2 RE43.2 ; RE43.2 299.1,19.42 CE69.1
+3VALW_PD: length 14.3
  TOP w0.127: v1(356.9,66.89) 357.85,67.85 v2(358.18,67.85)
  IN1 w0.508: v2(358.18,67.85) 357.81,67.85 357.63,67.67 357.19,67.67 356.78,68.07 356.78,70.96 v2(356.58,71.16)
  BOTTOM w0.152: UT4.H1 358.93,71.28 356.69,71.28 v2(356.58,71.16) 356.4,71.16 356.25,71.32 356.25,71.75 356.1,71.91 355.3,71.91 354.81,71.41
  BOTTOM w0.254: v2(358.18,67.85) 358.24,67.91 358.51,67.91 358.71,68.11 358.77,68.11 UT4.B1
  BOTTOM w0.508: RT53.2 CT101.1 CT88.1 354.81,71.41
+3VALWP: length 24.2
  TOP w0.14: v2(68.33,50.89) v4(69.17,50.89)
  TOP w0.508: PR300.1 85.74,44.75 86.21,45.23 86.21,46.7 85.75,47.15 PR314.2 v2(85.32,47.78)
  IN1 w0.508: 68.94,51.15 70.52,52.73 80.37,52.73 v2(85.32,47.78)
  vias: v2(64.24,50.89) v2(64.24,50.26) v2(64.82,50.89) v2(64.82,50.26) v2(65.41,50.89) v2(65.41,50.26) v2(65.99,50.89) v2(65.99,50.26) v2(66.57,50.89) v2(66.57,50.26) v2(67.16,50.89) v2(67.16,50.26) v2(67.74,50.89) v2(67.74,50.26) v2(68.33,50.26)
+3VLP: length 238.8
  TOP w0.127: v4(267.32,17.87) 267.63,18.18 v2(267.63,18.89)
  IN1 w0.508: v2(267.63,18.89) 267.08,19.43 264.12,19.43 256.33,27.23 250.37,27.23 249.51,28.09 243.16,28.09 241.54,29.71 221.62,29.71 221.37,29.46 172.53,29.46 172.06,29.94 156.76,29.94 155.87,30.83 147.96,30.83 147.11,29.97 142.86,29.97 141.73,31.11 120.04,31.11 119.06,30.13 108.69,30.13 107.2,31.61 96.72,31.61 96.22,32.12 96.22,32.72 95.54,33.39 89.41,33.39 88.43,34.37 88.43,39.46 v2(85.05,42.84)
  IN3 w0.508: v2(303.49,19.14) 303.49,19.33 302.98,19.84 300.75,19.84 298.44,17.53 295.73,17.53 295.29,17.08 288.71,17.08 287.51,15.89 283.99,15.89 282.96,16.92 281.28,16.92 280.46,17.74 268.77,17.74 v2(267.63,18.89)
  BOTTOM w0.508: v2(303.49,19.14) 303.49,19.84 RE20.2
+3VS: length 987.9
  TOP w0.203: v2(317.41,39.27) 317.65,39.51 UVGA1.26
  TOP w0.254: UVGA1.14 322.89,39.11 323.17,39.39 323.84,39.39 323.91,39.46 324.69,39.46 RVGA16.2 ; U5603.9 270.09,7.89 ; U5603.10 270.02,8.39
  TOP w0.305: v2(263.23,7.11) 263.6,7.11 263.88,7.39 U5603.3 ; v2(263.25,7.89) U5603.2
  TOP w0.356: QH4.5 QH4.2 272.21,29.69 v2(272.26,29.75) 272.4,29.61 RH27.1
  TOP w0.381: RG506.1 223.2,64.5 223.44,64.75 v2(223.75,64.75) ; RG505.1 227.1,62.75 226.61,63.25 v2(226.61,63.46)
  TOP w0.406: RTH3.1 96.75,75.96 QTH3.5 ; QTH3.2 96.75,72.86 97.18,72.43 RH531.1
  TOP w0.457: v2(246.83,37.34) 246.83,37.52 246.43,37.91
  TOP w0.508: RH531.1 96.31,72.16 v2(95.99,72.48) ; RH86.1 RH129.2 RH159.1 RH119.1 271.35,36.1 v2(271.25,36.2) ; RH551.1 v2(269.22,40.92) ; UA1.1 337.33,7.97 v2(337.38,8.02) ; v2(291.4,41.13) 290.84,40.56 CH188.1 ; 246.43,37.91 245.43,37.91 245.07,38.27 245.07,38.69 244.36,39.4 244.36,42.34 CD35.1 CD34.1 243.04,42.37 242.67,42.74 242.67,44.54 v2(243.4,45.27) ; PR6040.1 v2(161.08,134.17) ; v2(272.39,32.6) 272.27,32.6 271.71,33.16 RH547.1 ; v2(252.82,21.88) 252.65,22.05 252.65,23 253.37,23.71 256.9,23.71 v2(260.58,27.4) ; v2(234.15,61.48) 234.09,61.42 PR800.1 ; v2(327.69,25.43) 329.85,25.43 330.95,26.53 QA1.2 331.43,25.31 331.43,24.01 332.42,23.02 332.42,22.24 333.82,20.84 334.25,20.84 335,20.09 v2(335,13.73) 335.05,13.68 RA5.1 ; v2(132.59,85.63) 132.15,85.18 122.02,85.18 v2(121.12,86.08) ; RE122.1 304.59,48.49 Q13.2 306.49,48.09 v2(306.49,47.59) ; RZ37.1 286.3,68.42 v2(286.17,68.54) ; v2(131,144.43) 131.27,144.43 131.57,144.12 133.16,144.12 PR5015.1 ; v2(159.87,23.71) 159.87,22.38 v2(159.42,21.94) ; v2(328.91,36.54) 328.65,36.8 327.63,36.8 325.54,38.89 RVGA16.2 ; RVGA3.2 318.56,31.07 319.06,31.58 v2(319.06,32.6) ; RP28.2 331.38,53.24 v2(332.02,53.87) 332.08,53.93 332.08,56.54 QP1.1 ; RH141.2 296.77,31.18 296.77,30.42 v2(296.9,30.3) ; RTH3.1 v2(95.97,76.1) ; v2(265.56,11.99) 265.83,11.72 RS40.1 CN19.1 ; v2(160.75,131.92) 160.19,132.48 PR6061.1 ; v2(269.18,38.18) 269.25,38.26 RH553.1 ; v2(270.55,53.62) 270.55,48.54 269.27,47.26 v2(269.27,46.92) 271.82,46.92 272.43,47.53 v4(273.14,47.53) 278.74,47.53 279.07,47.2 279.07,46.48 RH559.1 ; RTH4.1 v2(92.99,73.14)
  IN1 w0.508: v2(121.12,86.08) 119.53,86.08 119.14,85.69 119.14,73.92 118.4,73.18 115.74,73.18 108.52,65.97 94.44,65.97 v2(94.21,66.2) ; v2(95.97,76.1) 95.97,75.64 93.47,73.14 v2(92.99,73.14) ; v2(269.18,38.18) 269.27,38.18 269.83,38.74 269.83,40.31 v2(269.22,40.92) ; v2(263.23,7.11) 263.25,7.13 v2(263.25,7.89) 263.25,10.75 263.51,11.01 269.8,11.01 270.18,10.63 v2(270.18,8.87)
  IN1 w1.016: 259.06,27.89 257.45,29.49 255.08,29.49 254.22,30.35 244.61,30.35 242.34,32.62 242.34,33.66 242.99,34.3 245.32,34.3 246.29,35.27
  IN2 w0.508: v2(131,144.43) 131,144.25 131.54,143.72 150.58,143.72 152.67,141.63 159.97,141.63 161.47,140.14 161.47,134.56 v2(161.08,134.17) ; v2(121.12,86.08) 121.12,87.67 122.54,89.09 122.54,102.42 124.65,104.52 124.65,105.79 125.96,107.1 v2(125.96,107.41) ; v2(223.75,64.75) 223.23,64.23 218.83,64.23 218.3,64.76 217.09,64.76 216.56,64.23 210.96,64.23 210.74,64.01 v2(207.8,64.01) ; 301,24.06 301,22.98 299.76,21.75 299.76,16.79 302.69,13.86 302.69,11.69 300.75,9.76 v2(300.75,9.11) ; v2(95.97,76.1) 97.32,74.76 97.32,72.95 96.85,72.48 v2(95.99,72.48) 95.99,71.59 93.57,69.17 v2(93.57,66.2)
  IN2 w1.016: 21.88,34.95 21.88,35.65 23.08,36.85 26.67,36.85 27.2,37.38 ; 88.88,66.2 86.97,66.2 75.35,54.57 65.32,54.57 62.14,57.75 57.25,57.75 54.71,60.29 33.62,60.29 28.36,55.03 28.36,45.15 30.33,43.18 30.33,39.72 29.38,38.76 ; 17.63,49.53 17.54,49.44 17.54,42.47 19.53,40.48 19.53,35.59 20.41,34.71
  IN3 w0.508: v2(332.02,53.87) 330.37,52.23 326.49,52.23 321.29,47.02 321.29,40.67 319,38.38 ; v2(226.61,63.46) 226.61,63.46 226.61,63.15 227.55,62.21 233.42,62.21 v2(234.15,61.48) ; v2(362.69,65.24) 362.08,64.63 359.55,64.63 v2(358.65,65.53) ; v2(159.87,23.71) 159.18,24.4 137.18,24.4 136.78,23.99 130.13,23.99 129.03,25.09 122.26,25.09 v2(120.98,23.81)
  IN3 w1.016: 104.05,60.86 104.05,59.4 111.96,51.49 111.96,44.19 112.31,43.84 112.31,35.4 114.97,32.73 114.97,31.59 ; 166.02,43.66 165.14,42.78 165.14,34.83 164.06,33.75 164.06,32.41 163.15,31.5 118.68,31.5 118.59,31.59 ; 260.58,28.57 260.58,29.68 261.3,30.4 261.31,30.4 262.75,31.84 263.77,31.84 265.02,33.1 265.02,34.38 266.49,35.84
  IN4 w0.508: v2(265.56,11.99) 266.25,11.31 268.35,11.31 v2(269.11,12.07) ; v2(131,144.43) 131,143.51 128.78,141.29 128.78,140.99 122.93,135.14 122.93,117.8 126.65,114.09 126.65,108 126.05,107.41 v2(125.96,107.41) ; v2(358.69,39.97) 359.7,39.97 362.36,42.62 362.36,50.17 361.99,50.54 361.99,59.29 362.15,59.45 362.15,61.16 362.1,61.22 362.1,64.65 v2(362.69,65.24)
  IN4 w1.016: 242.93,44.11 241.24,42.42 177.76,42.42 176.33,40.99 171.59,40.99 169.19,43.39 167.74,43.39
  IN5 w0.508: 295.67,9.9 299.96,9.9 v2(300.75,9.11) ; 295.67,9.9 v2(295.54,10.02) ; 295.67,9.9 295.67,9.52 296.14,9.05 296.14,8.22 295.63,7.71 288.77,7.71 288.27,8.22 288.27,9.68 287.69,10.25 ; v2(269.11,12.07) 271.54,12.07 273.36,10.25 280.65,10.25 281.53,9.36 285.85,9.36 287.19,10.7
  IN5 w1.016: 103.35,62.7 103.35,63.94 103,64.29 103,64.39 102.53,64.86 94.46,64.86 94.02,65.31 ; 234.04,60.7 234.04,60.24 234.96,59.31 234.96,53.08 238.29,49.75 241.47,49.75 243.4,47.82 243.4,46.29
  BOTTOM w0.203: UH2.AD13 291.11,40.84 v2(291.4,41.13)
  BOTTOM w0.305: v2(244.69,45.27) 244.9,45.06 244.9,43.97 244.83,43.9 JDIMM2.255 ; JDIMM1.255 168.33,44.06 168.02,44.36 166.99,44.36 166.79,44.16 v2(166.74,44.16)
  BOTTOM w0.356: v2(362.69,65.24) 362.62,65.31 RT57.1 ; RT58.1 359.27,65.53 v2(358.65,65.53)
  BOTTOM w0.381: QE19.5 v2(159.42,21.94) ; QE19.2 159.42,24.16 v2(159.87,23.71)
  BOTTOM w0.457: v2(300.75,9.11) 301.58,9.93 RE143.2
  BOTTOM w0.508: 269.15,38.83 268.46,39.52 268.46,40.23 269.15,40.92 v2(269.22,40.92) 268.33,41.81 268.33,46.13 269.11,46.92 v2(269.27,46.92) 269.27,46.87 RH79.2 ; v2(223.75,64.75) 225.32,64.75 v2(226.61,63.46) ; 309.28,32.92 308.6,32.92 307.66,33.86 307.66,40.24 306.67,41.22 306.67,43.15 306.53,43.29 306.53,47.55 v2(306.49,47.59) ; v2(120.98,23.81) 120.98,25.57 122.09,26.67 122.09,31.65 121.26,32.48 116.42,32.48 116.02,32.07 v2(116.02,31.73) ; v2(337.38,8.02) 337.07,7.71 CA4.1 RA2.1 336.4,12.33 v2(335,13.73) ; v2(116.69,31.69) 116.69,29.31 117.2,28.8 RE120.2 117.67,28.61 QE3.2 ; v2(286.17,68.54) 286.17,66.58 282.87,63.27 282.87,61.18 275.31,53.62 v2(270.55,53.62) 269.79,52.86 RH557.1 268.45,51.21 268.01,50.76 268.01,49.11 268.71,48.42 RH561.1 ; v2(295.54,10.02) 295.54,10.3 295.72,10.48 RTPM14.2 ; RW4.1 226.4,24.42 225.81,23.83 225.81,23.15 226.19,22.77 228.77,22.77 229.1,23.11 229.1,24.27 232.46,27.63 241.08,27.63 242.22,26.49 242.22,24.68 242.99,23.9 242.99,22.81 243.63,22.17 252.53,22.17 v2(252.82,21.88) ; PR4001.1 125.96,107.23 v2(125.96,107.41) ; v2(286.04,25.44) 286.08,25.48 RH573.2 ; v2(161.08,134.17) 161.08,133.51 160.75,133.18 v2(160.75,131.92) ; RH93.1 v2(132.59,85.63)
  vias: v2(17.87,51.2) v2(18.34,50.84) v2(21.17,34.64) v2(21.17,34.05) v2(28.21,37.77) v2(28.8,37.73) v2(89.76,66.33) v2(90.15,65.69) v2(104.05,62.19) v2(104.43,61.75) v2(166.28,44.54) v2(246.83,36.76) v2(260.03,27.89) v2(267.33,36.1) v2(267.33,35.52) v2(267.33,34.93) v2(267.33,34.35) v2(267.33,33.76) v2(267.91,35.78) v2(267.91,35.2) v2(267.91,34.61) v2(267.91,34.03) v2(267.91,33.45) v2(279.08,28.35) v2(279.25,27.71) v2(279.88,27.71) v2(280.14,27.08) v2(284.39,19.57) v2(284.39,18.89) v2(285.02,19.59) v2(284.98,18.83) v2(285.56,19.38) v2(285.56,18.79) v2(287.25,11.84) v2(287.4,11.26) v2(300.44,24.44) v2(300.93,24.77) v2(301.51,24.77) v2(309.8,32.29) v2(309.99,32.86) v2(310.39,32.29) v2(311.95,28.98) v2(315.13,33.49) v2(315.76,33.49) v2(342.2,37.1) v2(342.51,37.62) v2(342.82,37.1) v2(358.05,39.97)
+3VS_CAM: length 7.8
  TOP w0.127: v4(286.72,61.75) 287.2,62.23 CZ44.1
  TOP w0.508: v2(288.84,66.96) 288.15,67.64 287.81,67.64 287.69,67.53 ; 287.69,67.53 CV584.1 287.2,65.51 CV582.1 CV583.1 CZ44.1 ; 287.69,67.53 RZ37.2
+3VS_CR: length 2.1
  TOP w0.127: v4(19.43,29.61) 18.64,28.82 v2(18.64,28.65)
  BOTTOM w0.254: UR1.8 v2(18.64,28.65)
  vias: v2(17.06,30.73) v2(17.5,31.19)
+3VS_OUT: length 3.8
  TOP w0.14: v1(266.97,38.6) 265.11,36.74 265.11,35.59
+3VS_TBT: length 7.6
  TOP w0.127: v1(350.15,41.6) 350.71,42.15 RT77.2
  TOP w0.254: CT49.1 356.82,61.79 357.09,62.05 357.09,62.08 357.23,62.22 v2(357.23,62.33)
  TOP w0.356: RT77.2 351.32,41.56 351.89,40.99 352.72,40.99 v2(353.04,41.31) 353.23,41.49 RT76.2
  BOTTOM w0.178: UT1.H9 356.11,56.15 355.78,56.48 v2(355.78,56.48)
  BOTTOM w0.305: v2(357.23,62.33) RT21.1
  BOTTOM w0.356: RT20.1 358.34,45.68 358.17,45.51 358.17,45.5 357.99,45.31 v2(357.99,45.3)
  vias: v2(357.93,43.78) v2(358.51,43.77) v2(359.5,60.44) v2(359.5,59.8)
+3VS_TP: length 253.7
  TOP w0.508: v2(158.03,23.78) 157.27,24.54 v4(137.06,24.54) 132.88,24.54 128.82,28.6 v2(128.25,28.6) ; v2(319.2,14.48) 318.8,14.89 RE55.1 RE24.1
  IN2 w0.508: v2(156.44,28.6) 156.44,25.36 v2(158.03,23.78) 158.79,23.02 162.09,23.02 163.23,21.87 183.81,21.87 186.54,24.6 225.56,24.6 226.64,25.68 236.89,25.68 240.32,22.25 252.32,22.25 252.68,22.61 260.32,22.61 261,21.94 264.33,21.94 v2(265.66,20.6)
  IN5 w0.508: v2(319.2,14.48) 319.66,14.02 319.66,8.94 317.56,6.85 309.94,6.85 308.12,8.67 307.8,8.67 307.45,8.31 306.03,8.31 305.32,9.02 305.32,9.45 304.14,10.63 299.06,10.63 298.41,11.28 289.39,11.28 288.3,12.37 288.3,12.54 287.79,13.05 285.77,13.05 285.41,12.69 273.57,12.69 273.47,12.59 272.02,12.59 271.06,13.55 266.35,13.55 265.25,14.65 265.25,20.2 v2(265.66,20.6)
  BOTTOM w0.508: RE7.2 RE9.2 157.75,22.05 158.03,22.33 v2(158.03,23.78) ; v2(128.25,28.6) CE2.1 128.94,28.59 RE93.2 127.65,27.46 QE13.2 126.7,28.41 126.66,28.41 126.14,28.93 RE87.1 125.26,30.06 126.21,31.02 141.71,31.02 142.45,30.27 JTP.8 ; DE4.5 v2(156.44,28.6) RE123.1
+3VS_TP_OUT: length 4.2
  BOTTOM w0.127: RE93.1 v1(130.34,25.83)
  BOTTOM w0.508: UE4.1 131.87,28.36 130.96,27.46 RE93.1
+3VS_WLAN: length 10.4
  IN2 w1.016: 337.77,50.17 337.77,42.28 339,41.05 339,40.29
  vias: v2(338.05,33.06) v2(338.43,32.6) v2(338.49,51.74) v2(338.68,33.18) v2(338.95,51.36) v4(337.43,33.26) v4(337.45,35.04) v4(344.09,33.66)
+5V_AVDD: length 13
  TOP w0.127: v1(352.06,16.49) 351.75,16.18 351.14,16.18
  TOP w0.203: HDA1.26 347.89,18.26 348.34,17.82 348.34,17.45
  BOTTOM w1.016: 349.99,16.09 346.15,12.26 344.17,12.26 341.92,14.51
  vias: v2(350.94,16.47) v2(350.94,15.84)
+5V_CHGUSB_1:
  vias: v2(352.53,39.14) v2(353.11,39.14) v2(353.7,39.14) v2(354.05,38.64) v2(362.9,26.22) v2(362.9,25.63) v2(363.54,26.22) v2(363.54,25.63) v2(364.72,36.41) v2(364.72,35.83) v2(365.35,36.41) v2(365.35,35.83) v4(361.89,22.71)
+5V_CHGUSB_1_OUT: length 1.3
  TOP w0.14: v2(351.49,39.09) v1(350.14,39.09)
+5V_CHGUSB_3:
  vias: v2(5.99,38.89) v2(6.57,38.89) v2(6.57,38.31) v2(6.57,37.72) v2(7.16,38.89) v2(17.17,68.44) v2(17.17,67.86) v2(17.76,68.44) v2(17.76,67.86) v2(17.76,67.27) v4(18.52,69.7)
+5V_PVDD: length 3.8
  TOP w0.203: HDA1.41 345.05,24.11 345.66,24.72 v2(345.66,24.92)
  BOTTOM w0.305: v2(345.66,24.92) 345.66,24.73 344.78,23.85 CA12.1
  vias: v1(340.6,25.78) v2(339.26,26.44) v2(339.84,26.44) v2(340.42,26.44)
+5VALW: length 445.2
  TOP w0.127: v2(176.82,23.78) v4(177.98,23.78)
  TOP w0.203: 261.25,30.6 UZ1.4
  TOP w0.406: 212.8,66.32 211.72,67.4 207.74,67.4 206.3,65.96 206.3,64.68
  TOP w0.508: 214.58,66.17 RG511.1 ; 214.58,66.17 214.69,66.28 217.13,66.28 v2(217.24,66.17) 217.32,66.09 RG509.1 ; 214.58,66.17 212.96,66.17 212.8,66.32 ; RH506.1 281.63,11.47 282.21,11.47 v2(282.82,10.86) 283.52,10.16 RW3.2 ; PR204.1 112.87,71.67 v2(111.87,72.66) ; v2(219.97,57.47) 219.55,57.05 219.55,56.92 219.15,56.51 RH504.1 RH505.1 ; v2(195.73,59.3) 195.49,59.54 RG543.1
  TOP w0.635: v2(182.45,105.48) 181.08,106.85 181.08,108.74 183.62,111.28 v2(185.59,111.28) ; 228.33,50.13 228.97,50.13 229.76,50.92 v2(229.76,51.7) ; 212.8,66.32 212.76,66.28 RG513.1
  IN2 w0.635: 116.94,97.63 116.94,86.9 118.54,85.3 118.54,74.43 ; v2(229.76,51.7) 221.95,51.7 218.93,54.72 218.93,56.43 v2(219.97,57.47) ; 80.56,30.7 81.76,30.7 84.62,33.55 87.45,33.55 88.42,34.52 92.16,34.52 113.51,55.88 113.51,64.23 115.71,66.42 117.2,66.42 118.54,67.77 118.54,74.43 ; 118.54,74.43 117.04,72.93 115.2,72.93 114.15,71.87 112.66,71.87 v2(111.87,72.66)
  IN3 w0.508: v2(195.73,59.3) 196.41,58.63 199.84,58.63 200.39,59.18 200.39,59.52 201.08,60.2 203.86,60.2 206.29,62.62 v2(206.29,64.1)
  IN3 w0.635: v2(240.75,54.73) 240.75,52.85 240.08,52.17 234.15,52.17 233.22,53.1 230.63,53.1 229.76,52.23 v2(229.76,51.7) 229.76,49.15 227.69,47.08 223.18,47.08 221.4,45.3 221.4,36.54 219.98,35.12 v2(219.98,30.14)
  IN3 w1.016: 13.25,38.83 13.25,41.87 16.83,45.46 16.83,48.18 16.61,48.4 16.61,53.24 19.84,56.47 20.23,56.47 21.77,58 42.01,58 43.22,56.8 43.22,55.97
  IN4 w1.016: 43.23,55.98 47.54,60.29 54.08,60.29 56.38,57.99 61.88,57.99 64.62,55.25 74.04,55.25 75.6,53.69 75.6,33.75 76.43,32.92
  IN5 w0.254: 199.84,86.03 196.95,88.92 196.95,89.83 196.56,90.22 192.63,90.22 192.03,90.83 192.03,100.53 186.98,105.57 186.98,107.09 185.59,108.49 v2(185.59,111.28)
  IN5 w0.635: v2(242.9,73.64) 242.38,74.16 238.75,74.16 238.21,73.62 234.36,73.62 230.8,77.18 214.55,77.18 213.69,76.32 211.72,76.32 211.37,76.67 206.29,76.67 205.14,77.82 202.41,77.82 201.84,78.39 199.87,78.39 199.43,78.83 199.43,79.56 198.9,80.09 198.9,81.89 199.84,82.83 199.84,86.03
  BOTTOM w0.254: v2(362.91,71.69) 363.01,71.69 363.42,71.28 UT4.H10
  BOTTOM w0.305: JPW.1 217.65,27.77
  BOTTOM w0.381: 217.65,27.77 217.65,24.52 v2(216.84,23.71) ; v2(201.61,23.74) 201.65,23.78 JLED.4
  BOTTOM w0.508: PR203.1 v2(111.87,72.66)
  BOTTOM w0.635: v2(242.9,73.64) 243.37,73.17 243.37,72.21 RG583.1 242.75,70.63 242.02,69.9 242.02,60.44 241.12,59.54 241.12,58.97 239.24,57.08 239.24,55.11 ; v2(219.97,57.47) 219.97,61.72 220.57,62.32 220.57,64.8 219.21,66.17 v2(217.24,66.17)
  vias: v2(11.05,38.79) v2(11.34,38.19) v2(11.63,38.79) v2(11.6,37.62) v2(12.04,38.19) v2(43.23,55.04) v2(43.23,54.46) v2(77.13,32.13) v2(77.13,31.55) v2(77.13,30.97) v2(77.13,30.38) v2(77.41,32.72) v2(77.71,32.13) v2(77.71,31.55) v2(77.71,30.97) v2(77.71,30.38) v2(77.99,32.72) v2(78.3,32.13) v2(78.3,31.55) v2(78.3,30.97) v2(78.3,30.38) v2(78.58,32.72) v2(78.88,32.13) v2(78.88,31.55) v2(78.88,30.97) v2(78.88,30.38) v2(79.16,32.72) v2(91.48,23.78) v2(92.06,23.78) v2(92.65,23.78) v2(93.23,23.78) v2(93.82,23.78) v2(116.24,98.71) v2(116.88,98.71) v2(173.32,23.78) v2(173.9,23.78) v2(174.49,23.78) v2(175.07,23.78) v2(175.65,23.78) v2(176.24,23.78) v2(240.07,54.96) v2(257.53,31.91) v2(257.53,31.32) v2(257.53,30.74) v2(258.12,31.91) v2(258.12,31.32) v2(258.12,30.74) v2(258.7,31.91) v2(258.7,31.32) v2(258.7,30.74) v2(259.28,31.91) v2(259.28,31.32) v2(259.28,30.74) v2(349.47,31.16) v2(349.49,30.53) v2(350.17,31.17) v2(350.17,30.53) v2(364.25,67.15) v2(364.42,67.75) v2(364.85,66.89) v2(365.02,67.47) v2(366.31,66.64) v2(366.31,66.06) v2(366.31,65.47) v4(257.82,29.9) v4(365.81,68.28)
+5VALWP: length 31.5
  TOP w0.14: v2(73.45,30.94) v4(73.45,29.95)
  TOP w0.203: v2(78.72,42.34) 78.8,42.42 PU300.14
  TOP w0.508: v2(84.6,39.65) 85,39.65 85.5,40.15 PR301.2
  IN3 w0.508: v2(78.72,42.34) 79.96,42.34 80.8,41.5 82.07,41.5 82.64,40.93 82.64,40.34 83.33,39.65 v2(84.6,39.65)
  IN4 w0.508: 74.65,29.56 79.03,29.56 79.86,30.38 79.86,34.45 76.84,37.47 76.84,41.74 77.45,42.34 v2(78.72,42.34)
  vias: v2(73.45,31.52) v2(74.03,31.52) v2(74.03,30.94) v2(74.61,31.52) v2(74.61,30.94) v2(75.2,31.52) v2(75.2,30.94)
+5VS: length 931.9
  TOP w0.254: PR5229.2 v2(164.06,130.65) ; v2(114.87,127.27) 114.87,127.89 115.02,128.04 PR5216.2 115.52,127.93 PR5212.1
  TOP w0.508: PR5113.1 136.08,128.63 PR5116.2 140.01,128.63 141.9,130.52 v2(141.9,131.22) 141.9,131.7 142.41,132.21 147.31,132.21 ; PR5103.2 147.96,128.9 PR5101.1 147.11,130.02 147.31,130.22 147.31,132.21 ; v2(170.41,130.27) 173.33,130.27 174.11,129.49 PR6103.2 174.3,129.12 PR6106.1 ; PR6050.2 PR6044.2 PR6048.2 155.74,130.72 155.05,130.03 ; v2(162.08,144.62) 162.78,143.92 PR6037.1 ; PR5201.1 118.04,114.97 PR5203.2 117.83,116.1 v2(116.9,116.1) ; 155.05,130.03 153.11,131.98 v2(151.17,131.98) 150.69,132.46 148.69,132.46 148.44,132.21 147.31,132.21 ; 155.05,130.03 155.05,129.58 156,128.63 PR5128.2 157.31,128.63 PR5125.1 ; v2(169.46,137.63) 170.03,138.2 v2(170.03,139.18) 172.29,139.18 173.13,138.35 174.3,138.35 PR6113.1 ; PR5230.1 166.68,124.56 165.97,124.56 v2(165.96,124.56) ; PR6047.2 PR6046.2 v2(152.08,139.47)
  TOP w1.016: 265.19,39.73 263.75,38.29 258.78,38.29 257.66,37.18 256.83,37.18 255.88,36.22 ; 308.27,50.32 308.01,50.07 307.25,50.07 306.24,51.08 306.24,53.75 302.68,57.31 299.89,57.31 287.63,69.56 283.63,69.56 ; 336.08,31.07 330.84,31.07 329.05,32.86 329.05,35.4 329.81,36.16 329.81,37.26 329.23,37.84 327.93,37.84 324.85,40.91 324.85,41.18 ; 111.23,30.13 117.96,30.13 119.8,31.97 141.45,31.97 144.82,28.6 154.85,28.6 155.72,29.47 v4(165.39,29.47) 201.12,29.47 201.65,30
  TOP w2.032: 265.19,39.73 265.19,44.98 264.3,45.88
  TOP w4.064: 283.63,69.56 282.36,68.29 282.36,64.16 280.33,62.13 268.71,62.13 264.3,57.72 264.3,45.88
  IN1 w0.508: v2(114.87,127.27) 115.33,127.27 115.89,126.71 115.89,123.52 114.59,122.23 v2(114.59,119.09) 114.8,119.09 115.27,118.62 115.27,117.74 v2(116.9,116.1) ; v2(172.51,117.76) 172.51,126.41 171.83,127.09 170.66,127.09 170.26,127.5 170.26,130.11 v2(170.41,130.27)
  IN1 w1.016: 322.3,42.57 322.3,43.44 320.07,45.67 319.09,45.67 318.85,45.43 318.85,43.99 321.22,41.62 321.29,41.62
  IN1 w2.032: 309.03,48.22 314.62,48.22 315.6,47.25 317.51,47.25 319.09,45.67
  IN2 w0.508: v2(165.96,124.56) 165.75,124.56 165.37,124.94 165.37,127.65 164.31,128.71 164.31,129.61 164.06,129.86 v2(164.06,130.65) ; 118.91,107.22 116.82,107.22 114.12,104.52 114.12,97.89 115.66,96.36 115.66,87.23 117.87,85.02 117.87,74.71 116.79,73.62 111.3,73.62 110.73,74.2 107.65,74.2 104.84,71.39 104.84,66.75 102.3,64.21 v2(102.3,63.72) ; 118.91,107.22 118.91,115.04 117.85,116.1 v2(116.9,116.1) ; 118.91,107.22 121.51,107.22 123.46,109.16 124.61,109.16 125.02,108.75 126.3,108.75 127.15,109.6 127.15,116.85 127.48,117.17 131.67,121.37 131.67,123.5 132.91,124.74 134.85,124.74 139.17,129.06 139.99,129.06 141.9,130.97 v2(141.9,131.22) ; v2(151.17,131.98) 153.65,131.98 154.63,132.97 157.58,132.97 157.93,132.62 157.93,131.47 158.23,131.17 158.86,131.17 v2(158.92,131.22) ; v2(137.75,145.16) 137.85,145.16 138.67,144.34 153.54,144.34 154.6,143.28 160.74,143.28 v2(162.08,144.62) 162.97,143.73 162.97,143.05 168.39,137.63 v2(169.46,137.63) 169.84,137.63 171.49,135.98 171.49,131.35 v2(170.41,130.27)
  IN2 w1.016: 255.14,30.48 253.07,30.48 252.46,29.87 245.06,29.87 242.97,31.97 201.72,31.97
  IN3 w0.508: v2(368.66,112.92) 364.71,112.92 361.29,109.5 361.29,98.8 360.55,98.06 360.55,88.13 361.28,87.4 v2(363.32,87.4) ; v2(339.13,56.16) 339.13,56.5 343.59,60.97 349.4,60.97 351.13,62.7 351.13,68.56 352.87,70.3 353.78,70.3 355.22,71.74 355.22,73.36 360.55,78.69 360.55,85.84 361.48,86.77 v2(363.32,86.77) ; v2(202.03,30.83) 202.69,31.49 214.25,31.49 217.72,34.95 217.72,37.2 218.58,38.06 218.58,40.95 220.65,43.02 220.65,45.53 224.17,49.05 224.17,55.18 v2(223.62,55.73)
  IN3 w1.016: 102.59,62.77 102.59,57.75 109.58,50.76 109.58,35.52 110.69,34.41 110.69,31.71
  IN3 w1.524: 261.41,48.03 261.85,48.03 264.77,45.11 264.77,38.06 262.93,36.22 259.82,36.22 256.64,33.05 ; 260.41,46 260.41,39.22 255.63,34.45
  IN4 w0.508: v2(170.41,130.27) 170.36,130.22 166.65,130.22 166.18,130.69 164.58,130.69 164.55,130.65 v2(164.06,130.65) ; v2(137.75,145.16) 139.24,143.67 140.31,143.67 141.48,142.49 141.48,141.7 141.12,141.34 141.12,137.18 139.99,136.05 139.99,135.09 141.9,133.18 v2(141.9,131.22) ; v2(151.17,131.98) 150.45,132.71 150.45,138.23 151.69,139.47 v2(152.08,139.47) ; v2(86.03,61.28) 85.68,61.28 85.38,60.99 85.38,53.24 v2(86.72,51.91)
  IN5 w1.016: 101.13,63.02 100.43,63.72 86.82,63.72 85.97,62.87 85.97,62.19
  IN5 w1.524: 367.42,112.84 363.39,108.8 363.39,103.85 361.61,102.07 361.61,77.82 359.39,75.59 357.23,75.59 355.7,74.07 355.7,71.91 354.85,71.06 354.76,71.06 354.57,70.87 352.41,70.87 350.79,69.24 350.79,62.26 349.26,60.73 344.84,60.73 343.57,59.46 343.57,57.88 340.72,55.02 338.11,55.02
  BOTTOM w0.203: CG386.1 220.07,70.51 219.05,69.5 217.16,69.5 216.33,70.33 UG12.4
  BOTTOM w0.254: PR5200.2 114.73,118.95 v2(114.59,119.09) ; PR5214.2 115.29,127.27 v2(114.87,127.27)
  BOTTOM w0.508: v2(110.47,30.77) 110.47,30.57 113.39,27.65 113.39,26.44 113.92,25.91 QE4.3 114.9,26.34 115.41,26.85 116.23,26.85 116.27,26.89 116.31,26.89 116.82,27.4 118.09,27.4 118.49,26.99 RE1.2 ; PR5004.1 138.01,144.9 v2(137.75,145.16) ; PR5115.2 v2(141.9,131.22) ; v2(223.62,55.73) 224.8,56.91 224.8,59.74 225.97,60.91 226.86,60.91 228.21,62.26 228.21,63.78 222.69,69.3 220.83,69.3 220.31,69.82 CG386.1 ; v2(158.92,131.22) 159.47,130.66 PR5127.2 ; PR6112.2 PR6109.2 v2(169.46,137.63) ; v2(151.17,131.98) 151.18,131.97 PR5100.2 ; RZ26.1 v2(86.72,51.91)
  BOTTOM w1.016: 338.39,13.83 336.27,13.83 329.5,20.6 329.5,30.34 331.19,32.03
  vias: v2(86.02,60.66) v2(100.81,61.75) v2(109.83,30.76) v2(201.38,30.83) v2(254.42,31.84) v2(254.48,32.48) v2(255,31.84) v2(255.12,32.48) v2(255.59,31.84) v2(255.56,31.26) v2(256.17,31.84) v2(256.17,31.26) v2(256.76,31.84) v2(256.76,31.26) v2(258.91,47.39) v2(259.25,47.91) v2(259.31,46.96) v2(259.74,48.22) v2(259.74,47.39) v2(260.2,47.84) v2(285.41,71.52) v2(285.73,71.02) v2(285.79,71.97) v2(286.24,71.52) v2(286.24,70.69) v2(286.67,71.08) v2(307.4,49.08) v2(307.4,48.49) v2(308.01,49.08) v2(307.99,48.49) v2(322.17,41.02) v2(322.3,40.45) v2(322.56,41.62) v2(322.76,40.9) v2(326.28,42.07) v2(326.75,41.7) v2(326.82,42.28) v2(336.4,32.54) v2(336.91,32.12) v2(337.31,56.29) v2(337.54,32.1) v2(337.9,56.29) v2(338.13,32.1) v2(338.48,56.29) v2(363.32,86.13) v2(363.32,85.54) v2(368.91,113.5) v2(369.49,113.5) v2(369.49,112.92)
+5VS_HDD: length 17.9
  TOP w0.127: v4(254.89,21.97) 254.03,21.97 253.62,21.57 v2(253.44,21.57) 253.38,21.63 253.38,22.58 v4(253.24,22.72) ; v2(244.22,23.48) 244.26,23.52 244.26,24.69 v4(243.82,25.14)
  IN4 w0.508: v2(253.44,21.57) 253.44,22.27 253.11,22.6 244.53,22.6 244.22,22.9 v2(244.22,23.48)
  BOTTOM w0.508: RS1.1 253.44,21.94 v2(253.44,21.57) ; v2(244.22,23.48) 244.22,23.57 244.35,23.7 244.35,24.58 243.95,24.98
