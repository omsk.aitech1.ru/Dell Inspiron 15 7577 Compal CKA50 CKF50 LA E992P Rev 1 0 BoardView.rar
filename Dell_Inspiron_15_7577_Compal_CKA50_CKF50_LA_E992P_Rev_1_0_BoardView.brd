# Allegro board Dell_Inspiron_15_7577_Compal_CKA50_CKF50_LA_E992P_Rev_1_0_BoardView.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+0.9V_LVR_OUT on TOP (solid shape): 349.1,59.85 349.1,59.74 349.02,59.53 349.1,59.32 349.1,58.64 348.84,58.38 348.34,58.38 348.15,58.19 348.15,58.1 348.13,58 348.15,57.91 348.15,57.69 348.08,57.62 347.38,57.62 347.19,57.81 347.19,60.04 347.26,60.1 348.84,60.1
+0.9V_PCIE on TOP (solid shape): 354.05,54.78 354.11,54.72 354.11,54.39 354.11,54.39 354.11,54.34 354.05,54.27 353.37,54.27 353.36,54.27 353.11,54.22 353.01,53.99 353.01,53.97 352.67,53.62 352.35,53.62 351.99,53.26 351.1,53.26 350.79,52.94 350.41,52.94 350.37,52.98 350.37,54.43 350.43,54.49 350.88,54.49 350.89,54.45 351.28,54.16 351.59,54.53 351.59,54.55 351.8,54.75 352.08,54.75 352.08,54.76 352.58,54.76 352.6,54.78 353.68,54.78
+0.9V_PCIE on BOTTOM (solid shape): 352.26,55.02 352.34,54.92 352.45,54.86 352.47,54.86 352.63,54.7 352.68,54.7 352.7,54.68 352.91,54.62 353.08,54.76 353.09,54.79 353.3,54.79 353.31,54.76 353.49,54.63 353.69,54.72 353.71,54.75 353.93,54.75 354.3,54.38 354.3,54.15 354.22,54.07 354.11,54.07 353.98,54.19 353.69,54.19 353.45,53.95 352.82,53.95 352.24,53.38 351.44,53.38 351.4,53.42 351.4,53.69 351.78,54.07 351.78,54.3 351.56,54.52 351.56,54.66 351.44,54.79 351.44,54.91 351.58,55.05 352.24,55.05
+0.9V_SVR on TOP (solid shape): 368.02,58.64 368.02,57.75 367.45,57.18 365.23,57.18 364.34,58.07 364.34,58.64 364.4,58.7 367.96,58.7
+0.9V_SVR on TOP (solid shape): 355.99,55.29 356.59,55.29 356.65,55.23 356.65,54.91 356.59,54.85 356.21,54.85 356.08,54.72 356.08,54.4 355.95,54.27 355.7,54.27 355.57,54.4 355.57,55.28 355.69,55.4 355.89,55.4
+0.9V_SVR on TOP (solid shape): 355.83,58.53 355.83,58.23 355.68,58.08 355.67,58.08 355.55,58 355.48,57.89 355.48,57.88 355.41,57.81 355.41,57.79 355.38,57.77 355.38,57.16 355.38,57.06 355.33,57 355.19,56.9 355.03,56.91 354.78,56.84 354.75,56.84 354.75,56.8 354.68,56.74 354.68,56.38 354.55,56.24 353.53,56.9 353.18,56.9 353.05,57.03 353.05,57.33 353.11,57.39 354.09,57.39 354.24,57.55 354.24,57.99 354.12,58.12 354.09,58.12 354.05,58.16 353.64,58.16 353.61,58.19 353.61,58.55 353.65,58.59 355.76,58.59
+0.9V_SVR on BOTTOM (solid shape): 368.36,59.19 368.36,57.56 368,57.2 365.1,57.2 364.33,57.97 364.33,59.41 364.45,59.53 368.02,59.53
+0.9V_SVR on IN3 (solid shape): outline of 549 points within 353.48,56.73 368.34,61.43
+0.9V_SVR on IN4 (solid shape): outline of 185 points within 353.55,54.13 356.85,58.38
+1.0VS_VGA_PGOOD on BOTTOM (solid shape): 122.47,94.79 122.47,94.2 122.4,94.14 120.31,94.14 120.24,94.2 120.24,94.33 120.37,94.45 121.21,94.45 121.59,94.83 122.43,94.83
+1.0VS_VGAP on BOTTOM (solid shape): 118.59,92.64 118.59,90.64 118.85,90.39 123.61,90.39 123.67,90.45 127.42,90.45 127.55,90.33 127.55,88.67 127.17,88.29 126.02,88.29 126.02,87.72 125.83,87.72 125.83,88.29 125.2,88.29 125.2,87.72 125.01,87.72 125.01,88.29 118.89,88.29 117.36,89.83 117.36,92.52 117.67,92.83 118.4,92.83
+1.2V_DDR on TOP (solid shape): 133.45,56.86 125.45,56.86 125.45,64.86 133.45,64.86
+1.2V_DDR on TOP (solid shape): 150.6,54.34 135.6,54.34 135.6,64.34 150.6,64.34
+1.2V_DDR on TOP (solid shape): 176.89,54.77 168.89,54.77 168.89,62.77 176.89,62.77
+1.2V_DDR on TOP (solid shape): outline of 32813 points within 103.1,28.72 242.29,87.47
+1.2V_DDR on BOTTOM (solid shape): 179.36,33.56 179.36,32.92 179.81,32.48 186.03,32.48 186.6,31.91 186.6,28.22 185.84,27.46 178.86,27.46 177.46,28.86 177.46,33.56 177.6,33.7 179.22,33.7
+1.2V_DDR on BOTTOM (solid shape): 119.17,72.55 120.05,72.55 120.05,73.18 120.31,73.18 120.31,72.55 121.2,72.55 121.2,73.18 123.86,73.18 124.63,72.42 124.63,69.24 123.74,68.35 116.37,68.35 116.12,68.61 116.12,72.55 116.75,73.18 119.17,73.18
+1.2V_DDR on BOTTOM (solid shape): 151.8,82 151.8,81.99 151.85,81.92 151.93,81.87 151.93,81.86 152.23,81.57 152.23,81.56 152.23,81.33 151.71,80.81 151.54,80.81 151.03,81.32 151.03,81.64 151.43,82.04 151.75,82.04
+1.2V_DDR on BOTTOM (solid shape): 162.32,81.52 162.32,80.73 162.18,80.6 161.89,80.6 161.7,80.66 161.5,80.6 161.17,80.6 161.1,80.67 161.1,80.85 161.59,81.34 161.71,81.34 161.97,81.6 162.23,81.6 162.24,81.6
+1.2V_DDR on BOTTOM (solid shape): 167.34,81.52 167.34,81.31 167.03,81 166.99,80.97 166.95,80.92 166.82,80.79 166.61,80.79 166.51,80.89 166.51,80.89 166.46,80.97 166.39,81.02 166.38,81.02 166.14,81.26 166.14,81.46 166.33,81.65 167.22,81.65
+1.2V_DDR on BOTTOM (solid shape): 154.49,85.94 154.49,85.93 154.57,85.79 154.7,85.71 154.72,85.71 154.92,85.51 154.92,85.51 154.92,85.27 154.4,84.75 154.23,84.75 153.72,85.26 153.72,85.58 153.84,85.71 153.86,85.71 154.05,85.77 154.15,85.94 154.16,85.98 154.45,85.98
+1.2V_DDR on BOTTOM (solid shape): 174.33,85.62 174.36,85.62 174.78,85.62 174.83,85.62 174.85,85.63 175.16,85.63 175.52,85.28 175.52,84.99 175.4,84.87 175.07,84.87 174.77,85.18 174.7,85.18 174.41,85.35 174.12,85.18 173.89,85.18 173.79,85.27 173.79,85.46 173.96,85.63 174.29,85.63
+1.2V_DDR on BOTTOM (solid shape): 155.89,82.21 155.89,81.66 155.3,81.07 154.52,81.07 154.29,80.84 154.05,80.84 153.88,81.01 153.88,81.17 154.06,81.35 154.24,81.35 154.27,81.39 154.28,81.39 154.42,81.47 154.51,81.6 154.52,81.63 154.97,81.63 155.31,81.97 155.32,81.97 155.46,82.05 155.54,82.2 155.54,82.21 155.62,82.28 155.81,82.28
+1.2V_DDR on BOTTOM (solid shape): 160.01,85.26 160.04,85.21 160.04,84.95 159.91,84.82 159.7,84.82 159.58,84.94 159.45,84.94 159.44,84.95 159.35,84.97 159.25,84.95 159.24,84.94 159.2,84.94 159.03,84.78 158.91,84.78 158.78,84.78 158.67,84.68 158.63,84.64 158.52,84.52 158.31,84.52 158.23,84.6 158.23,84.82 158.5,85.09 158.51,85.09 158.62,85.16 158.69,85.27 158.69,85.28 159.01,85.59 159.67,85.59
+1.2V_DDR on BOTTOM (solid shape): 174.05,81.78 174.36,81.48 174.68,81.78 174.77,81.78 174.91,81.64 175.79,81.64 176.19,81.24 176.19,81 175.99,80.81 175.83,80.81 175.65,80.63 175.39,80.63 174.77,81.26 174.56,81.26 174.54,81.28 174.26,81.45 173.97,81.3 173.94,81.27 173.78,81.27 173.69,81.35 173.69,81.53 173.94,81.78
+1.2V_DDR on BOTTOM (solid shape): 170.07,83.38 170.07,83.36 170.09,83.29 170.13,83.23 170.13,82.92 170.07,82.75 170.13,82.58 170.13,82.27 170.08,82.02 170.26,81.85 170.27,81.85 170.44,81.68 170.54,81.68 170.68,81.54 170.68,81.34 170.56,81.21 169.72,81.21 169.35,80.84 169.06,80.84 169.03,80.87 169.03,80.88 168.99,80.95 168.94,81 168.94,81.2 168.96,81.21 169.05,81.29 169.09,81.39 169.1,81.41 169.63,81.94 169.63,81.97 169.64,81.98 169.66,82.1 169.64,82.21 169.63,82.22 169.63,82.62 169.64,82.63 169.66,82.75 169.64,82.86 169.63,82.87 169.63,83.02 169.61,83.04 169.61,83.24 169.63,83.28 169.78,83.43 170.02,83.43
+1.2V_RTM on TOP (solid shape): 328.82,48.31 328.82,46.72 329.96,45.58 331.4,45.58 331.47,45.51 331.47,45.35 331.4,45.28 329.72,45.28 329.7,45.29 329.58,45.32 329.45,45.29 329.44,45.28 328.91,45.28 328.77,45.43 328.77,46 328.7,46.06 327.87,46.06 327.66,46.28 327.66,47.89 327.57,47.98 326.62,47.98 326.44,48.16 326.44,48.83 326.53,48.92 328.22,48.92
+1.2V_VCCK on TOP (solid shape): 317.35,40.73 317.35,40.32 317.6,40.06 318.5,40.06 318.6,39.96 318.6,39.84 318.51,39.74 317.27,39.74 316.88,39.35 316.24,39.35 316.15,39.44 316.15,40.88 315.76,41.28 315.61,41.28 315.46,41.43 315.46,41.79 315.55,41.87 316.2,41.87
+1.2V_VCCPLL_OC on TOP (solid shape): 224.47,54.55 224.47,54.28 224.45,54.28 224.45,53.37 224.36,53.28 222.47,53.28 222.02,53.72 222.02,55.03 222.38,55.39 223.64,55.39
+1.2V_VCCPLL_OC on TOP (solid shape): 340.21,37.87 340.21,37.35 340.09,37.23 339.37,37.23 338.87,36.73 338.15,36.73 338.06,36.82 338.06,37.7 338.37,38 340.08,38
+1.2V_VCCPLL_OC on TOP (solid shape): 322.56,53.49 322.56,52.18 322.43,52.06 321.13,52.06 320.8,52.39 320.8,53.57 320.92,53.69 321.47,53.69 321.47,53.69 322.36,53.69
+1.2V_VCCPLL_OC on BOTTOM (solid shape): 204.42,48.11 204.42,47.34 204.23,47.15 203.61,47.15 202.97,47.78 202.97,48.31 203.15,48.49 204.04,48.49
+1.2V_VCCPLL_OC on BOTTOM (solid shape): 242.55,53.11 242.55,52.54 242.29,52.29 240.75,52.29 240.56,52.48 240.56,53.05 240.81,53.3 242.36,53.3
+1.2V_VCCPLL_OC on BOTTOM (solid shape): 325.74,44.19 325.74,42.68 325.61,42.55 324.57,42.55 324.3,42.82 324.3,43.98 324.77,44.45 325.48,44.45
+1.2V_VCCPLL_OC on BOTTOM (solid shape): 244.36,69.12 244.36,67.8 244.1,67.53 242.86,67.53 242.61,67.78 242.61,69.18 242.74,69.31 244.18,69.31
+1.2V_VCCPLL_OC on BOTTOM (solid shape): 244.4,56.95 244.4,55.92 244.13,55.65 241.78,55.65 241.53,55.9 241.53,57.94 242.04,58.45 242.9,58.45
+1.2V_VCCPLL_OC on BOTTOM (solid shape): outline of 166 points within 336.29,37.46 341.09,40.61
+1.2V_VCCPLL_OC on IN1 (solid shape): outline of 7518 points within 143.61,80.64 182.5,87.25
+1.2V_VCCPLL_OC on IN2 (solid shape): 224.54,54.69 224.54,53.71 224.44,53.61 222.95,53.61 222.31,54.24 222.31,55.15 222.53,55.36 223.86,55.36
+1.2V_VCCPLL_OC on IN2 (solid shape): 242.49,58.3 242.49,57.23 242.31,57.04 240.99,57.04 240.85,57.18 240.85,58.04 241.26,58.45 242.34,58.45
+1.2V_VCCPLL_OC on IN3 (solid shape): 322.56,53.59 322.56,52.96 321.82,52.22 319.38,52.22 319.02,52.59 319.02,53.1 319.62,53.7 322.45,53.7
+1.2V_VCCPLL_OC on IN3 (solid shape): 245.48,69.91 245.48,68.78 245.32,68.61 242.73,68.61 242.55,68.8 242.55,70.32 242.61,70.39 245.01,70.39
+1.2V_VCCPLL_OC on IN4 (solid shape): 200.82,48.53 203.75,48.53 203.91,48.36 203.91,47.87 203.84,47.8 200.04,47.8 199.24,48.59 199.24,49.02 199.59,49.38 199.97,49.38
+1.2V_VCCPLL_OC on IN4 (solid shape): outline of 404 points within 139.33,77.8 146.1,86.79
+1.2V_VCCPLL_OC on TOP: 324.63,46.05 324.68,46.1 325.83,46.1 326.19,45.75 326.19,43.72 325.86,43.39 324.28,43.39 324.13,43.54 324.13,45.74 324.45,46.05
+1.2V_VCCPLL_OC_OUT on TOP (solid shape): 226.62,54.14 226.62,51.92 226.52,51.82 224.98,51.82 224.65,52.15 224.65,53.39 225.08,53.39 225.08,54.32 226.44,54.32
+1.2VP on TOP (solid shape): 122.59,76.29 122.59,74.01 121.96,73.37 120.94,73.37 120.94,72.86 120.56,72.86 120.56,73.37 119.74,73.37 119.74,72.86 119.42,72.86 119.42,73.37 116.82,73.37 116.31,73.88 116.31,76.48 116.43,76.61 122.28,76.61
+1.2VP on BOTTOM (solid shape): 117.39,83.85 117.39,81.5 117.86,81.02 125.99,81.02 126.21,80.8 126.21,79.85 126.66,79.4 126.66,75.72 124.37,73.43 120.94,73.43 120.94,72.93 120.56,72.93 120.56,73.43 119.8,73.43 119.8,72.93 119.42,72.93 119.42,73.43 117.13,73.43 116.37,74.2 116.37,77.24 115.23,78.39 111.8,78.39 111.29,78.9 111.29,83.09 112.23,84.03 117.21,84.03
+1.8V_PRIM on TOP (solid shape): 267.12,74.88 267.12,73.78 267.11,73.78 266.93,72.51 267.11,71.24 267.12,71.24 267.12,70.19 266.42,69.5 265.72,69.5 264.77,70.45 264.77,70.78 265.47,71.47 265.47,74.66 265.47,74.66 265.47,74.89 265.6,75.02 266.97,75.02
+1.8V_PRIM on TOP (solid shape): 220.24,75.1 220.24,73.51 220.23,73.51 219.93,73.18 220.23,72.85 220.24,72.85 220.24,71.58 219.88,71.21 218.54,71.21 218.29,71.47 218.29,73.49 218.39,73.73 218.29,73.97 218.29,74.84 218.43,74.99 218.44,75.21 218.44,75.23 218.61,75.41 219.93,75.41
+1.8V_PRIM on BOTTOM (solid shape): 266.68,89.5 266.68,88.97 266.13,88.97 266.13,88.42 266.68,88.42 266.68,88.17 266.13,88.17 266.13,87.62 266.68,87.62 266.68,87.09 266.36,86.77 265.22,86.77 265.09,86.9 265.09,89.44 265.34,89.69 266.49,89.69
+1.8V_PRIM on BOTTOM (solid shape): 219.62,75.24 219.62,72.87 218.92,72.16 218.92,71.46 218.82,71.36 218.82,70.63 218.72,70.54 217.96,70.54 217.94,70.55 217.78,70.59 217.62,70.55 217.6,70.54 217.1,70.54 217.02,70.62 217.02,71.29 217.11,71.37 217.92,71.37 218.18,71.63 218.18,72.95 218.61,73.37 218.61,75.19 218.78,75.36 219.5,75.36
+1.8V_PRIM on IN3 (solid shape): outline of 719 points within 280.8,31.35 290.18,34.98
+1.8V_PRIM on TOP: 333.92,24.77 335.42,24.77 335.85,25.2 335.85,26.48 335.69,26.65 334.21,26.65 333.73,26.17 333.73,24.97
+1.8V_PRIM on IN1: outline of 270 points within 218.02,72.93 268.2,90.39
+1.8V_PRIM on IN2: 314.27,53.79 313.22,53.79 313.1,53.68 313.1,52.39 313.25,52.24 314.27,52.24 314.47,52.45 314.47,53.59
+1.8V_PRIM on IN2: 333.35,26.89 335.45,26.89 335.79,26.55 335.79,26.01 335.51,25.74 333.3,25.74 333.18,25.85 333.18,26.72
+1.8V_PRIM on IN3: 265.99,89.61 266.13,89.47 266.13,85.87 265.95,85.69 265.12,85.69 264.95,85.86 264.95,89.52 265.04,89.61
+1.8V_PRIM on IN3: 313.02,54.69 314.33,54.69 314.51,54.52 314.51,53.47 314.33,53.3 313.28,53.3 312.65,53.93 312.65,54.32
+1.8V_PRIM on IN4: 265.46,75.66 263.69,77.43 263.69,80.28 263.75,80.38 263.86,80.36 264.42,80.59 263.86,80.83 263.75,80.81 263.69,80.9 263.69,88.48 265,89.79 267.28,89.79 267.82,89.25 267.82,86.42 267.81,86.32 267.82,86.23 267.82,80.26 267.81,80.17 267.82,80.07 267.82,78.86 267.81,78.77 267.82,78.68 267.82,78.47 268.15,78.14 268.15,72.34 267.91,72.11 265.65,72.11 265.46,72.3
+1.8VSP on TOP (solid shape): 269.79,86.52 269.79,83.02 268.58,81.82 267.25,81.82 267.12,81.94 267.12,86.77 267.25,86.9 269.41,86.9
+1.8VSP on BOTTOM (solid shape): 268.2,89.63 268.63,88.22 269.53,87.05 269.53,82.77 269.28,82.51 267.31,82.51 267.25,82.58 267.25,86.64 266.81,87.08 266.81,87.75 266.29,87.75 266.29,88.04 266.81,88.04 266.81,88.55 266.29,88.55 266.29,88.84 266.81,88.84 266.81,89.43 267.05,89.67 268.19,89.67
+1.35VS_VGA on TOP (solid shape): outline of 45048 points within 198.29,67.39 266.11,143.79
+1.35VS_VGA on BOTTOM (solid shape): 263.2,131.41 263.2,128.45 263.13,128.38 258.99,128.38 258.91,128.47 258.91,131.56 258.97,131.62 262.99,131.62
+1.35VS_VGA on BOTTOM (solid shape): 200.87,145.09 200.87,144.19 200.78,144.1 200.78,143.06 200.87,142.97 200.87,142.73 200.74,142.59 200.48,142.59 200.15,142.92 200.15,145.1 200.19,145.15 200.82,145.15
+1.35VS_VGA on BOTTOM (solid shape): 202.45,135.64 202.45,135.55 202.12,135.23 202.12,135.1 202.82,134.4 202.82,134.32 202.71,134.21 202.58,134.21 201.71,135.08 201.71,135.25 202.23,135.77 202.31,135.77
+1.35VS_VGA on BOTTOM (solid shape): 204.93,141.73 204.93,141.3 204.86,141.24 204.24,141.24 203.65,140.64 203.39,140.64 203.31,140.72 203.31,140.84 204.28,141.81 204.43,141.81 204.44,141.82 204.83,141.82
+1.35VS_VGA on BOTTOM (solid shape): 254.56,118.46 254.56,118.3 254.27,118.01 254.27,117.91 255.36,116.82 255.36,116.68 255.31,116.63 255.14,116.63 253.89,117.88 253.89,118.04 254.37,118.52 254.49,118.52
+1.35VS_VGA on BOTTOM (solid shape): 249.66,130.52 249.66,129.38 249.47,129.19 247.18,129.19 246.3,130.07 245.42,130.07 245.17,130.32 245.17,130.5 245.29,130.61 246.37,130.61 246.45,130.69 249.49,130.69
+1.35VS_VGA on BOTTOM (solid shape): 253.39,96.85 253.39,96.72 252.32,95.65 252.32,95.49 252.56,95.24 252.56,95.1 252.48,95.01 252.47,95.01 252.26,95.01 251.8,95.47 251.8,95.64 253.1,96.93 253.3,96.93
+1.35VS_VGA on BOTTOM (solid shape): 202.8,137.66 202.8,137.49 202.17,136.86 202.17,136.73 202.48,136.42 202.48,136.31 202.39,136.22 202.17,136.22 201.71,136.69 201.71,136.85 202.51,137.66 202.51,137.68 202.57,137.74 202.72,137.74
+1.35VS_VGA on BOTTOM (solid shape): 213.94,130.68 213.94,130.01 213.88,129.95 211.66,129.95 211.62,129.99 210.81,129.99 210.51,130.29 210.51,130.47 210.6,130.56 210.71,130.56 210.9,130.37 212.7,130.37 213.03,130.7 213.91,130.7
+1.35VS_VGA on BOTTOM (solid shape): 236.7,133.65 236.7,133.5 236.62,133.41 236.45,133.41 235.78,134.08 235.69,134.08 235.03,133.42 235.03,133.42 234.61,133 234.47,133 234.39,133.08 234.39,134.05 234.88,134.54 235.81,134.54
+1.35VS_VGA on BOTTOM (solid shape): 253.24,123.18 253.24,121.95 254.29,120.9 254.29,120.3 254.54,120.04 254.54,119.87 254.51,119.84 254.24,119.84 253.75,120.32 253.75,120.69 252.57,121.87 252.57,123.17 252.64,123.24 253.18,123.24
+1.35VS_VGA on BOTTOM (solid shape): 258.46,75.24 258.52,75.24 259.38,74.38 259.38,74.16 259.26,74.04 258.36,74.04 257.86,74.54 257.86,74.84 258,74.98 258,75.27 257.86,75.42 257.86,75.61 257.93,75.68 258.03,75.68
+1.35VS_VGA on BOTTOM (solid shape): 262.96,118.05 262.96,117.88 261.82,116.74 261.82,116.16 261.73,116.07 261.53,116.07 261.46,116.14 261.46,116.81 262.55,117.9 262.55,118.02 262.28,118.29 262.28,118.44 262.34,118.5 262.51,118.5
+1.35VS_VGA on BOTTOM (solid shape): 264.46,123.18 264.46,122.14 263.9,121.58 263.9,120.3 264.18,120.02 264.18,119.91 264.1,119.83 263.83,119.83 263.36,120.3 263.36,121.89 263.66,122.19 263.66,123.1 263.81,123.25 264.39,123.25
+1.35VS_VGA on BOTTOM (solid shape): 215.19,133.52 215.19,132.52 215.42,132.29 218.31,132.29 218.44,132.16 218.99,132.16 219.09,132.07 219.09,131.79 218.68,131.39 218.32,131.39 218.1,131.61 214.81,131.61 214.51,131.91 214.51,133.55 214.55,133.59 215.12,133.59
+1.35VS_VGA on BOTTOM (solid shape): 219.09,130.46 219.09,130.31 218.78,129.99 218.78,129.87 218.56,129.65 217.63,129.65 216.83,128.85 215.58,128.85 215.47,128.96 215.47,129.43 215.6,129.55 216.75,129.55 217.38,130.18 218.52,130.18 218.9,130.56 218.99,130.56
+1.35VS_VGA on BOTTOM (solid shape): 222.27,131.26 222.27,131.1 222.21,131.03 222.07,131.03 221.38,131.72 221.3,131.72 221.04,131.46 220.79,131.46 220.39,131.86 220.39,132.08 220.43,132.12 220.58,132.12 220.89,131.81 220.96,131.81 221.29,132.14 221.39,132.14
+1.35VS_VGA on BOTTOM (solid shape): 235.58,137.97 235.81,137.97 236.02,138.18 236.02,138.19 236.38,138.55 236.61,138.55 236.71,138.44 236.71,138.32 236.25,137.86 236.25,137.76 235.91,137.42 234.61,137.42 234.24,137.8 234.24,138.83 234.39,138.98 234.57,138.98
+1.35VS_VGA on BOTTOM (solid shape): 248.63,138.78 248.63,138.14 248.55,138.06 247.66,138.06 247.22,138.5 245.71,138.5 245.44,138.24 245.22,138.24 245.17,138.28 245.17,138.46 245.5,138.78 245.5,138.87 245.64,139.01 245.74,139.01 245.78,139.06 248.35,139.06
+1.35VS_VGA on BOTTOM (solid shape): 260.8,93.37 260.87,93.37 261.03,93.21 261.03,92.25 261.98,91.29 261.98,90.31 261.92,90.25 261.4,90.25 261.3,90.35 261.3,91.18 260.51,91.97 260.51,93.21 260.25,93.47 260.25,93.64 260.33,93.72 260.46,93.72
+1.35VS_VGA on BOTTOM (solid shape): 200.16,142.04 200.16,141.91 200.42,141.64 200.42,141.45 200.41,141.44 200.13,141.44 199.85,141.72 199.05,141.72 198.41,141.09 198.41,139.54 198.22,139.35 197.4,139.35 197.24,139.51 197.24,141.28 198.26,142.31 199.89,142.31
+1.35VS_VGA on BOTTOM (solid shape): 247.61,141.92 248.6,141.92 248.67,141.86 248.67,141.22 248.57,141.13 247.35,141.13 246.8,141.69 245.8,141.69 245.5,141.39 245.25,141.39 245.14,141.49 245.14,141.74 245.64,142.24 247.29,142.24
+1.35VS_VGA on BOTTOM (solid shape): 200.59,134.26 200.74,134.26 200.96,134.47 201.23,134.47 202.01,133.69 202.01,133.5 201.92,133.41 201.81,133.41 201.11,134.11 200.99,134.11 200.08,133.19 200.08,133.13 199.93,132.98 199.8,132.98 199.66,133.12 199.66,134.02 200.18,134.54 200.3,134.54
+1.35VS_VGA on BOTTOM (solid shape): 227.88,138.45 227.88,138.3 227.23,137.65 227.23,137.49 227.68,137.04 227.69,137.04 227.88,136.85 227.88,136.66 227.42,136.2 227.25,136.2 227.15,136.3 227.15,136.51 227.39,136.75 227.39,136.88 226.77,137.5 226.77,137.63 227.69,138.55 227.78,138.55
+1.35VS_VGA on BOTTOM (solid shape): 250.6,88.04 250.6,87.28 250.53,87.22 250.53,85.77 250.66,85.64 250.66,85.48 250.94,85.2 250.94,85.01 250.92,84.99 250.55,84.99 249.94,85.6 249.93,85.64 249.91,85.67 249.91,88.07 249.96,88.12 250.52,88.12
+1.35VS_VGA on BOTTOM (solid shape): 253.79,77.61 253.79,77.37 253.72,77.3 253.53,77.3 253.23,77.6 253.12,77.6 252.92,77.4 252.92,76.6 252.49,76.17 252.33,76.17 252.25,76.25 252.25,76.38 252.67,76.8 252.67,77.59 253.1,78.02 253.1,78.04 253.37,78.04
+1.35VS_VGA on BOTTOM (solid shape): 243.22,131.89 243.43,131.89 243.67,132.12 243.89,132.12 244.28,131.73 244.28,131.42 244.26,131.41 244.06,131.41 243.79,131.67 243.78,131.69 243.71,131.69 243.51,131.48 243.51,131.47 243.48,131.44 243.2,131.44 241.96,132.69 241.96,132.83 242.07,132.94 242.17,132.94
+1.35VS_VGA on BOTTOM (solid shape): 234.03,140.61 234.61,140.61 235.12,140.1 235.12,139.88 235.04,139.8 234.82,139.8 234.62,140 233.28,140 232.83,140.44 230.93,140.44 230.58,140.08 229.68,140.08 229.4,139.81 229.26,139.81 229.16,139.91 229.16,140.06 229.21,140.11 229.21,140.17 230.29,141.25 233.4,141.25
+1.35VS_VGA on BOTTOM (solid shape): 251.34,102.06 251.34,101.71 251.3,101.55 251.34,101.39 251.34,101.26 251.76,100.85 251.76,100.66 251.69,100.59 251.52,100.59 251.07,101.05 251.07,101.83 250.64,102.26 250.64,102.44 250.73,102.53 250.88,102.53
+1.35VS_VGA on BOTTOM (solid shape): 254.94,75.68 254.94,75.42 254.92,75.4 254.92,74.59 254.46,74.12 253.54,74.12 253.43,74.23 253.43,74.4 254.35,75.31 254.35,75.7 254.13,75.92 253.88,75.92 253.67,75.72 253.52,75.72 253.38,75.85 253.38,76 253.46,76.08 253.51,76.08 253.9,76.48 254.15,76.48
+1.35VS_VGA on BOTTOM (solid shape): 255.87,123.15 255.87,121.32 257.28,119.91 257.28,119.39 256.3,118.42 256.3,118.32 256.94,117.67 256.94,117.49 256.87,117.42 256.71,117.42 255.9,118.23 255.9,118.49 256.52,119.1 256.54,119.1 256.54,119.23 255.36,120.41 255.36,122.06 255.06,122.36 255.06,123.13 255.14,123.21 255.8,123.21
+1.35VS_VGA on BOTTOM (solid shape): 229.92,131.61 229.92,130.7 229.43,130.21 229.27,130.21 229.17,130.31 229.17,130.46 229.57,130.86 229.57,131 229.63,131.18 229.57,131.35 229.57,131.46 229.16,131.88 229.16,132.02 229.28,132.15 229.37,132.15
+1.35VS_VGA on BOTTOM (solid shape): 232.02,138.54 232.6,138.54 232.73,138.41 232.73,137.68 232.59,137.54 230.68,137.54 230.32,137.91 230.03,137.91 229.96,137.91 229.88,137.89 229.49,137.89 229.14,138.24 229.14,138.53 229.63,139.03 229.74,139.03 229.74,139.03 231.53,139.03
+1.35VS_VGA on BOTTOM (solid shape): 237.51,137.68 237.51,137.46 237.07,137.02 237.07,135.5 236.91,135.34 236.91,135.11 237.52,134.5 237.52,134.32 237.4,134.2 237.19,134.2 236.35,135.04 236.35,135.23 236.8,135.69 236.8,136.18 236.39,136.59 236.39,136.7 236.38,136.7 236.38,136.98 237.18,137.77 237.41,137.77
+1.35VS_VGA on BOTTOM (solid shape): 200.42,138.42 200.42,138.35 200.12,138.05 200.12,137.91 200.34,137.69 200.38,137.65 200.92,137.65 201.16,137.89 201.16,138.02 201.35,138.21 201.46,138.21 201.79,138.55 201.95,138.55 202.03,138.47 202.03,138.33 201.1,137.39 200.16,137.39 199.67,137.89 199.67,138.07 200.15,138.55 200.29,138.55
+1.35VS_VGA on BOTTOM (solid shape): 235.1,132.05 235.1,131.89 234.69,131.48 234.69,131.36 234.63,131.18 234.69,130.99 234.69,130.89 235.1,130.47 235.1,130.29 235.02,130.2 234.77,130.2 234.39,130.58 234.39,131.71 234.75,132.07 234.76,132.07 234.83,132.14 235.02,132.14
+1.35VS_VGA on BOTTOM (solid shape): 254.32,103.9 254.49,103.9 254.67,104.07 254.67,104.08 254.71,104.12 254.83,104.12 254.94,104.02 254.94,103.87 254.67,103.6 254.67,103.47 254.92,103.22 254.92,103.06 254.61,102.75 254.61,102.67 254.14,102.19 253.89,102.19 253.85,102.24 253.85,102.48 254.46,103.09 254.46,103.26 253.39,104.33 253.39,104.43 253.53,104.57 253.65,104.57
+1.35VS_VGA on BOTTOM (solid shape): 229.49,134.46 229.49,134.32 229.16,134 229.16,133.95 229.71,133.41 229.77,133.41 229.93,133.25 229.93,133.11 229.8,132.97 229.7,132.97 228.57,134.11 228.48,134.11 227.98,133.61 227.98,133.57 228.28,133.27 228.28,133.27 228.28,133.1 228.19,133 228.04,133 227.58,133.47 227.58,133.7 228.4,134.52 228.6,134.52 228.84,134.28 229,134.28 229.26,134.54 229.4,134.54
+1.35VS_VGA on BOTTOM (solid shape): 213.92,142.07 213.92,141.44 213.77,141.29 212.84,141.29 211.64,140.08 211.01,140.08 210.74,139.81 210.57,139.81 210.48,139.91 210.48,140.05 210.55,140.12 210.55,140.21 211,140.66 211.25,140.66 211.61,141.01 211.61,141.31 211.41,141.51 210.85,141.51 210.73,141.4 210.57,141.4 210.48,141.49 210.48,141.73 210.89,142.14 213.85,142.14
+1.35VS_VGA on BOTTOM (solid shape): 257.57,111.42 257.68,111.42 257.96,111.7 258.89,111.7 259.15,111.45 259.23,111.45 259.88,112.1 260.15,112.1 260.98,111.28 260.98,111.08 260.92,111.03 260.79,111.03 260.79,111.03 260.7,111.03 260.09,111.64 259.95,111.64 259.35,111.04 259.15,111.04 258.73,111.45 258.08,111.45 257.68,111.05 257.56,111.05 256.67,111.93 256.67,112.04 256.74,112.11 256.87,112.11
+1.35VS_VGA on BOTTOM (solid shape): 244.38,138.85 244.38,138.69 244.11,138.41 244.11,138.33 244.44,138.01 244.44,137.87 244.66,137.65 245.07,137.65 245.65,138.23 245.89,138.23 246.03,138.09 246.03,137.86 245.41,137.24 244.38,137.24 243.37,136.23 243.28,136.23 243.15,136.37 243.15,136.47 244.05,137.37 244.05,137.7 243.75,138 243.57,138 243,137.43 242.79,137.43 242.34,137.88 242.34,138.11 242.41,138.18 242.54,138.18 242.85,137.87 242.99,137.87 243.8,138.68 243.8,138.77 244.05,139.02 244.22,139.02
+1.35VS_VGA on BOTTOM (solid shape): 258.56,96.51 258.56,96.27 258.28,96 258.28,95.93 259.39,94.82 259.39,94.68 259.3,94.59 259.11,94.59 258.91,94.78 258.64,94.78 258.04,94.18 258.04,93.74 258.21,93.56 258.58,93.56 258.73,93.72 258.95,93.72 259.38,93.28 259.38,93.05 259.26,92.93 258.36,92.93 257.72,93.56 257.72,94.39 256.64,95.47 256.64,95.64 256.74,95.74 256.91,95.74 257.36,95.28 257.36,95.17 257.87,94.66 258.06,94.66 258.52,95.12 258.52,95.19 257.86,95.85 257.86,96.05 258.37,96.55 258.51,96.55
+1.35VS_VGA on BOTTOM (solid shape): 209.67,138.93 209.67,138.68 209.44,138.45 209.44,138.25 210.1,137.59 210.42,137.59 210.67,137.84 210.67,138.12 210.5,138.28 210.5,138.5 210.8,138.8 210.8,138.88 210.93,139.01 211.22,139.01 212.71,137.51 213.2,137.51 213.38,137.33 213.38,136.87 213.24,136.73 212.5,136.73 211.61,137.62 211.03,137.62 210.66,137.24 209.86,137.24 208.76,136.15 208.57,136.15 208.43,136.29 208.43,136.48 209.41,137.46 209.41,137.74 208.9,138.24 208.9,138.55 209.37,139.02 209.58,139.02
+1.35VS_VGA on BOTTOM (solid shape): 220.69,135.27 220.69,135.1 220.27,134.68 220.27,134.68 220.04,134.46 220.04,134.3 220.46,133.88 220.59,133.88 221.27,134.56 221.42,134.56 221.5,134.49 221.5,134.24 220.69,133.43 220.47,133.43 219.78,134.12 219.69,134.12 218.98,133.4 218.88,133.4 218.77,133.52 218.77,133.64 218.95,133.82 218.95,133.82 219.07,133.93 219.07,134.02 218.77,134.32 218.77,134.44 218.87,134.54 218.98,134.54 219.26,134.25 219.39,134.25 219.86,134.73 219.86,134.84 220.03,135 220.12,135 220.46,135.33 220.47,135.35 220.6,135.35
+1.35VS_VGA on BOTTOM (solid shape): 209.25,141.69 209.25,141.43 208.83,141.01 208.83,140.97 208.76,140.78 208.83,140.59 208.83,140.44 209.23,140.04 209.23,139.91 209.13,139.82 208.95,139.82 208.7,140.06 208.58,140.06 208.32,139.8 208.16,139.8 208.08,139.88 208.08,140.11 208.47,140.5 208.47,140.57 208.56,140.78 208.47,140.99 208.47,141.22 209.01,141.75 209.19,141.75
+1.35VS_VGA on BOTTOM (solid shape): 253.05,88.12 253.05,87.15 253.86,86.33 253.86,86.15 254.34,85.67 254.48,85.67 254.94,85.22 254.94,85.01 254.86,84.93 254.86,84.44 254.9,84.4 255.65,83.65 255.66,83.65 255.74,83.57 255.74,83.43 255.68,83.37 255.5,83.37 254.83,84.04 254.76,84.04 254.28,83.55 254.28,83.45 254.79,82.93 254.8,82.93 254.96,82.76 254.96,82.64 254.88,82.56 254.63,82.56 253.86,83.32 253.86,83.63 254.45,84.22 254.45,84.33 253.31,85.47 253.31,86.01 252.34,86.98 252.34,88.07 252.45,88.18 252.99,88.18
+1.35VS_VGA on BOTTOM (solid shape): 211.96,109.2 212.09,109.11 212.24,109.07 212.26,109.07 212.36,108.97 212.39,108.9 212.42,108.85 212.42,108.69 212.36,108.6 212.27,108.33 212.39,108.07 212.43,107.99 212.4,107.92 212.35,107.88 212.2,107.88 211.1,108.98 211.1,109.13 211.18,109.2
+1.35VS_VGA on BOTTOM (solid shape): 256.05,102.1 256.24,102.1 256.4,102.05 256.55,102.1 256.74,102.1 257.14,102.49 257.3,102.49 258.15,101.64 258.15,101.48 258.06,101.39 257.93,101.39 257.24,102.08 257.17,102.08 256.9,101.81 256.55,101.81 256.4,101.85 256.24,101.81 255.9,101.81 255.66,102.05 255.58,102.05 254.91,101.38 254.71,101.38 254.62,101.47 254.62,101.61 254.96,101.96 254.96,102.02 255.45,102.5 255.57,102.5 255.57,102.51 255.64,102.51
+1.35VS_VGA on BOTTOM (solid shape): 259.41,75.99 259.41,75.82 259.3,75.71 259.15,75.71 258.23,76.63 257.82,76.63 257.33,76.14 257.13,76.14 256.72,76.56 256.56,76.56 256.4,76.61 256.23,76.56 256.14,76.46 255.98,76.46 255.7,76.18 255.43,76.18 254.64,76.97 254.64,77.18 254.71,77.26 254.85,77.26 255.38,76.73 255.6,76.73 255.8,76.94 256.15,76.94 256.23,76.86 256.4,76.81 256.56,76.86 256.64,76.93 256.87,76.93 257.07,76.73 257.31,76.73 257.83,77.26 258.13,77.26
+1.35VS_VGA on BOTTOM (solid shape): 210.05,134.46 210.48,134.46 210.56,134.54 210.76,134.54 211.29,134.02 211.29,132.93 211.41,132.81 212.59,132.81 212.87,133.09 212.87,133.48 213.02,133.63 213.9,133.63 213.96,133.58 213.96,133 213.85,132.89 213.44,132.89 212.85,132.3 211.04,132.3 210.93,132.41 210.93,132.66 210.98,132.71 210.98,132.94 210.55,133.37 210.55,133.67 210.58,133.7 210.58,134.22 210.5,134.3 210,134.3 209.4,133.7 209.4,133.55 209.67,133.29 209.67,133.07 209.56,132.97 209.39,132.97 209.26,133.1 209.26,133.15 208.12,134.28 208.12,134.49 208.17,134.54 208.37,134.54 208.95,133.96 209.21,133.96 209.56,134.31 209.56,134.47 208.86,135.17 208.86,135.28 208.95,135.36 209.14,135.36
+1.35VS_VGA on BOTTOM (solid shape): 229.27,89.91 229.47,89.71 229.47,89.69 229.53,89.54 229.65,89.42 229.65,88.72 229.62,88.71 229.47,88.61 229.33,88.33 229.28,88.3 229.25,88.28 229.09,88.28 229,88.34 228.86,88.42 228.7,88.43 228.52,88.61 228.52,89.51 228.77,89.77 228.89,89.8 229.09,89.92 229.25,89.92
+1.35VS_VGA on BOTTOM (solid shape): 259.29,88.11 259.29,87.04 260.26,86.07 260.26,85.45 260.55,85.16 260.55,84.99 260.51,84.95 260.3,84.95 259.85,85.4 259.33,85.4 258.86,84.92 258.74,84.92 258.63,85.03 258.63,85.19 258.6,85.21 258.34,85.21 258.05,84.92 258.05,84.48 258.22,84.3 258.33,84.3 258.63,84 258.63,83.91 258.97,83.57 258.97,83.42 258.95,83.42 258.38,82.84 258.38,82.63 258.58,82.43 258.58,82.2 258.48,82.1 258.31,82.1 257.84,82.57 257.84,82.85 258.38,83.39 258.38,83.62 258.06,83.94 257.94,83.94 256.86,82.86 256.72,82.86 256.57,83.01 256.57,83.11 257.68,84.22 257.68,85 258.4,85.72 258.67,85.72 258.89,85.94 258.89,86.45 258.54,86.79 258.54,88.07 258.66,88.18 259.22,88.18
+1.35VS_VGA on BOTTOM (solid shape): 219.1,140.06 219.1,139.93 218.78,139.6 218.78,139.44 218.7,139.36 218.67,139.32 218.67,138.83 219.09,138.41 219.09,138.28 218.81,138.01 218.81,137.95 219.1,137.66 219.14,137.63 219.5,137.63 220.14,138.27 220.14,138.44 219.92,138.66 219.92,138.9 220.02,138.99 220.19,138.99 221.19,137.99 221.43,137.99 221.63,138.18 221.84,138.18 221.96,138.07 221.96,137.86 221.51,137.42 221.21,137.42 220.55,138.08 220.46,138.08 220.1,137.73 220.1,137.45 221.12,136.43 221.12,136.24 221.05,136.17 220.84,136.17 219.74,137.27 218.74,137.27 217.97,138.04 217.97,138.84 217.72,139.08 215.84,139.08 215.71,139.21 215.71,139.76 215.82,139.87 218.58,139.87 218.84,140.13 219.03,140.13
+1.35VS_VGA on BOTTOM (solid shape): 254.95,96.06 254.95,95.82 254.49,95.36 254.49,94.94 254.66,94.77 254.9,94.77 255.45,95.32 255.68,95.32 255.74,95.26 255.74,95.08 255.64,94.99 255.55,94.99 255.34,94.78 255.34,94.66 254.86,94.18 254.86,93.72 254.97,93.61 254.97,93.31 254.75,93.09 254.75,92.35 254.77,92.34 254.77,90.9 254.67,90.81 254.1,90.81 253.69,90.39 253.69,89.31 253.52,89.15 253.1,89.15 252.95,89.3 252.95,92.18 253.11,92.34 253.11,92.85 253.48,93.22 253.53,93.22 253.82,93.51 253.82,93.63 253.91,93.72 254.06,93.72 254.2,93.58 254.62,93.58 254.72,93.69 254.72,94.17 254.05,94.83 253.97,94.83 253.66,94.52 253.52,94.52 253.4,94.64 253.4,94.8 254.66,96.06 254.7,96.11 254.9,96.11
+1.35VS_VGA on BOTTOM (solid shape): 244.65,134.46 244.76,134.46 244.93,134.42 245.1,134.46 245.19,134.46 245.28,134.56 246.05,134.56 246.14,134.47 246.14,133.41 246.1,133.36 245.32,133.36 245.21,133.47 245.21,133.67 245.27,133.74 245.27,133.89 245.28,133.98 245.27,134.06 245.27,134.2 245.18,134.29 245.09,134.29 244.93,134.33 244.76,134.29 244.65,134.29 244.05,133.69 244.05,133.52 244.29,133.28 244.29,133.1 244.16,132.97 244.04,132.97 242.75,134.27 242.75,134.48 242.84,134.58 242.96,134.58 243.63,133.9 243.81,133.9 244.23,134.32 244.23,134.47 243.56,135.14 243.56,135.26 243.62,135.32 243.79,135.32
+1.35VS_VGA on BOTTOM (solid shape): 226.61,109.28 226.76,109.12 226.98,109.07 227,109.07 227.05,109.03 227.05,109 227.05,108.59 226.97,108.35 227.05,108.11 227.05,107.93 226.95,107.83 225.51,107.83 225.45,107.88 225.45,108.03 225.63,108.29 225.54,108.6 225.48,108.69 225.48,108.85 225.51,108.9 225.54,108.97 225.64,109.07 225.66,109.07 225.85,109.13 225.99,109.28
+1.35VS_VGA on BOTTOM (solid shape): 261.7,123.13 261.7,120.88 261.97,120.61 262.08,120.61 262.58,120.11 262.58,119.9 262.53,119.85 262.29,119.85 261.85,120.29 261.47,120.29 261.02,119.84 260.69,119.84 260.52,120.01 260.29,120.01 260.1,119.82 260.1,119.31 260.12,119.29 260.12,119.26 260.95,118.43 260.94,118.42 260.94,118.3 260.26,117.62 260.26,117.53 260.62,117.17 260.62,117.04 260.51,116.93 260.42,116.93 259.9,117.45 259.9,117.66 260.53,118.29 260.53,118.44 260.12,118.86 259.98,118.86 259.37,118.24 259.12,118.24 258.74,118.62 258.6,118.62 258.43,118.67 258.26,118.62 258.13,118.62 257.74,118.23 257.51,118.23 257.47,118.26 257.47,118.41 257.58,118.52 257.61,118.52 257.97,118.89 258.9,118.89 259.18,118.6 259.27,118.6 259.77,119.11 259.77,119.94 260.13,120.3 260.13,121.84 259.94,122.04 259.94,122.56 260.01,122.63 260.73,122.63 260.84,122.75 260.84,123.2 260.93,123.29 261.54,123.29
+1.35VS_VGA on BOTTOM (solid shape): 228.46,106.7 228.71,106.57 228.98,106.65 229.07,106.7 229.28,106.7 229.33,106.67 229.39,106.65 229.45,106.62 229.47,106.55 229.51,106.36 229.65,106.22 229.65,105.52 229.63,105.51 229.45,105.39 229.37,105.19 229.37,105.17 229.33,105.13 229.28,105.1 229.25,105.08 229.09,105.08 228.96,105.17 228.92,105.24 228.95,105.32 228.96,105.34 228.97,105.77 228.53,105.77 228.51,105.74 228.38,105.7 228.26,105.7 228.2,105.76 228.2,106.6 228.3,106.7
+1.35VS_VGA on BOTTOM (solid shape): 265.95,74.88 265.95,67.06 265.09,66.2 261.66,66.2 261.66,66.7 260.9,66.7 260.9,66.2 260.52,66.2 260.52,66.7 259.63,66.7 259.63,66.2 256.33,66.2 256.33,66.7 255.44,66.7 255.44,66.2 255.06,66.2 255.06,66.7 254.17,66.7 254.17,66.2 253.53,66.2 253.28,66.45 253.28,70.89 254.93,72.55 257.53,72.55 257.85,72.86 257.85,75.47 257.98,75.59 258.11,75.59 258.46,75.24 258.52,75.24 259.38,74.38 259.38,74.2 259.54,74.04 259.83,74.04 259.84,74.03 260,73.99 260.15,74.03 260.16,74.04 260.61,74.04 260.8,73.98 260.99,74.04 261.43,74.04 261.44,74.03 261.6,73.99 261.75,74.03 261.76,74.04 262.21,74.04 262.4,73.98 262.59,74.04 263.03,74.04 263.04,74.03 263.2,73.99 263.35,74.03 263.36,74.04 263.48,74.04 263.61,74.17 263.61,76.15 263.75,76.29 264.54,76.29
+1.35VS_VGA on BOTTOM (solid shape): 226.21,86.89 226.81,86.89 226.97,86.72 226.98,86.55 227.06,86.4 227.12,86.32 227.12,86.15 227.09,86.11 227.07,86.06 226.78,85.78 225.8,85.78 225.54,86.03 225.51,86.1 225.48,86.15 225.48,86.32 225.54,86.4 225.25,87.03 224.96,86.4 225.02,86.32 225.02,86.15 225.01,86.13 224.7,85.83 223.7,85.83 223.6,85.93 223.59,85.93 223.4,86.13 223.38,86.15 223.38,86.32 223.47,86.44 223.54,86.48 223.62,86.45 223.64,86.44 223.87,86.35 224.09,86.46 224.24,86.61 224.24,86.87 224.62,87.25 225.85,87.25
+1.35VS_VGA on BOTTOM (solid shape): outline of 100 points within 220.37,138.55 226.31,141.48
+1.35VS_VGA on BOTTOM (solid shape): 217.95,87.03 217.95,86.64 218.14,86.37 218.47,86.44 218.48,86.45 218.56,86.48 218.63,86.44 218.72,86.32 218.72,86.15 218.7,86.12 218.67,86.07 218.33,85.73 217.5,85.73 217.1,86.13 217.08,86.15 217.08,86.32 217.14,86.4 216.85,87.03 216.56,86.4 216.62,86.32 216.62,86.17 216.2,85.75 215.37,85.75 214.99,86.13 214.98,86.15 214.98,86.32 215.04,86.4 215.13,86.69 214.98,86.96 214.98,87.1 215.1,87.22 217.75,87.22
+1.35VS_VGA on BOTTOM (solid shape): outline of 130 points within 237.54,138.57 243.88,141.74
+1.35VS_VGA on BOTTOM (solid shape): 222.95,87.14 222.95,86.98 222.77,86.71 222.86,86.4 222.92,86.32 222.92,86.15 222.91,86.13 222.58,85.8 221.57,85.8 221.34,86.03 221.31,86.1 221.28,86.15 221.28,86.32 221.34,86.4 221.05,87.03 220.76,86.4 220.82,86.32 220.82,86.15 220.8,86.12 220.77,86.08 220.48,85.92 220.39,85.78 220.38,85.75 219.68,85.75 219.54,85.88 219.36,85.93 219.34,85.93 219.24,86.03 219.21,86.1 219.18,86.15 219.18,86.32 219.24,86.4 219.29,86.82 218.93,87.03 218.89,87.04 218.88,87.07 218.86,87.12 218.88,87.21 218.96,87.25 222.84,87.25
+1.35VS_VGA on BOTTOM (solid shape): outline of 181 points within 257.8,94.97 265.18,110.52
+1.35VS_VGA on BOTTOM (solid shape): 214,109.3 214.14,109.13 214.34,109.07 214.36,109.07 214.46,108.97 214.49,108.9 214.52,108.85 214.52,108.69 214.46,108.6 214.75,107.97 215.04,108.6 214.98,108.69 214.98,108.85 215.02,108.91 215.05,108.99 215.05,109 215.09,109.04 215.21,109.07 215.36,109.13 215.48,109.25 216.17,109.25 216.3,109.13 216.47,109.07 216.48,109.07 216.55,109 216.55,108.99 216.58,108.91 216.62,108.85 216.62,108.69 216.56,108.6 216.85,107.97 217.14,108.6 217.08,108.69 217.08,108.85 217.11,108.89 217.13,108.94 217.14,108.95 217.41,109.09 217.5,109.23 218.32,109.23 218.39,109.14 218.49,109.07 218.64,108.96 218.69,108.89 218.72,108.85 218.72,108.69 218.63,108.57 218.56,108.52 218.48,108.55 218.47,108.57 218.04,108.57 218.04,107.92 217.94,107.83 214.1,107.83 213.65,108.27 213.65,108.35 213.47,108.63 213.14,108.57 213.07,108.54 213,108.57 212.9,108.68 212.9,108.88 212.93,108.93 213.33,109.33 213.99,109.33
+1.35VS_VGA on BOTTOM (solid shape): 222.41,109.27 222.55,109.13 222.74,109.07 222.76,109.07 222.86,108.97 222.89,108.9 222.92,108.85 222.92,108.69 222.86,108.6 223.15,107.97 223.44,108.6 223.38,108.69 223.38,108.85 223.4,108.88 223.43,108.92 223.73,109.09 223.82,109.24 223.83,109.28 224.51,109.28 224.65,109.13 224.84,109.07 224.86,109.07 224.96,108.97 224.99,108.9 225.02,108.85 225.02,108.69 224.93,108.57 224.86,108.52 224.78,108.55 224.77,108.57 224.34,108.57 224.34,108.14 224.36,108.11 224.44,107.88 224.44,107.83 219.18,107.83 219.13,107.87 219.13,108.01 219.33,108.28 219.24,108.6 219.18,108.69 219.18,108.85 219.21,108.9 219.24,108.97 219.34,109.07 219.36,109.07 219.55,109.13 219.69,109.28 220.31,109.28 220.46,109.12 220.66,109.07 220.68,109.07 220.75,109 220.75,108.99 220.78,108.91 220.82,108.85 220.82,108.69 220.76,108.6 221.05,107.97 221.34,108.6 221.28,108.69 221.28,108.85 221.31,108.89 221.33,108.94 221.52,109.12 221.52,109.17 221.65,109.3 222.4,109.3
+1.35VS_VGA on BOTTOM (solid shape): 228.4,104.69 228.67,104.48 229,104.56 229.09,104.62 229.25,104.62 229.3,104.59 229.37,104.56 229.47,104.46 229.47,104.44 229.51,104.27 229.63,104.14 229.63,103.41 229.59,103.4 229.44,103.27 229.37,103.09 229.37,103.07 229.33,103.03 229.28,103 229.25,102.98 229.1,102.98 228.98,103.06 228.37,102.75 228.98,102.44 229.1,102.52 229.25,102.52 229.27,102.51 229.47,102.31 229.47,102.29 229.52,102.15 229.63,102.04 229.63,101.36 229.52,101.24 229.47,101.09 229.47,101.07 229.33,100.93 229.28,100.9 229.25,100.88 229.09,100.88 229,100.94 228.37,100.65 229,100.36 229.09,100.42 229.25,100.42 229.27,100.41 229.47,100.21 229.47,100.19 229.53,100.04 229.65,99.92 229.65,99.28 229.53,99.15 229.47,98.99 229.47,98.97 229.33,98.83 229.28,98.8 229.25,98.78 228.97,98.78 228.91,98.82 228.84,98.85 228.84,99 228.94,99.44 228.5,99.35 228.48,99.32 228.45,99.32 228.37,99.32 228.3,99.3 228.21,99.32 228.17,99.4 228.17,104.59 228.27,104.69
+1.35VS_VGA on BOTTOM (solid shape): 228.42,98.37 228.68,98.17 229,98.26 229.09,98.32 229.25,98.32 229.28,98.3 229.33,98.27 229.47,98.13 229.47,98.12 229.53,97.95 229.65,97.82 229.65,97.13 229.55,97.03 229.49,96.9 229.48,96.88 229.33,96.73 229.28,96.7 229.25,96.68 229.09,96.68 229,96.74 228.37,96.45 229,96.16 229.09,96.22 229.25,96.22 229.27,96.21 229.46,96.02 229.46,96.01 229.53,95.88 229.65,95.8 229.65,95.02 229.62,95.01 229.47,94.91 229.33,94.63 229.28,94.6 229.25,94.58 229.09,94.58 229,94.64 228.37,94.35 229,94.06 229.09,94.12 229.25,94.12 229.28,94.1 229.33,94.07 229.47,93.93 229.47,93.92 229.53,93.75 229.65,93.62 229.65,92.88 229.54,92.77 229.54,92.75 229.5,92.7 229.33,92.53 229.28,92.5 229.25,92.48 229.09,92.48 229,92.54 228.37,92.25 229,91.96 229.09,92.02 229.25,92.02 229.27,92.01 229.47,91.81 229.47,91.79 229.52,91.65 229.63,91.54 229.63,90.75 229.27,90.4 229.25,90.38 229.09,90.38 228.96,90.47 228.92,90.54 228.95,90.62 229.02,90.98 228.7,91.15 228.28,91.15 228.15,91.28 228.15,98.27 228.25,98.37
+1.35VS_VGA on IN1 (solid shape): outline of 184 points within 214.91,85.96 221.74,87.6
+1.35VS_VGA on IN1 (solid shape): outline of 6318 points within 212,85.99 234.79,143.83
+1.35VS_VGA on IN2 (solid shape): outline of 1300 points within 211.96,85.98 229.42,109.01
+1.35VS_VGA on IN3 (solid shape): outline of 8737 points within 199.15,125.59 263.42,145.6
+1.35VS_VGA on IN3 (solid shape): outline of 15520 points within 214.69,72.41 265.71,109.63
+1.35VS_VGA on IN4 (solid shape): outline of 2707 points within 256.51,72.14 265.27,87.42
+1.35VS_VGA on IN5 (solid shape): outline of 11805 points within 211.69,72.28 268.06,120.77
+1.35VS_VGAP on BOTTOM (solid shape): 254.8,65.81 255.69,65.81 255.69,66.45 256.07,66.45 256.07,65.81 259.88,65.81 259.88,66.45 260.26,66.45 260.26,65.81 261.15,65.81 261.15,66.45 261.41,66.45 261.41,65.81 267.12,65.81 268.92,64.02 268.92,58.72 267.5,57.31 267.5,52.22 267.13,51.84 261.91,51.84 261.15,52.61 261.15,58.07 255.97,63.24 265.3,63.24 265.3,63.19 265.31,63.14 265.32,63.09 265.34,63.04 265.37,62.99 265.41,62.96 265.45,62.92 265.5,62.9 265.55,62.88 265.6,62.86 265.65,62.86 265.71,62.86 265.76,62.88 265.81,62.9 265.85,62.92 265.9,62.96 265.93,62.99 265.96,63.04 265.99,63.09 266,63.14 266.01,63.19 266.01,63.24 266,63.3 265.99,63.35 265.96,63.4 265.93,63.44 265.9,63.48 265.85,63.51 265.81,63.54 265.76,63.56 265.71,63.57 265.65,63.57 265.6,63.57 265.55,63.56 265.5,63.54 265.45,63.51 265.41,63.48 265.37,63.44 265.34,63.4 265.32,63.35 265.31,63.3 265.3,63.24 255.97,63.24 255.04,64.18 253.61,64.18 253.28,64.52 253.28,65.56 253.53,65.81 254.55,65.81 254.55,66.45 254.8,66.45
+1.35VS_VGAP_B+ on TOP (solid shape): 256.58,60.31 256.58,57.94 256.96,57.56 257.47,57.56 257.53,57.5 257.53,56.48 257.47,56.42 253.53,56.42 252.58,57.37 252.26,57.37 251.31,56.42 247.18,56.42 246.8,56.04 246.8,54.51 246.52,54.23 244.65,54.23 243.88,55.01 243.88,57.05 243.37,57.56 243,57.56 242.89,57.67 242.89,58.83 250.61,58.83 250.61,57.81 250.86,57.56 252.13,57.56 252.26,57.69 252.26,58.96 252.13,59.08 250.86,59.08 250.61,58.83 242.89,58.83 242.89,59.49 243.08,59.68 246,59.68 247.16,60.84 256.05,60.84
+1V8_AON on TOP (solid shape): 202.69,64.92 203.31,64.92 203.55,64.69 203.55,64.13 203.54,64.08 203.55,64.02 203.55,62.41 203.46,62.32 202.09,62.32 201.59,61.81 201.3,61.81 201.16,61.95 201.16,62.79 202.02,63.66 202.72,63.66 202.81,63.75 202.81,63.86 202.91,64.16 202.73,64.42 202.72,64.43 202.65,64.5 202.24,64.5 202.21,64.54 202.17,64.59 202.17,64.81 202.36,65 202.62,65
+1V8_AON on TOP (solid shape): 208.01,88.42 208.01,87.53 207.82,87.34 207.82,87.31 207.82,86.89 207.69,86.77 207.69,85.56 207.95,85.31 208.29,85.31 208.45,85.15 208.45,84.74 207.93,84.22 206.96,84.22 206.45,84.73 204.77,84.73 204.64,84.61 203.95,84.61 203.88,84.67 203.88,85.18 203.94,85.23 204.03,85.24 204.52,85.24 204.61,85.33 204.76,85.33 204.8,85.37 204.88,85.43 204.93,85.5 205.17,85.74 207.14,85.74 207.17,85.78 207.18,85.78 207.18,85.79 207.25,85.85 207.25,87.47 207.2,87.52 207.17,87.6 207.23,87.68 207.34,88.2 206.82,88.09 206.8,88.07 206.77,88.05 206.71,87.98 206.09,87.98 206.09,87.98 205.92,87.98 205.61,88.29 205.61,88.37 205.94,88.7 207.73,88.7
+1V8_AON on TOP (solid shape): outline of 1595 points within 191.43,60 221.29,80.67
+1V8_AON on BOTTOM (solid shape): 215.64,71.27 215.64,69.84 215.54,69.75 213.42,69.75 213.37,69.79 213.37,71.03 213.41,71.07 214.73,71.07 215,71.33 215.57,71.33
+1V8_AON on BOTTOM (solid shape): 206.73,76.23 206.73,75.28 206.22,75.28 206.03,75.47 205.78,75.47 205.65,75.59 205.65,75.85 205.78,75.97 205.97,75.97 206.29,76.29 206.67,76.29
+1V8_AON on BOTTOM (solid shape): 218.46,75.29 218.46,73.45 217.59,72.58 217.12,72.58 217.02,72.67 217.02,73.59 217.27,73.84 217.27,75.21 217.4,75.34 218.42,75.34
+1V8_AON on BOTTOM (solid shape): 190.92,79.36 192.45,79.36 192.59,79.22 192.59,78.69 192.76,78.52 193.89,78.52 193.91,78.5 193.91,76.89 193.9,76.88 192.74,76.88 192.74,76.93 192.38,77.28 192.02,76.93 192.02,76.88 191.53,76.88 190.35,78.06 189.63,78.06 189.55,78.13 189.55,79.46 189.63,79.54 190.74,79.54
+1V8_AON on BOTTOM (solid shape): 189.61,83.21 189.61,81.39 188.14,79.92 183.78,79.92 183.77,79.95 183.73,79.99 183.68,80.02 183.63,80.05 183.63,80.55 183.77,80.69 185.96,80.69 186.48,81.21 187.64,81.21 187.64,81.15 187.65,81.1 187.67,81.05 187.69,81 187.72,80.96 187.76,80.92 187.8,80.89 187.84,80.86 187.89,80.84 187.95,80.83 188,80.82 188.05,80.83 188.1,80.84 188.15,80.86 188.2,80.89 188.24,80.92 188.28,80.96 188.31,81 188.33,81.05 188.35,81.1 188.35,81.15 188.35,81.21 188.35,81.26 188.33,81.31 188.31,81.36 188.28,81.4 188.24,81.44 188.2,81.48 188.15,81.5 188.1,81.52 188.05,81.53 188,81.54 187.95,81.53 187.89,81.52 187.84,81.5 187.8,81.48 187.76,81.44 187.72,81.4 187.69,81.36 187.67,81.31 187.65,81.26 187.64,81.21 186.48,81.21 186.92,81.65 186.92,83.17 186.99,83.25 189.57,83.25
+1V8_AON on IN2 (solid shape): outline of 446 points within 193.08,69.75 205.59,73.37
+1V8_AON on IN2 (solid shape): outline of 2074 points within 187.43,75.59 208.95,87.02
+1V8_AON on IN3 (solid shape): outline of 363 points within 206.3,80.21 209.85,88.73
+1V8_AON on IN4 (solid shape): outline of 141 points within 213.21,69.56 218.48,75.5
+1V8_MAIN on TOP (solid shape): 200.47,92.27 200.47,90.63 200.36,90.53 199.09,90.53 199.04,90.58 199.04,91.4 199.09,91.45 199.55,91.45 199.73,91.63 199.73,92.03 199.58,92.18 199.42,92.18 199.29,92.32 199.29,92.51 199.45,92.67 200.06,92.67
+1V8_MAIN on TOP (solid shape): outline of 188 points within 205.7,96.11 209.06,101.93
+1V8_MAIN on TOP (solid shape): outline of 438 points within 208.6,80.73 215.43,88.7
+1V8_MAIN on BOTTOM (solid shape): 213.87,74.85 214.83,74.85 215.08,74.59 215.08,74.03 215.64,73.47 215.64,72.65 215.58,72.6 213.24,72.6 213.11,72.46 213.11,71.82 213.06,71.76 210.91,71.76 210.85,71.82 210.85,72.45 210.97,72.57 211.83,72.57 212.05,72.79 212.05,74.33 211.73,74.65 210.72,74.65 210.66,74.71 210.66,75.35 210.71,75.4 213.32,75.4
+1V8_MAIN on BOTTOM (solid shape): 207.64,101.36 207.64,100.95 207.54,100.85 207.37,100.85 207.12,101.03 206.82,100.96 206.7,100.88 206.55,100.88 206.49,100.92 206.41,100.95 206.36,100.98 206.33,101.05 206.29,101.23 206.16,101.37 206.16,101.61 206.22,101.67 207.33,101.67
+1V8_MAIN on BOTTOM (solid shape): 214.55,87.08 214.55,86.98 214.37,86.71 214.46,86.4 214.46,86.4 214.46,86.06 214.38,85.98 214.37,85.98 214.19,85.92 214.07,85.78 214.06,85.75 213.38,85.75 213.26,85.87 213.11,85.93 213.09,85.93 212.9,86.13 212.88,86.15 212.88,86.3 212.96,86.42 212.65,87.03 212.35,86.42 212.42,86.3 212.42,86.15 212.4,86.12 212.37,86.07 212.27,85.97 212.26,85.97 212.12,85.89 212.03,85.78 211.9,85.78 211.78,85.9 211.5,85.9 211.37,85.78 211.15,85.78 210.8,86.13 210.78,86.15 210.78,86.3 210.86,86.42 210.55,87.03 210.25,86.42 210.32,86.3 210.32,86.15 210.3,86.12 210.27,86.07 210.13,85.93 210.12,85.93 209.99,85.9 209.88,85.83 209.12,85.83 209.05,85.88 208.96,85.92 208.6,86.28 208.6,87.05 208.78,87.23 214.4,87.23
+1V8_MAIN on BOTTOM (solid shape): 206.12,100.51 206.33,100.38 206.56,100.48 206.78,100.48 206.84,100.41 206.92,100.36 206.92,100.19 206.85,100.12 206.8,100.04 206.79,100.03 206.77,100 206.77,99.85 206.92,99.7 207.05,99.68 207.14,99.7 207.48,99.7 207.69,99.49 207.69,96.81 207.48,96.6 207.33,96.6 207.28,96.67 207.2,96.73 207.18,96.75 207.14,96.75 207.05,96.77 206.96,96.75 206.95,96.75 206.9,96.75 206.77,96.62 206.55,96.62 206.52,96.65 206.48,96.68 206.26,96.9 206.26,96.92 206.17,97.08 206.02,97.16 206,97.16 205.88,97.28 205.84,97.34 205.78,97.38 205.45,97.72 205.45,97.9 205.52,97.99 205.56,98.1 205.57,98.11 205.86,98.4 206.11,98.4 206.16,98.35 206.17,98.35 206.18,98.34 206.38,98.28 206.56,98.38 206.78,98.38 207.37,98.55 206.78,98.72 206.56,98.72 206.5,98.77 206.43,98.81 206.41,98.81 206.27,98.95 206.27,99.07 206.19,99.16 206.19,99.19 205.93,99.45 205.91,99.47 205.8,99.47 205.79,99.48 205.73,99.5 205.67,99.52 205.65,99.52 205.42,99.75 205.42,99.98 205.53,100.11 205.57,100.27 205.57,100.3 205.78,100.51
+1V8_MAIN on IN1 (solid shape): outline of 3097 points within 201.91,72.8 215.43,101.5
+1V8_MAIN on IN4 (solid shape): outline of 4451 points within 198.79,82.26 215.69,101.56
+1V_B+ on TOP (solid shape): 253.47,49.37 253.47,49.05 252.96,49.05 252.96,48.48 253.47,48.48 253.47,48.22 252.96,48.22 252.96,47.65 253.47,47.65 253.47,47.08 252.58,46.19 251.75,46.19 251.5,45.94 251.5,41.62 251.42,41.54 249.99,41.54 249.66,41.87 249.66,42.54 248.9,43.29 248.9,43.71 247.84,44.78 247.84,47.43 248.06,47.65 251.82,47.65 252.01,47.84 252.01,49.3 252.13,49.43 253.4,49.43
+1V_MPHY on TOP (solid shape): 284.73,45.25 286.48,45.25 286.68,45.06 286.68,43.56 286.63,43.47 286.53,43.47 286.14,43.42 286.07,43.04 286.06,42.94 285.98,42.89 285.91,42.89 285.86,42.92 285.87,42.97 285.64,43.5 285.3,43.03 285.29,42.94 285.21,42.89 284.69,42.89 284.5,43.07 283.7,43.07 283.63,43.14 283.44,43.48 283.05,43.44 282.96,43.44 282.89,43.5 282.89,44.68 282.8,44.77 282.8,45.43 282.93,45.56 284.42,45.56
+1V_MPHY on BOTTOM (solid shape): 286.93,44.41 286.93,44.22 286.68,43.97 286.68,43.86 286.47,43.65 286.21,43.65 286.19,43.68 286.01,43.79 285.81,43.72 285.39,43.72 285.01,43.69 285.12,43.33 285.15,43.31 285.15,43.08 284.96,42.89 284.71,42.89 284.14,43.46 284.14,44.41 284.27,44.54 286.81,44.54
+1V_MPHY_MPHYPLL on TOP (solid shape): 277.15,54.1 277.15,51.36 276.93,51.14 276.93,50.77 276.79,50.63 273.39,50.63 273.22,50.8 273.22,51.35 274.23,52.36 274.33,52.36 274.47,52.22 274.51,52.15 274.48,52.08 274.72,51.52 274.95,52.08 274.93,52.15 275.07,52.48 274.97,52.74 274.85,52.85 274.85,52.99 275.13,53.27 275.13,54.07 275.29,54.22 277.02,54.22
+1V_PCH on TOP (solid shape): outline of 243 points within 286.87,40.6 291.43,46.82
+1V_PCH_CLK5 on BOTTOM (solid shape): 296.59,47.67 296.9,47.67 297.14,47.42 297.83,47.42 297.95,47.38 298.08,47.38 298.11,47.39 298.29,47.21 298.72,47.21 298.93,47.42 302.97,47.42 303.06,47.34 303.06,46.29 302.97,46.21 298.67,46.21 298.2,46.67 297.47,46.67 297.47,46.68 297.36,46.68 297.09,46.95 297.05,46.98 297.03,47.03 296.96,47.15 296.83,47.2 296.72,47.2 296.37,47.2 296.32,47.2 296.22,47.2 296.13,47.29 295.89,47.29 295.8,47.39 295.8,47.71 295.85,47.77 296.26,47.77 296.26,47.77 296.49,47.77
+1V_PCH_PRIM on TOP (solid shape): outline of 1234 points within 283.5,36.92 297.03,46
