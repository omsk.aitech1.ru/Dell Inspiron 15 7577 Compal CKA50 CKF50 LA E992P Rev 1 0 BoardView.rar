# Allegro board Dell_Inspiron_15_7577_Compal_CKA50_CKF50_LA_E992P_Rev_1_0_BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
ISEN1_VCORE: length 33.4
  TOP w0.14: v1(147,117.94) 147.09,118.02 PR5112.2
  TOP w0.203: PU5000.21 138.87,134.81 v2(138.95,134.74) 138.95,134.32 139.14,134.13 140.29,134.13 140.83,133.6 140.85,133.6 PC5028.1
  TOP w0.254: 149.31,117.66 PR5108.2 ; 149.31,117.66 PR5111.2 ; 149.31,117.66 148.81,117.66 PR5112.2 v2(148.44,118.71)
  IN1 w0.254: v2(148.44,118.71) 146.47,118.71 145.84,119.34 145.84,124.36 146.72,125.25 146.72,129.06 146.03,129.76 141.58,129.76 140.5,130.84 140.5,134.52 139.84,135.18 139.24,135.18 138.95,134.89 v2(138.95,134.74)
ISEN2: length 5.2
  TOP w0.14: v1(159.06,144.95) 159.06,143.21 158.67,142.83 PR6028.2
  TOP w0.203: PU6000.19 156.94,141.21 PR6028.2
ISEN2_GT: length 13.4
  TOP w0.14: PR5220.2 v1(124.23,135.61)
  TOP w0.203: PC5026.2 133.29,136.8 v2(133.54,136.8) 133.76,136.8 134.3,137.33 PU5000.10
  TOP w0.254: v2(127.93,136.24) PR5222.2 PR5220.2
  IN4 w0.254: v2(133.54,136.8) 132.03,135.28 128.88,135.28 v2(127.93,136.24)
ISEN2_VCORE: length 21.5
  TOP w0.203: PU5000.22 139.27,135.18 139.55,134.9 v2(139.55,134.65)
  TOP w0.254: PR5123.2 141.26,119.27 PR5120.2 140.39,119.28 PR5124.2 v2(139.74,119.29)
  IN1 w0.254: v2(139.74,119.29) 139.74,122.65 140.5,123.41 140.5,129.63 140.07,130.06 140.07,134.13 v2(139.55,134.65)
  BOTTOM w0.254: v2(139.55,134.65) v1(140.06,134.13) 140.63,133.57 PC5027.1
ISEN3: length 3.4
  TOP w0.203: PR6029.2 158.55,141.82 v1(158.36,141.82) 158.01,141.82 157.34,141.15 PU6000.18
ISEN3_VCORE: length 34
  TOP w0.14: v2(142.42,133.63) 143.13,133.63 v1(143.5,133.26)
  TOP w0.203: PC5025.1 140.64,134.71 140.24,134.71 139.67,135.27 PU5000.23
  TOP w0.254: v2(142.42,133.63) 142.36,133.57 141.78,133.57 PC5025.1 ; v2(156.69,118.27) PR5136.2 PR5135.2 157.57,117.66 PR5133.2
  IN1 w0.254: v2(142.42,133.63) 145.07,133.63 147.23,131.47 147.23,129.7 148.63,128.3 153.07,128.3 153.65,127.73 154.15,127.73 157.52,124.36 157.52,119.09 v2(156.69,118.27)
ISEN4: length 4
  TOP w0.203: PR6033.2 160.44,142.61 v1(159.67,141.84) 159.21,141.38 158.01,141.38 157.74,141.11 PU6000.17
ISOLATEB: length 5.5
  BOTTOM w0.14: UL1.20 26.53,42.86 26.43,42.76 26.43,42.2 RL30.1 27.57,41.06 27.57,40.8 v1(28.04,40.33) 28.04,39.54 RL1.2 RL33.2
ISUMN_GT: length 23.6
  TOP w0.14: v2(128.25,126.19) v1(127.26,126.19)
  TOP w0.254: v2(128.25,126.19) PR5209.1 129.4,126.72 129.4,133.53 129.21,133.72 129.21,135.07 PR5221.1 130.37,135.6 131.31,136.54 v2(131.31,137.25) PC5026.1 PR5040.1 131.91,138.2 PR5038.1
  BOTTOM w0.254: v2(131.31,137.25) PC5029.1 131.88,137.3 PC5017.2 ; PC5024.1 131.85,138.2 PC5017.2 ; PC5017.2 131.93,138.22 PC5018.2 131.88,139.12 PR5035.2 ; v2(128.25,126.19) 127.18,126.19 126.65,126.72 PH5002.2
ISUMN_SA: length 52.5
  TOP w0.254: PC5012.1 PC5011.1 PR5024.2 144.63,140.81 v2(144.87,140.57) 144.86,140.56 PC5013.1 ; v2(165.53,117.26) 167.04,117.26 PR5228.1
  IN1 w0.254: v2(165.53,117.26) 165.67,117.26 166.21,117.8 166.21,123.43 165.48,124.16 165.48,127.83 166.68,129.02 166.68,131.54 162.09,136.12 154.11,136.12 151.94,138.29 147.08,138.29 145.55,139.83 143.87,139.83 143.64,140.06 143.64,140.33 144.01,140.69 144.66,140.69 144.79,140.57 v2(144.87,140.57)
  BOTTOM w0.254: PR5029.1 143.85,140.48 PR5027.1 144.43,140.45 144.53,140.55 144.86,140.55 v2(144.87,140.57) ; v2(165.53,117.26) 165.43,117.36 165.01,117.36 PH5001.1
ISUMN_VCORE: length 49.1
  TOP w0.14: v1(143.56,117.88) 142.99,118.46 v2(142.79,118.46)
  TOP w0.254: v2(142.79,118.46) 142.74,118.4 PR5122.1 ; v2(151.11,117.76) 150.99,117.64 PR5109.1 ; PR5042.1 136.54,132.73 PC5031.1 137.83,132.29 v2(137.83,131.98) 137.83,131.71 138.09,131.46 138.75,131.46 PC5030.1 139.96,132.67 PR5041.2 PC5028.2 PC5025.2 ; PR5134.1 v2(159.25,117.64)
  IN1 w0.254: v2(142.79,118.46) 140.69,118.46 140.59,118.35 139.31,118.35 138.61,119.05 138.61,131.1 137.83,131.88 v2(137.83,131.98)
  BOTTOM w0.254: v2(142.79,118.46) 143.17,118.07 150.79,118.07 v2(151.11,117.76) 153.96,117.76 154.46,118.25 PH5003.1 155.94,118.25 156.55,117.64 v2(159.25,117.64) ; v2(137.83,131.98) 137.83,132.24 PC5032.1 138.86,133.26 139.55,133.26 140.11,132.71 PR5043.2 140.13,132.65 PC5027.2
ISUMP_GT: length 37.8
  TOP w0.203: v2(133.52,138.33) 133.77,138.33 133.97,138.53 PU5000.7
  TOP w0.254: PR5219.1 125.83,136.27 v2(127.26,137.69) ; PR5034.1 124.75,126.15 v1(124.75,125.49) PR5207.1 v2(124.11,122.33)
  IN4 w0.254: v2(133.52,138.33) 133.2,138.01 130.03,138.01 129.59,137.57 127.38,137.57 v2(127.26,137.69) 124.12,134.55 124.12,122.34 v2(124.11,122.33)
  BOTTOM w0.254: PR5210.2 133.58,138.27 v2(133.52,138.33) 133.35,138.17 PC5017.1 132.79,139.02 PC5018.1 132.84,139.91 PR5035.1
ISUMP_SA: length 49
  TOP w0.203: v2(142.13,139.5) 141.78,139.5 141.62,139.33 PU5000.32
  TOP w0.254: v2(142.13,139.5) 142.48,139.86 PC5011.2 PC5012.2 ; PR5227.2 166.93,117.87 PR5231.2 165.56,117.87 v2(165.53,117.85)
  IN1 w0.254: v2(165.53,117.85) 165.83,118.14 165.83,123.27 165.1,124 165.1,127.98 166.29,129.18 166.29,131.38 161.94,135.74 153.95,135.74 151.78,137.91 146.93,137.91 145.39,139.45 143.71,139.45 143.43,139.73 142.25,139.73 142.13,139.6 v2(142.13,139.5)
  BOTTOM w0.254: v2(142.13,139.5) 142.13,139.68 142.09,139.72 PR5029.2 ; v2(165.53,117.85) 165.43,117.74 165.04,117.74 PR5030.2
ISUMP_VCORE: length 47.8
  TOP w0.203: PU5000.19 138.07,134.33 v2(138.03,134.29)
  TOP w0.254: PR5119.1 144.58,119.4 v2(145.25,119.4) v1(146.24,119.4) PR5110.2 149.19,119.4 PR5107.1 ; PR5132.1 v2(156.82,119.6) 156.82,119.21 155.86,118.25 PR5044.2 ; PR5042.2 137.33,133.58 PC5031.2 v2(138.03,134.29)
  IN1 w0.254: v2(138.03,134.29) 138.03,134.22 139.6,132.65 139.6,130.03 140.15,129.48 140.15,123.56 139.17,122.58 139.17,119 139.45,118.71 140.31,118.71 141,119.4 v2(145.25,119.4)
  IN2 w0.254: v2(156.82,119.6) 145.45,119.6 v2(145.25,119.4)
  BOTTOM w0.254: v2(138.03,134.29) 138.28,134.04 138.28,133.64 PC5032.2
JACK_PLUG: length 37
  TOP w0.305: v2(352.22,7.17) 353.53,7.17 DA5.3 353.49,7.84 v2(352.22,7.84)
  IN1 w0.254: 367.5,4.5 371.62,4.5 372.57,5.45 JHP1.6
  IN1 w0.305: 367.5,4.5 366.54,5.46 366.54,9.32 363.77,12.09 357.44,12.09 353.19,7.84 v2(352.22,7.84)
  BOTTOM w0.254: RA56.1 351.99,7.39 v2(352.22,7.17)
JTAG_CLK: length 4.7
  BOTTOM w0.14: RE111.2 324.09,11.24 324.09,8.61 v1(324.07,8.59) 323.75,8.27 JDEG1.4
JTAG_TDI: length 5
  BOTTOM w0.14: JDEG1.2 324.75,7.57 v1(325.87,8.69) 325.92,8.74 RE109.2
JTAG_TDO: length 4.7
  BOTTOM w0.14: JDEG1.5 323.25,9.1 322.94,9.41 v1(322.94,10.19) RE112.2
JTAG_TMS: length 4.8
  BOTTOM w0.14: JDEG1.3 324.25,7.64 324.91,8.3 v1(324.91,10.24) RE110.2
KB_BL_DET: length 104.4
  IN3 w0.254: v2(267.3,48.69) 266.1,47.5 266.1,37.18 259.82,30.89 259.82,30.38 259.63,30.19 254.92,30.19 253.16,31.96 224.04,31.96 221.52,29.44 216.04,29.44 215.29,30.19 196.51,30.19 v2(193.4,33.3)
  BOTTOM w0.203: v2(267.3,48.69) v1(267.81,48.18) 268.34,47.65 270.47,47.65 271.6,46.52 273.41,46.52 275.17,44.76 UH2.T45
  BOTTOM w0.254: v2(193.4,33.3) 193.18,33.09 RE3.1 192.85,31.35 192.44,31.35 RE4.2
KB_DET#: length 216.9
  TOP w0.14: v4(287.36,24.89) 287.19,24.72 v2(287.19,24.29)
  IN3 w0.124: v2(86.08,29.96) 86.15,30.03 88.23,30.03 89.13,29.12 101.78,29.12 102.46,29.81 108.32,29.81 109.01,29.12 113.59,29.12 114.75,30.28 136.23,30.28 137.33,29.17 155.6,29.17 156.05,29.62 190.66,29.62 191.31,28.97 209.92,28.97 210.35,28.54 221.99,28.54 223.22,29.77 244.98,29.77 245.55,30.34 253.5,30.34 254.55,29.29 256.41,29.29 260.26,25.44 264.62,25.44 265.65,24.41 283.46,24.41 283.78,24.73 286.74,24.73 v2(287.19,24.29)
  BOTTOM w0.076: UH2.BD22 286.6,30.41 286.84,30.17 286.84,28.84 286.55,28.55 286.55,28.48
  BOTTOM w0.14: JKB1.30 85.38,31.01 86.08,30.31 v2(86.08,29.96) ; v2(287.19,24.29) 287.19,25.14 287.52,25.47 287.52,26.74 RH128.1 286.55,27.7 286.55,28.48
KB_LED_PWM: length 146.3
  TOP w0.254: v2(309.28,17.94) 309.28,17.09 303.89,11.7 303.89,10.75 305.2,9.43 UE1.44
  IN4 w0.254: v2(190.38,33.4) 191.02,32.76 210.85,32.76 212.31,34.22 241.14,34.22 241.75,34.83 248.39,34.83 249.94,33.28 259.14,33.28 259.82,32.6 259.82,28.89 262.48,26.23 264.87,26.23 265.27,25.84 269.62,25.84 271.04,24.41 271.04,23.82 271.61,23.26 273.32,23.26 273.65,23.59 279.83,23.59 280.01,23.78 281.28,23.78 282.55,22.51 285.34,22.51 285.9,21.96 292.84,21.96 293.03,22.15 298.7,22.15 298.97,21.88 298.98,21.88 300.38,20.48 305.06,20.48 306.4,19.14 306.4,17.92 306.96,17.35 309.03,17.35 309.28,17.61 v2(309.28,17.94)
  BOTTOM w0.254: v2(190.38,33.4) 190.66,33.11 QE5.2
KB_LED_PWM#: length 5
  BOTTOM w0.127: v1(187.53,31.46) QE5.1
  BOTTOM w0.254: QE5.1 188.76,30.86 189.82,29.81 190.49,29.81 190.75,29.55 JBL1.4
KSI0: length 261.2
  TOP w0.14: v4(92.08,30.89) 91.78,31.19 v2(91.78,32.34) ; v2(312.37,21.15) 312.8,21.57 UE1.98
  IN4 w0.137: v2(312.37,21.15) 312.37,22.05 311.94,22.48 310.3,22.48 309.68,21.85 309.68,18.7 310.97,17.4 313.4,17.4 314.42,16.37 314.42,10.5 312.41,8.49 303.46,8.49 303.1,8.13 301.95,8.13 301.1,7.28 294.64,7.28 293.29,8.63 292.65,8.63 291.79,9.48 290.09,9.48 289.92,9.31 282.46,9.31 280.47,11.3 275.14,11.3 273.75,12.69 272.03,12.69 268.96,15.75 263.38,15.75 255.01,24.12 253.23,24.12 252.83,24.52 245.1,24.52 244.17,25.45 238.82,25.45 237.93,26.35 225.2,26.35 223.89,25.04 189.5,25.04 188.86,25.68 179.55,25.68 178.22,24.35 163.56,24.35 162.83,25.08 130.24,25.08 128.88,26.44 120.37,26.44 120.05,26.13 108.24,26.13 108.12,26.25 97.87,26.25 v2(91.78,32.34)
  BOTTOM w0.14: JKB1.22 v2(91.78,32.34) ; RPE2.4 312.57,20.95 v2(312.37,21.15)
KSI1: length 263.6
  TOP w0.14: v2(311.77,21.15) 312.4,21.78 UE1.99 ; v4(90.31,31.12) 90.18,31.25 v2(90.18,32.34)
  IN4 w0.137: v2(311.77,21.15) 312.09,21.46 312.09,21.94 311.81,22.22 310.41,22.22 309.97,21.77 309.97,19.9 310.41,19.46 313.03,19.46 314.95,17.54 314.95,10.28 312.63,7.97 303.68,7.97 303.32,7.6 302.17,7.6 301.31,6.75 294.42,6.75 293.07,8.1 286.87,8.1 286.18,8.78 282.24,8.78 280.25,10.77 272.97,10.77 269.19,14.55 263.83,14.55 254.79,23.59 253.01,23.59 252.61,23.99 244.88,23.99 243.95,24.93 238.6,24.93 237.71,25.82 225.42,25.82 224.11,24.51 189.28,24.51 188.73,25.07 181.49,25.07 179.36,22.94 163.81,22.94 162.24,24.5 130.08,24.5 128.66,25.92 120.59,25.92 120.27,25.6 108.02,25.6 107.97,25.66 96.86,25.66 v2(90.18,32.34)
  BOTTOM w0.14: v2(311.77,21.15) 312.07,20.85 RPE2.3 ; JKB1.24 v2(90.18,32.34)
KSI2: length 274
  TOP w0.14: UE1.6 299.18,19.38 301.8,19.38 302.64,18.54 306.8,18.54 307.85,19.59 309.37,19.59 v2(310.43,20.64) ; v4(88.41,31.22) 88.58,31.39 v2(88.58,32.34)
  IN4 w0.137: v2(310.43,20.64) 310.57,20.5 313.26,20.5 315.48,18.28 315.48,10.06 312.85,7.44 303.9,7.44 303.53,7.07 302.38,7.07 301.53,6.22 294.2,6.22 292.85,7.57 286.65,7.57 285.96,8.26 282.02,8.26 280.03,10.24 272.72,10.24 268.93,14.02 263.61,14.02 256.76,20.87 253.22,20.87 251.95,22.15 240.58,22.15 237.44,25.29 227.23,25.29 224.97,23.03 190.02,23.03 188.63,24.41 185.89,24.41 183.89,22.41 163.39,22.41 162.79,23.02 154.98,23.02 154.73,23.27 141.33,23.27 140.69,23.9 129.36,23.9 127.88,25.39 120.81,25.39 120.49,25.07 107.81,25.07 107.75,25.13 95.48,25.13 95.19,25.41 94.92,25.41 88.58,31.75 v2(88.58,32.34)
  BOTTOM w0.14: JKB1.26 v2(88.58,32.34) ; RPE2.2 311.57,20.69 311.38,20.88 310.67,20.88 v2(310.43,20.64)
KSI3: length 266.4
  TOP w0.14: v2(310.69,18.33) 310.62,18.41 307.87,18.41 307,17.53 303.26,17.53 301.81,18.99 UE1.7 ; v4(91.36,33.06) 90.98,32.68 v2(90.98,32.34)
  IN4 w0.137: v2(310.69,18.33) 312.84,18.33 314.69,16.48 314.69,10.39 312.52,8.23 303.57,8.23 303.21,7.86 302.06,7.86 301.2,7.01 294.53,7.01 293.18,8.36 291.11,8.36 290.93,8.54 290.93,8.86 290.57,9.22 290.2,9.22 290.03,9.05 282.35,9.05 280.36,11.03 275.03,11.03 273.65,12.41 271.93,12.41 268.85,15.49 263.27,15.49 254.9,23.85 253.12,23.85 252.72,24.26 244.99,24.26 244.06,25.19 238.71,25.19 237.82,26.08 225.31,26.08 224,24.77 189.39,24.77 188.84,25.33 181.38,25.33 179.25,23.2 163.99,23.2 162.37,24.82 130.13,24.82 128.77,26.18 120.48,26.18 120.16,25.86 108.13,25.86 108.01,25.99 97.33,25.99 v2(90.98,32.34)
  BOTTOM w0.14: JKB1.23 v2(90.98,32.34) ; v2(310.69,18.33) 310.69,19.59 311.07,19.97 RPE2.1
KSI4: length 268
  TOP w0.14: v4(311.43,25.48) v2(311.43,24.86) 310.4,23.83 UE1.104
  IN4 w0.137: v2(311.43,24.86) 311.43,24.47 317.51,18.39 317.51,11.57 316.65,10.72 316.65,10.1 316.14,9.59 315.38,9.59 312.96,7.17 304.01,7.17 303.64,6.81 302.49,6.81 301.64,5.96 294.09,5.96 292.74,7.31 286.54,7.31 285.85,7.99 281.91,7.99 279.93,9.98 272.61,9.98 268.82,13.76 263.5,13.76 256.65,20.61 253.12,20.61 251.84,21.88 240.46,21.88 237.32,25.02 227.34,25.02 225.08,22.77 188.58,22.77 187.31,24.03 185.97,24.03 184.06,22.13 163.23,22.13 162.66,22.7 154.85,22.7 154.6,22.95 141.2,22.95 140.56,23.59 129.31,23.59 127.77,25.12 120.92,25.12 120.6,24.81 107.7,24.81 107.64,24.86 95.37,24.86 95.08,25.15 93.79,25.15 89.87,29.07 v2(89.87,29.7)
  BOTTOM w0.14: JKB1.27 87.78,30.5 87.96,30.32 89.24,30.32 v2(89.87,29.7) ; v2(311.43,24.86) 311.15,24.86 310.29,23.99 RPE3.4
KSI5: length 263.7
  TOP w0.14: v2(310.56,24.87) 310.56,24.57 310,24.01 UE1.105 310,21.86 310.9,20.96 310.9,20.5 v2(310.44,20.04) ; v2(89.38,32.34) v4(89.38,33.12)
  IN4 w0.137: v2(89.38,32.34) 96.33,25.39 107.86,25.39 107.91,25.33 120.38,25.33 120.7,25.65 128,25.65 129.44,24.21 156.89,24.21 157.83,23.28 162.97,23.28 163.57,22.67 179.47,22.67 181.6,24.8 188.62,24.8 189.18,24.24 224.22,24.24 225.53,25.55 237.58,25.55 238.47,24.66 243.84,24.66 244.67,23.83 244.67,23.21 244.83,23.05 253.24,23.05 253.24,23.05 254.96,23.05 263.72,14.29 269.08,14.29 272.86,10.51 280.14,10.51 282.13,8.52 286.07,8.52 286.76,7.83 292.96,7.83 294.31,6.48 301.42,6.48 302.27,7.34 303.43,7.34 303.79,7.7 312.74,7.7 315.21,10.17 315.21,17.86 313.03,20.04 v2(310.44,20.04)
  BOTTOM w0.14: RPE3.3 309.79,24.1 v2(310.56,24.87) ; JKB1.25 v2(89.38,32.34)
KSI6: length 275.5
  TOP w0.14: v4(92.99,29.35) 92.15,30.19 89.73,30.19 v2(89.22,29.68) ; UE1.107 309.2,24.28 v2(309.54,24.62)
  IN4 w0.137: v2(309.54,24.62) 310.41,25.49 312.17,25.49 313.49,24.17 313.49,23.01 317.77,18.73 317.77,10.1 317.21,9.54 317.21,7.33 316.79,6.91 304.12,6.91 303.75,6.54 302.6,6.54 301.75,5.69 293.98,5.69 292.63,7.04 286.43,7.04 285.74,7.73 281.8,7.73 279.82,9.71 272.5,9.71 268.72,13.5 263.39,13.5 256.54,20.35 253.01,20.35 251.73,21.62 240.05,21.62 236.91,24.76 231.08,24.76 228.82,22.5 185.45,22.5 184.76,21.81 163.11,21.81 162.54,22.38 154.73,22.38 154.47,22.63 141.07,22.63 140.44,23.27 129.25,23.27 127.74,24.78 120.95,24.78 120.71,24.54 107.59,24.54 107.53,24.6 95.26,24.6 94.99,24.87 93.61,24.87 89.22,29.27 v2(89.22,29.68)
  BOTTOM w0.14: v2(309.54,24.62) 309.29,24.37 RPE3.2 ; v2(89.22,29.68) 88.89,30.01 87.85,30.01 86.98,30.88 JKB1.28
KSI7: length 279.3
  TOP w0.14: v4(86.73,30.61) 87.07,30.27 87.39,30.27 v2(88.1,29.56) ; UE1.108 308.8,24.36 309.12,24.68 309.12,24.82 v2(309.52,25.23)
  IN4 w0.137: v2(309.52,25.23) 310.05,25.76 312.28,25.76 312.43,25.6 312.43,25.6 313.75,24.28 313.75,23.17 318.03,18.89 318.03,9.99 317.48,9.43 317.48,6.7 315.71,4.93 311.24,4.93 309.53,6.64 304.23,6.64 303.86,6.28 302.71,6.28 301.86,5.43 294.09,5.43 293.87,5.43 292.52,6.78 286.32,6.78 285.63,7.46 281.69,7.46 279.71,9.45 272.37,9.45 268.59,13.23 263.28,13.23 256.43,20.08 252.9,20.08 251.62,21.35 239.94,21.35 236.8,24.49 231.18,24.49 228.93,22.24 185.7,22.24 184.89,21.43 162.73,21.43 162.15,22 160.38,22 159.74,21.36 155.3,21.36 154.34,22.32 140.97,22.32 140.29,23.01 129.14,23.01 127.63,24.52 122.66,24.52 121.43,23.28 95.82,23.28 94.55,24.55 93.49,24.55 88.48,29.56 v2(88.1,29.56)
  BOTTOM w0.14: RPE3.1 308.79,24.49 v2(309.52,25.23) ; JKB1.29 86.18,30.73 87.35,29.56 v2(88.1,29.56)
KSO0: length 224.9
  TOP w0.14: v4(99.15,30.83) 99.15,32.17 v2(98.98,32.34) ; RPE4.8 296.55,18.3 296.8,18.56 v2(296.8,18.82) 296.8,19.5 296.36,19.94 296.36,20.64 296.7,20.99 UE1.2
  IN4 w0.137: v2(296.8,18.82) 296.83,18.79 297.17,18.79 298.24,17.73 298.24,16.03 297.55,15.34 295.61,15.34 294.55,16.4 288.28,16.4 288.03,16.15 283.63,16.15 281.31,18.47 275.58,18.47 273.86,20.19 270.92,20.19 270.56,20.54 269.01,20.54 267.75,21.8 262.56,21.8 256.54,27.82 254.76,27.82 253.36,29.22 250.25,29.22 248.94,30.52 224.14,30.52 222.36,28.74 191.04,28.74 189.85,29.92 174.7,29.92 173.28,28.5 168,28.5 166.58,29.92 158.34,29.92 158.1,29.68 156.25,29.68 155.63,30.31 153.19,30.31 152.76,29.88 136.83,29.88 135.44,31.27 119.29,31.27 118.28,30.25 111.93,30.25 110.97,31.21 110.97,32.67 109.77,33.87 106.29,33.87 105.27,32.86 99.5,32.86 v2(98.98,32.34)
  BOTTOM w0.14: JKB1.13 v2(98.98,32.34)
KSO1: length 219.9
  TOP w0.14: v2(97.5,32.32) 97.5,31.11 v4(97.4,31) ; UE1.14 297.75,16.19 v2(297.46,16.47) 297.46,17.11 296.77,17.8 RPE4.7
  IN4 w0.137: v2(297.46,16.47) 296.86,15.87 295.94,15.87 293.18,18.63 289.92,18.63 289.47,18.19 282.36,18.19 281.55,19 277.13,19 275.41,20.71 271.14,20.71 270.78,21.07 269.23,21.07 267.97,22.33 262.78,22.33 256.76,28.34 254.98,28.34 253.56,29.77 250.45,29.77 249.16,31.05 215.71,31.05 213.97,29.3 191.22,29.3 190.07,30.45 174.48,30.45 173.06,29.03 168.22,29.03 166.8,30.45 158.44,30.45 157.75,31.14 136.37,31.14 135.61,31.91 119.04,31.91 118.02,30.89 112.18,30.89 111.61,31.46 111.61,33.03 110.06,34.58 103.3,34.58 102.91,34.19 99.38,34.19 v2(97.5,32.32)
  BOTTOM w0.14: v2(97.5,32.32) 97.38,32.19 JKB1.15
KSO2: length 221
  TOP w0.14: RPE4.6 296.6,17.3 v2(297.02,16.88) 297.02,16.24 297.48,15.79 UE1.15 ; v4(98.18,33.04) v2(98.18,32.32)
  IN4 w0.137: v2(297.02,16.88) 297.13,17 297.68,17 297.97,16.7 297.97,16.18 297.39,15.61 295.72,15.61 294.66,16.67 288.17,16.67 287.92,16.42 283.74,16.42 281.42,18.73 275.69,18.73 273.97,20.45 271.03,20.45 270.67,20.81 269.12,20.81 267.86,22.06 262.67,22.06 256.65,28.08 254.87,28.08 253.45,29.5 250.34,29.5 249.05,30.79 224.03,30.79 222.28,29.04 191.11,29.04 189.96,30.19 174.59,30.19 173.17,28.77 168.11,28.77 166.69,30.19 158.24,30.19 158,29.95 156.36,29.95 155.73,30.57 153.08,30.57 152.65,30.15 136.94,30.15 135.5,31.59 119.17,31.59 118.15,30.57 112.05,30.57 111.29,31.33 111.29,32.98 109.95,34.32 103.8,34.32 103.23,33.75 99.61,33.75 v2(98.18,32.32)
  BOTTOM w0.14: JKB1.14 v2(98.18,32.32)
KSO3: length 218.2
  TOP w0.14: UE1.16 296.83,15.39 v4(296.71,15.51) 296.47,15.75 v2(296.47,16.32) 296.4,16.32 296.27,16.45 RPE4.5
  IN4 w0.137: v2(96.89,32.86) 97.64,32.86 99.35,34.57 102.78,34.57 103.16,34.95 110.21,34.95 111.93,33.24 111.93,31.59 112.31,31.21 117.9,31.21 118.91,32.22 135.74,32.22 136.5,31.46 157.84,31.46 158.58,30.72 166.91,30.72 168.33,29.29 172.95,29.29 174.37,30.72 190.18,30.72 191.3,29.59 213.88,29.59 215.61,31.31 249.27,31.31 250.56,30.03 253.67,30.03 255.09,28.61 256.87,28.61 262.89,22.59 269.63,22.59 271.25,20.98 275.58,20.98 276.47,20.09 285.6,20.09 286.79,18.9 293.29,18.9 295.87,16.31 296.46,16.31 v2(296.47,16.32)
  BOTTOM w0.14: v2(96.89,32.86) 96.58,32.55 JKB1.16
KSO4: length 233.2
  TOP w0.14: RPE5.8 297.61,6.61 298.72,5.5 299.58,5.5 299.99,5.91 301.85,5.91 302.4,6.45 UE1.37 302.4,8.21 302.26,8.35 302.26,8.73 302.69,9.16 v2(302.69,9.17) ; v2(93.38,32.33) 93.38,31.59 v4(93.82,31.16)
  IN4 w0.137: v2(93.38,32.33) 98.82,26.89 108.37,26.89 108.5,26.76 119.8,26.76 120.5,27.46 126.53,27.46 126.88,27.11 131.52,27.11 132.12,26.51 135.55,26.51 136.37,25.68 163.11,25.68 163.81,24.98 178.03,24.98 179.36,26.32 188.97,26.32 189.72,25.57 223.67,25.57 224.98,26.88 238.29,26.88 239.19,25.98 244.39,25.98 245.32,25.05 253.04,25.05 253.45,24.65 255.23,24.65 263.6,16.28 269.18,16.28 271.53,13.94 273.25,13.94 275.36,11.83 282.59,11.83 284.58,9.84 289.7,9.84 289.87,10.01 292.21,10.01 292.92,9.3 299.92,9.3 300.18,9.55 302.3,9.55 v2(302.69,9.17)
  BOTTOM w0.14: JKB1.20 v2(93.38,32.33)
KSO5: length 232.7
  TOP w0.14: RPE5.7 297.58,6.11 298.54,5.15 299.64,5.15 300,5.51 v4(300.8,5.51) 301.89,5.51 302.8,6.42 UE1.38 302.8,8.46 v2(302.7,8.56)
  IN4 w0.137: v2(302.7,8.56) 302.01,8.56 301.7,8.26 300.74,8.26 299.96,9.03 292.81,9.03 292.1,9.74 289.98,9.74 289.81,9.58 282.57,9.58 280.58,11.56 275.25,11.56 273.14,13.67 271.42,13.67 269.07,16.02 263.49,16.02 255.12,24.38 253.34,24.38 252.94,24.79 245.21,24.79 244.28,25.72 239.08,25.72 238.19,26.61 225.09,26.61 223.78,25.3 189.61,25.3 188.91,26 179.49,26 178.16,24.67 163.68,24.67 162.98,25.36 136.25,25.36 135.42,26.19 131.99,26.19 131.34,26.85 126.7,26.85 126.4,27.14 120.63,27.14 119.93,26.44 108.37,26.44 108.24,26.57 98.34,26.57 v2(92.58,32.33)
  BOTTOM w0.14: JKB1.21 v2(92.58,32.33)
KSO6: length 233.3
  TOP w0.14: v2(303.85,9.79) 303.2,9.15 UE1.39 303.2,6.4 302.71,5.9 302.71,5.37 v4(302.58,5.25) 302.44,5.11 299.98,5.11 299.75,4.88 298.34,4.88 297.61,5.61 RPE5.6
  IN4 w0.137: v2(303.85,9.79) 303.56,10.08 300.4,10.08 299.25,11.23 288.04,11.23 287.18,10.37 286.67,10.37 285.36,11.68 283.49,11.68 282.81,12.35 279.78,12.35 278.15,13.99 274.93,13.99 272.11,16.82 263.81,16.82 255.45,25.17 253.67,25.17 253.26,25.58 245.54,25.58 244.61,26.51 239.41,26.51 238.47,27.45 224.8,27.45 223.45,26.09 189.94,26.09 189.08,26.95 178.79,26.95 177.65,25.81 163.87,25.81 163.36,26.32 136.5,26.32 136.37,26.44 135.67,27.14 132.37,27.14 131.88,27.64 127.24,27.64 126.79,28.1 120.24,28.1 119.55,27.4 108.75,27.4 107.86,28.29 99.02,28.29 v2(94.98,32.33)
  BOTTOM w0.14: JKB1.18 v2(94.98,32.33)
KSO7: length 243.4
  TOP w0.102: UE1.50 307.6,7.33
  TOP w0.14: UE1.50 307.6,9.52 v2(307.19,9.93) ; 307.6,7.33 307.6,5.75 v4(306.86,5.01) 306.1,4.24 298.45,4.24 297.59,5.11 RPE5.5
  IN4 w0.137: v2(94.18,32.33) 98.54,27.97 107.74,27.97 108.62,27.08 119.67,27.08 120.37,27.78 126.66,27.78 127.06,27.37 131.7,27.37 132.25,26.83 135.61,26.83 136.44,26 163.23,26 163.74,25.49 177.78,25.49 178.92,26.63 189.03,26.63 189.83,25.83 223.56,25.83 224.91,27.18 238.36,27.18 239.3,26.25 244.5,26.25 245.43,25.31 253.15,25.31 253.56,24.91 255.34,24.91 263.7,16.55 269.29,16.55 271.64,14.2 273.36,14.2 275.47,12.09 282.7,12.09 284.69,10.1 287.29,10.1 288.16,10.97 299.14,10.97 300.29,9.82 302.87,9.82 303.39,9.3 303.39,9 303.63,8.76 305.01,8.76 305.66,9.41 306.71,9.41 307.19,9.9 v2(307.19,9.93)
  BOTTOM w0.14: JKB1.19 v2(94.18,32.33)
KSO8: length 228.7
  TOP w0.14: UE1.46 306,8.19 305.65,8.54 305.65,10 v2(305.43,10.22) ; v2(95.61,32.4) v4(95.61,31.16)
  IN4 w0.137: v2(95.61,32.4) 99.4,28.6 107.99,28.6 108.88,27.71 119.42,27.71 120.12,28.41 126.91,28.41 127.42,27.9 132.06,27.9 132.5,27.46 135.74,27.46 136.6,26.59 163.53,26.59 164,26.12 177.52,26.12 178.66,27.27 189.14,27.27 190.05,26.36 223.34,26.36 224.78,27.79 248.25,27.79 249.86,26.18 253.03,26.18 253.78,25.44 255.56,25.44 263.92,17.08 272.22,17.08 275.04,14.26 278.25,14.26 279.89,12.62 282.92,12.62 283.6,11.94 286.12,11.94 287.04,12.86 287.43,12.86 288.8,11.5 299.36,11.5 300.49,10.36 304.24,10.36 304.37,10.22 v2(305.43,10.22)
  BOTTOM w0.14: RPE7.8 305.74,10.53 v2(305.43,10.22) ; JKB1.17 95.78,32.23 v2(95.61,32.4)
KSO9: length 229.4
  TOP w0.14: v4(104.26,30.69) 103.78,31.16 v2(103.78,32.32) ; v2(311.34,11.99) 311.85,11.48 311.85,10.67 312.33,10.19 UE1.68 315.95,10.19 316.01,10.13 v2(316.08,10.13)
  IN4 w0.137: v2(311.34,11.99) 310.87,11.99 309.28,13.59 301.07,13.59 300.71,13.95 295.75,13.95 294.68,15.02 286.6,15.02 286.26,15.36 282.11,15.36 279.83,17.64 275.29,17.64 273.53,19.39 270.59,19.39 270.47,19.51 263.73,19.51 256.22,27.02 254.43,27.02 253.69,27.77 250.52,27.77 248.65,29.63 224.37,29.63 222.68,27.94 190.71,27.94 189.52,29.13 175.05,29.13 173.63,27.71 167.67,27.71 166.71,28.67 163.18,28.67 162.69,28.18 137.41,28.18 135.27,30.32 119.48,30.32 118.61,29.45 109.48,29.45 107.87,31.06 105.04,31.06 v2(103.78,32.32)
  BOTTOM w0.14: JKB1.7 v2(103.78,32.32) ; RE30.1 315.81,10.41 316.08,10.14 v2(316.08,10.13)
KSO10: length 229.4
  TOP w0.14: v2(312.57,11.89) 314.72,11.89 UE1.72 ; v2(105.38,32.32) 105.38,31.77 v4(105.92,31.23)
  IN4 w0.137: v2(312.57,11.89) 313.51,11.89 314.16,12.53 314.16,14.08 313.4,14.83 301.22,14.83 300.87,14.48 296.1,14.48 294.45,16.14 288.39,16.14 288.14,15.89 282.33,15.89 280.05,18.16 275.51,18.16 273.75,19.92 270.81,19.92 270.69,20.04 263.95,20.04 256.43,27.55 254.65,27.55 253.91,28.3 250.74,28.3 248.84,30.19 224.19,30.19 222.47,28.47 190.93,28.47 189.74,29.66 174.81,29.66 173.39,28.24 167.89,28.24 166.83,29.29 137.05,29.29 135.39,30.95 119.36,30.95 118.38,29.98 109.7,29.98 108.09,31.59 106.11,31.59 v2(105.38,32.32)
  BOTTOM w0.14: v2(312.57,11.89) 312.88,12.19 312.88,12.63 312.76,12.74 RPE6.8 ; JKB1.5 v2(105.38,32.32)
KSO11: length 226.8
  TOP w0.14: v4(104.23,32.77) 104.58,32.42 v2(104.58,32.32) ; v2(313.41,12.53) 313.47,12.59 UE1.74
  IN4 w0.137: v2(104.58,32.32) 105.57,31.32 107.98,31.32 109.59,29.71 118.5,29.71 119.42,30.64 135.33,30.64 136.94,29.03 166.72,29.03 167.78,27.97 173.51,27.97 174.93,29.39 189.63,29.39 190.82,28.21 222.58,28.21 224.28,29.91 248.75,29.91 250.63,28.03 253.8,28.03 254.54,27.29 256.33,27.29 263.84,19.77 270.58,19.77 270.7,19.66 273.64,19.66 275.4,17.9 279.94,17.9 282.22,15.62 286.37,15.62 286.71,15.29 294.86,15.29 295.93,14.22 300.82,14.22 301.18,13.85 310.16,13.85 310.88,14.57 313.29,14.57 313.89,13.97 313.89,12.8 313.62,12.53 v2(313.41,12.53)
  BOTTOM w0.14: v2(313.41,12.53) 313.06,12.88 313.06,12.99 312.81,13.24 RPE6.7 ; JKB1.6 v2(104.58,32.32)
KSO12: length 233.2
  TOP w0.14: UE1.75 313.59,12.99 v2(313.47,13.11) ; v4(99.67,34.09) 99.67,32.45 v2(99.78,32.34)
  IN4 w0.137: v2(99.78,32.34) 102.38,29.74 107.3,29.74 109.01,28.03 119.29,28.03 119.99,28.73 127.04,28.73 127.59,28.18 132.23,28.18 132.63,27.78 135.8,27.78 136.72,26.86 163.65,26.86 164.12,26.39 177.4,26.39 178.6,27.59 189.2,27.59 190.16,26.62 223.23,26.62 224.67,28.06 248.36,28.06 249.97,26.45 253.14,26.45 253.89,25.7 255.67,25.7 264.03,17.34 272.33,17.34 275.15,14.52 278.36,14.52 280,12.88 283.03,12.88 283.71,12.21 286.01,12.21 286.93,13.13 287.54,13.13 288.91,11.76 299.47,11.76 300.58,10.65 311.46,10.65 312.1,11.29 312.1,12.32 312.89,13.11 v2(313.47,13.11)
  BOTTOM w0.14: JKB1.12 v2(99.78,32.34) ; v2(313.47,13.11) 313.42,13.11 312.79,13.74 RPE6.6
KSO13: length 230.4
  TOP w0.14: v2(102.61,32.32) v4(102.61,31.3) ; UE1.76 313.92,13.39 313.61,13.7 v2(313.47,13.7)
  IN4 w0.137: v2(313.47,13.7) 313.1,13.7 311.83,12.43 311.83,11.45 311.33,10.95 310.71,10.95 309.59,12.07 300.43,12.07 299.07,13.42 295.44,13.42 295.42,13.44 288.35,13.44 287.87,13.92 286.6,13.92 286.3,13.62 285.73,13.62 285.31,14.04 281.5,14.04 278.43,17.11 275.07,17.11 274.04,18.14 264.36,18.14 256,26.5 254.21,26.5 253.47,27.24 250.3,27.24 248.49,29.05 224.54,29.05 222.9,27.41 190.49,27.41 189.3,28.6 175.27,28.6 173.85,27.18 167.45,27.18 166.49,28.14 163.47,28.14 162.98,27.65 137.14,27.65 135.1,29.68 119.67,29.68 118.91,28.92 109.27,28.92 107.65,30.53 103.67,30.53 102.61,31.59 v2(102.61,32.32)
  BOTTOM w0.14: RPE6.5 312.92,14.24 v2(313.47,13.7) ; v2(102.61,32.32) 102.18,31.89 JKB1.9
KSO14: length 232.7
  TOP w0.14: v2(310.3,11.97) 312.44,14.11 313.63,14.11 313.95,13.79 UE1.77 ; v4(102.78,33.99) 103.2,33.57 v2(103.2,32.32)
  IN4 w0.137: v2(103.2,32.32) 103.2,31.81 104.21,30.8 107.76,30.8 109.38,29.18 118.73,29.18 119.55,30 135.22,30 137.3,27.91 162.8,27.91 163.29,28.4 166.6,28.4 167.56,27.44 173.74,27.44 175.16,28.87 189.41,28.87 190.6,27.68 222.79,27.68 224.48,29.37 248.54,29.37 250.41,27.5 253.58,27.5 254.32,26.76 256.11,26.76 264.47,18.4 269.25,18.4 269.98,19.13 273.42,19.13 275.18,17.37 278.54,17.37 280.81,15.1 286.16,15.1 286.49,14.76 294.48,14.76 295.55,13.69 300.6,13.69 300.96,13.32 308.94,13.32 v2(310.3,11.97)
  BOTTOM w0.14: v2(310.3,11.97) 307.96,11.97 307.4,11.41 306.89,11.41 306.74,11.26 RPE7.6 ; JKB1.8 102.98,32.11 v2(103.2,32.32)
KSO15: length 235
  TOP w0.14: v4(101.16,33.14) 101.38,32.91 v2(101.38,32.34) ; v2(304.52,11.34) 305.05,10.8 308.08,10.8 308.55,11.27 308.55,14.98 310.55,16.98 312.52,16.98 312.93,17.39 UE1.86
  IN4 w0.137: v2(304.52,11.34) 303.47,11.34 303,11.8 300.32,11.8 298.96,13.16 295.33,13.16 295.31,13.18 288.24,13.18 287.76,13.66 286.71,13.66 285.79,12.74 283.92,12.74 283.25,13.41 280.22,13.41 276.79,16.84 274.96,16.84 273.93,17.87 264.25,17.87 255.89,26.23 254.11,26.23 253.36,26.98 250.19,26.98 248.57,28.59 224.45,28.59 223.01,27.15 190.38,27.15 189.31,28.22 178.41,28.22 177.11,26.92 164.41,26.92 163.94,27.39 137.02,27.39 135.04,29.37 119.8,29.37 119.09,28.66 109.16,28.66 107.54,30.27 103.45,30.27 v2(101.38,32.34)
  BOTTOM w0.14: JKB1.10 v2(101.38,32.34) ; RPE7.7 306.24,11.26 306.05,11.46 304.65,11.46 304.52,11.33 v2(304.52,11.34)
KSO16: length 236.2
  TOP w0.14: UE1.92 313.84,19.79 313.64,19.58 313.64,18.48 312.41,17.25 310.44,17.25 308.29,15.09 308.29,11.69 v2(307.82,11.23) ; v4(100.89,30.98) 100.58,31.29 v2(100.58,32.34)
  IN4 w0.137: v2(100.58,32.34) 102.92,30 107.44,30 109.09,28.35 119.17,28.35 119.86,29.05 134.91,29.05 136.84,27.12 163.76,27.12 164.23,26.65 177.22,26.65 178.47,27.9 189.25,27.9 190.27,26.89 223.12,26.89 224.56,28.33 248.46,28.33 250.08,26.71 253.25,26.71 254,25.97 255.78,25.97 264.14,17.61 272.44,17.61 275.26,14.79 278.47,14.79 280.11,13.15 283.14,13.15 283.81,12.47 285.9,12.47 286.82,13.39 287.65,13.39 289.02,12.02 299.57,12.02 300.69,10.91 307.51,10.91 v2(307.82,11.23)
  BOTTOM w0.14: RPE7.5 307.48,10.88 v2(307.82,11.23) ; JKB1.11 v2(100.58,32.34)
L_BKLT_EN_EC: length 77.9
  IN1 w0.097: v2(274.89,13.52) 275.32,13.09 276.34,13.09 279.3,10.13 289.74,10.13 289.95,10.33 289.95,10.69 291.43,12.16 292.59,12.16 293.8,13.37 295.04,13.37 303.66,13.37 305.77,11.26 306.44,11.26 307.88,9.82 310.52,9.82 311.02,9.31 v2(311.02,8.96)
  IN2 w0.097: v2(274.89,13.52) 273.96,14.45 273.96,24.07 273,25.02 273,26.67 272.14,27.54 272.14,28.75 271.86,29.02 271.86,33.28 272.54,33.96 272.54,38.23 276.26,41.96 279.02,41.96 279.52,42.46 v2(279.52,42.47)
  BOTTOM w0.102: UH2.W35 279.57,42.47 v2(279.52,42.47)
  BOTTOM w0.14: v2(311.02,8.96) 311.02,9.4 RE134.2
LAN_CLKREQ#: length 305.4
  TOP w0.14: v1(283.54,23.93) 283.34,24.13 v2(283.34,25.25) RP3.5
  IN1 w0.097: v2(29.25,45.54) 29.76,45.03 29.76,36.12 29.19,35.56 29.19,34.27 29.72,33.75 31.73,33.75 33.68,31.79 41.49,31.79 42.9,30.38 55.58,30.38 56.67,31.47 61.82,31.47 63.31,29.99 76.15,29.99 77.25,28.89 82.68,28.89 83.16,28.41 89.13,28.41 89.38,28.67 101.58,28.67 102.59,29.68 106.12,29.68 107.65,28.16 121.45,28.16 122.3,29.01 138.32,29.01 140.16,27.17 238.2,27.17 240.15,25.23 252.37,25.23 253.39,24.2 256.53,24.2 264.43,16.3 268.64,16.3 271.2,13.74 274.03,13.74 274.35,14.06 277.08,14.06 277.74,13.4 281.84,13.4 v2(282.97,14.53)
  IN2 w0.097: v2(282.97,14.53) 281.73,15.77 281.73,23.95 283.03,25.25 v2(283.34,25.25) 284.54,26.46 284.54,29.73 284.35,29.93 284.35,31.61 285.09,32.35 285.09,33.81 286.22,34.94 v2(286.22,35.02)
  BOTTOM w0.076: v2(286.22,35.02) 285.98,35.02 285.54,34.58 UH2.AT24
  BOTTOM w0.14: UL1.12 v2(29.25,45.54)
LAN_DISABLE#_R: length 302.4
  TOP w0.14: v2(277.92,26.44) v1(277.01,26.44)
  IN2 w0.097: v2(277.92,26.44) 278.23,26.76 278.23,28.29 279.59,29.64 279.59,32.79 279.03,33.35 279.03,33.72 279.34,34.03 279.84,34.03 280.4,34.6 280.4,35.26 282.19,37.04 v2(283.76,37.04)
  IN3 w0.124: v2(277.92,26.44) 277.85,26.44 276.33,24.92 265.88,24.92 264.84,25.96 260.38,25.96 256.6,29.75 254.74,29.75 253.55,30.94 245.5,30.94 244.91,30.34 223.06,30.34 221.71,29 215.86,29 215.41,29.44 191.71,29.44 191.07,30.08 155.98,30.08 155.75,30.3 154.63,30.3 154.01,29.69 137.46,29.69 136.41,30.73 114.56,30.73 113.4,29.57 109.43,29.57 108.43,30.57 88.81,30.57 88.44,30.94 85.61,30.94 84.94,30.27 84.94,27.82 84.28,27.15 67.99,27.15 63.96,31.18 60.67,31.18 59.12,29.63 59.12,27.94 58.46,27.28 51.45,27.28 50.28,28.45 47.46,28.45 47.03,28.02 37.61,28.02 35.18,30.44 35.18,30.44 32.42,33.2 32.42,36.77 29.97,39.23 25.42,39.23 24.07,37.87 v2(22.52,37.87)
  BOTTOM w0.102: UH2.AL27 284.14,37.42 v2(283.76,37.04)
  BOTTOM w0.14: RL43.1 22.37,40.47 22.37,38.03 v2(22.52,37.87) 23.12,37.28 26.95,37.28 RL1.1
LAN_EN: length 326.3
  TOP w0.14: RE131.2 296.5,22.79 296.56,22.85 v2(296.56,23.18)
  IN3 w0.124: v2(296.56,23.18) 296.56,22.77 297.45,21.88 297.45,20.36 297.09,20.01 294.31,20.01 293.7,19.39 288.81,19.39 288.4,18.99 286.35,18.99 285.73,18.37 284.22,18.37 282.57,20.03 281.41,20.03 280.93,19.54 274.4,19.54 273.72,20.22 271.83,20.22 271.13,19.53 260.92,19.53 255.24,25.2 244.48,25.2 244.48,25.2 239.44,25.2 237.62,27.02 224.7,27.02 223.64,25.96 209.57,25.96 209.05,26.49 136.34,26.49 135.82,27 117.8,27 116.88,26.09 86.49,26.09 84.58,24.17 68.83,24.17 63.72,29.28 61.02,29.28 60.9,29.16 60.9,27 58.7,24.81 36.49,24.81 30.5,30.79 30.5,32.77 31.17,33.44 31.17,36.59 29.55,38.22 27.92,38.22 26.87,37.18 21.97,37.18 21.16,37.99 21.16,46.48 22.2,47.53 22.2,54.97 23.22,55.98 v2(23.22,56.44)
  BOTTOM w0.14: v2(296.56,23.18) 296.56,23.1 297.1,22.56 v1(297.44,22.56) ; v2(23.22,56.44) RL27.2 22.63,55.14 UL2.4
LAN_WAKE#: length 10
  BOTTOM w0.076: UH2.BD11 291.76,30.76 292.08,30.44 292.08,29.69 291.55,29.16 291.55,28.58 291.58,28.56
  BOTTOM w0.14: RH11.1 291.01,23.52 291.01,24.29 RH181.1 290.49,25.44 291.03,25.99 291.03,27.55 291.58,28.09 v1(291.58,28.22) 291.58,28.56
LAN_WAKE#_R: length 6.2
  BOTTOM w0.14: RL42.2 25.78,38.84 v1(25.78,38.29) ; RL42.2 26.35,39.41 RL2.2 ; RL42.2 26.34,41.86 26.13,42.07 UL1.21
LANWAKE#: length 21.5
  TOP w0.14: v2(301.54,8.72) 301.6,8.65 UE1.35
  BOTTOM w0.14: v2(301.54,8.72) 301.37,8.55 300.38,8.55 299.08,9.85 v1(299,9.85) 298.78,10.07 298.78,13.43 298.28,13.93 298.28,17.9 297.19,19 297.19,19.87 297.46,20.14 297.46,20.99 297.1,21.35 296.51,21.35 295.85,22.02 293.42,22.02 RH11.2
LCD_DBC: length 3.2
  TOP w0.14: v1(279.59,44.43) 279.98,44.43 v2(280.2,44.65) 280.35,44.8 RH560.1 280.35,45.91 RH559.2
  BOTTOM w0.076: v2(280.2,44.65) UH2.U35
LCD_TST: length 235
  TOP w0.14: v2(102.78,29.15) 101.94,29.99 101.94,33.36 99.81,35.5 v1(99.81,43.67) 99.81,44.48 97.44,46.85 94.07,46.85 92.99,47.93 92.99,48.31 92.69,48.62 RV538.1 92.18,48.49 DV2.3 ; v2(297.26,12.72) 297.02,12.47 297.02,12.04 297.67,11.39 UE1.26
  IN1 w0.097: v2(297.26,12.72) 296.8,13.17 293.88,13.17 292.67,11.97 291.51,11.97 290.15,10.61 290.15,10.25 289.82,9.93 289.12,9.93 289.12,9.93 279.22,9.93 276.56,12.59 271.68,12.59 268.45,15.82 264.24,15.82 256.33,23.73 253.2,23.73 252.17,24.75 239.95,24.75 238.01,26.69 139.93,26.69 138.98,27.65 133.52,27.65 132.97,28.2 122.17,28.2 121.62,27.65 107.46,27.65 105.96,29.15 v2(102.78,29.15)
LCD_TST_R: length 6.7
  TOP w0.14: RV538.2 93.5,46.51 v1(93.5,45.47) 93.5,43.43 v2(93.68,43.25)
  BOTTOM w0.14: JEDP1.5 v2(93.68,43.25)
LCD_VCC_TEST_EN: length 281.9
  TOP w0.127: DV3.2 v1(95.19,55.19)
  TOP w0.14: v2(307.11,19.54) 306.8,19.84 UE1.113 ; v2(92.43,55.46) 92.7,55.19 DV3.2
  IN3 w0.124: v2(87.61,23.14) 87.61,23.4 88.94,24.73 117.44,24.73 118.22,25.5 129.29,25.5 130.38,24.41 136.61,24.41 137.01,24.82 162.17,24.82 162.49,25.13 208.48,25.13 209.24,24.37 223.97,24.37 225.03,25.43 237.11,25.43 239.59,22.94 255.25,22.94 264.48,13.72 269.83,13.72 272.89,10.65 275.47,10.65 276.46,9.66 291.14,9.66 291.65,10.17 291.65,10.87 292.19,11.41 299.98,11.41 300.59,12.02 301.57,12.02 307.11,17.56 v2(307.11,19.54)
  IN4 w0.137: v2(87.61,23.14) 87.61,29.49 84.54,32.56 84.54,33.26 84.9,33.62 87.54,33.62 88.56,34.64 88.56,37.92 86.73,39.75 86.73,47.19 89.1,49.56 91.1,49.56 91.86,50.32 91.86,54.89 v2(92.43,55.46)
LDO1_CAP: length 4.8
  TOP w0.127: v1(349.15,17.26) 349.24,17.35 350.06,17.35 RA11.2
  TOP w0.203: CA19.2 349.33,18.44 348.98,18.1 348.49,18.1 347.93,18.66 HDA1.27
  TOP w0.381: RA11.2 350.08,17.68 349.8,17.96 CA19.2
LDO2_CAP: length 2.9
  TOP w0.203: HDA1.39 345.85,23.86 v1(346.23,24.23) 346.51,24.51 346.98,24.51 347.38,24.92 CA22.2
LDO3_CAP: length 2.7
  TOP w0.203: 340.78,19.74 340.9,19.86 340.92,19.86 340.93,19.86 HDA1.7
  TOP w0.381: 340.78,19.74 v1(340.11,19.74) 339.56,19.74 CA27.1
LDO_1V: length 0.8
  BOTTOM w0.14: v2(253.35,39.36) 253.85,39.36 v1(254.06,39.58)
LED1: length 40.5
  TOP w0.127: v2(209.02,33.3) 208.52,32.81 v1(208.29,32.81)
  TOP w0.254: v2(220.92,54.98) 220.92,55.63 221.45,56.16 QE20.6
  IN3 w0.254: v2(220.92,54.98) 219.62,53.69 219.62,47.15 213.97,41.49 213.97,35.53 210.85,32.41 209.91,32.41 209.02,33.3 v2(209.02,33.3)
  BOTTOM w0.254: v2(209.02,33.3) 209.02,32.5 206.88,30.36 203.4,30.36 202.65,29.61 JLED.3
LED2: length 48.6
  TOP w0.127: v1(210.05,33.95) 209.69,33.6 v2(209.69,33.34)
  TOP w0.254: QE21.3 225.91,55.95 225.45,55.49 v2(225.45,55.4) ; QE23.3 216.84,55.88 217.19,55.54 v2(218.26,55.54)
  IN3 w0.254: v2(218.26,55.54) 218.26,54.6 219.11,53.75 219.11,47.36 213.46,41.7 213.46,35.74 210.64,32.91 210.12,32.91 v2(209.69,33.34)
  IN5 w0.254: v2(218.26,55.54) 219.19,56.47 224.38,56.47 v2(225.45,55.4)
  BOTTOM w0.254: v2(209.69,33.34) 209.53,33.18 209.53,32.29 207.09,29.85 203.92,29.85 203.65,29.59 JLED.2
LG_1.2V: length 1.4
  TOP w0.14: v4(111.71,74.08) 110.95,73.32 v2(110.59,73.32)
  vias: v2(110.25,69.44) v2(110.23,68.83) v2(110.59,72.74)
LG_3V: length 8.5
  TOP w0.14: v2(79.4,44.74) 79.4,44.96 v1(78.92,45.44)
  IN5 w0.762: 71.16,43.72 78.25,43.72 78.58,44.04
  vias: v2(70.33,43.91) v2(70.33,43.27) v2(79.4,44.11)
LG_5V: length 13.9
  IN5 w0.762: 66.78,39.72 67.35,39.14 71.53,39.14 72.11,39.73 72.11,41.25 72.87,42.01 77.88,42.01 78.2,41.69
  vias: v1(65.56,39.53) v2(65.25,40.1) v2(65.89,40.1) v2(78.96,41.69) v2(78.96,41.06)
LG_+1.35V: length 18.7
  TOP w0.14: v2(239.69,54.13) 240.01,54.13 v1(240.4,53.74)
  IN1 w0.762: 257.6,52.48 244.64,52.48 244.13,52.99 241.47,52.99 240.45,54
  vias: v2(239.05,54.13) v2(250.99,51.72) v2(251.63,51.72) v2(257.21,51.72) v2(257.85,51.72)
LG_CHG: length 4.6
  TOP w0.14: v1(37.7,36.57) 37.98,36.85 v2(37.98,37.09)
  IN1 w1.016: 38.96,37.18 39.99,37.18 40.63,37.81 42.63,37.81 42.65,37.82
  vias: v2(37.47,37.47) v2(43.54,38.26) v2(43.54,37.62)
LID_CL_SIO#: length 17.5
  TOP w0.14: UE1.66 316.17,9.39 316.62,8.93 v1(317.39,8.93) v2(318.09,8.93) ; CE8.1 321.35,19.41 RE68.2 321.35,19.03 RE25.2 320.31,18.12 v2(319.85,18.58)
  IN4 w0.137: v2(318.09,8.93) 318.09,9.62 318.3,9.83 318.3,11.13 319.76,12.59 319.76,18.49 v2(319.85,18.58)
LID_CLOSE#: length 296.6
  TOP w0.14: v2(319.85,19.2) RE68.1 ; v2(216.83,145.13) v4(216.83,144.26) CE17.1 215.45,141.47 UE3.3
  IN1 w0.097: v2(320.33,28.68) 319.35,29.66 310.75,29.66 309.37,28.29 306.21,28.29 304.57,29.92 298.44,29.92 297.93,29.42 294.53,29.42 294.18,29.76 294.18,29.97 293.47,30.69 292.69,30.69 292.42,30.95 288.97,30.95 285.87,34.05 284.26,34.05 283.91,34.41 283.29,34.41 282.93,34.76 282.93,35.4 281.46,36.87 281.46,38 280.94,38.52 280.94,42.4 279.2,44.13 278.83,44.13 278.52,44.44 278.52,45.1 279.2,45.77 279.2,46.63 279.56,46.98 279.56,50.46 278.1,51.91 278.1,53.17 276.89,54.39 276.89,59.09 276.42,59.56 274.82,61.16 265.9,61.16 263.42,63.63 228.02,63.63 227.43,64.23 226.45,64.23 225.15,62.92 220.58,62.92 219.31,61.65 214.54,61.65 213.88,61 212.65,61 212.1,60.44 209.47,60.44 208.96,60.96 195.78,60.96 191.36,65.38 191.36,68 190.95,68.42 187.78,68.42 185.04,71.16 185.04,77.17 187.06,79.19 187.06,93.62 183.89,96.79 183.89,98.66 186.35,101.12 186.35,103.58 186.05,103.89 186.05,104.53 186.65,105.13 186.93,105.13 188.7,106.9 192.13,106.9 194.1,108.87 194.1,121.44 192.33,123.2 189.49,123.2 188.15,124.54 188.15,131.63 189.02,132.49 191.3,132.49 192.62,133.81 192.62,137.87 199.3,144.55 216.26,144.55 v2(216.83,145.13)
  BOTTOM w0.14: v2(319.85,19.2) 320.77,20.12 320.77,22.07 321.11,22.41 321.11,27.9 v2(320.33,28.68)
LINE1-L_C: length 2.3
  TOP w0.127: RA48.1 351.75,14.8 v1(352.06,15.1)
  TOP w0.305: RA48.1 351.59,13.76 CA64.2
LINE1-L_R: length 2.4
  TOP w0.127: CA65.2 v1(348.97,7.94)
  TOP w0.305: CA65.2 349.85,9.36 RA51.1
LINE1_L: length 5.4
  TOP w0.203: 346.79,16.2 346.71,16.27 346.22,16.27 345.85,16.64 HDA1.22
  TOP w0.305: 346.79,16.2 347.26,15.73 347.26,15.22 v1(347.41,15.07) 348.72,13.76 CA64.1
LINE1_R: length 8.6
  TOP w0.203: HDA1.21 345.45,16.52 346.2,15.76 346.35,15.76 346.45,15.66
  TOP w0.305: CA65.1 v1(347.57,11.29) 347.57,13.17 346.69,14.06 346.69,15.43 346.45,15.66
LINE1_VREFO_L: length 12.3
  TOP w0.127: v2(351,12.03) 350.48,12.03 v1(350.15,12.36)
  TOP w0.203: v2(348.84,20.16) 348.39,20.16 348.28,20.26 HDA1.31
  TOP w0.305: v2(351,12.03) 351.74,12.03 RA46.1
  IN1 w0.305: v2(348.84,20.16) 349.1,20.16 350.05,19.21 350.05,14.08 350.98,13.15 350.98,12.05 v2(351,12.03)
LINE1_VREFO_R: length 14.4
  TOP w0.127: v1(353.73,11.66) 353.21,11.14 v2(352.34,11.14)
  TOP w0.203: HDA1.30 348.12,19.86 348.46,19.52 v2(348.78,19.52)
  TOP w0.305: v2(352.34,11.14) RA53.1
  IN1 w0.305: v2(348.78,19.52) 348.91,19.52 349.49,18.94 349.49,13.62 350.21,12.9 350.21,11.93 351,11.14 v2(352.34,11.14)
LX_1.0VS_VGAP: length 3.3
  TOP w0.14: v2(120.82,91.85) v4(121.74,91.85)
  IN4 w1.016: 120.69,94.83 120.69,93.96 121.17,93.47 121.17,92.67
  vias: v2(120.82,91.27) v2(121.5,95.86) v2(121.5,95.28)
LX_1.2V: length 8.2
  TOP w0.14: v4(106.4,77.98) 105.93,77.51 105.93,77.12
  IN1 w1.016: 105.96,75.4 105.96,73.61 106.57,73 106.57,70.48 107.96,69.09
  vias: v2(106.81,76.29) v2(107.04,76.93) v2(107.42,76.29) v2(107.76,76.93) v2(108.37,76.93) v2(109.03,76.93) v2(109.18,68.82) v2(109.64,76.93) v2(109.66,68.47) v2(110.95,77.24) v2(110.95,76.61) v2(110.95,75.97) v2(110.95,75.34) v2(111.24,74.82) v2(111.58,77.24) v2(111.58,76.61) v2(111.58,75.97) v2(111.58,75.34)
LX_1.8V:
  vias: v1(271.73,79.07) v2(271.51,82.13) v2(271.51,81.5) v2(271.84,77.6) v2(272.27,77.19)
LX_1V: length 2.4
  IN2 w0.508: 249.78,41.87 252.21,41.87
  vias: v1(255.04,43.93) v2(249.09,42.4) v2(249.09,41.81) v2(252.82,41.82) v2(253.4,42.41) v2(253.4,41.82) v2(253.4,41.24) v2(254.04,42.59) v2(254.04,42) v2(254.62,42.59) v2(254.62,42)
LX_3V: length 18.5
  TOP w0.14: PR309.1 v1(63.16,50.36)
  IN5 w0.762: 65.83,48.86 65.83,48.87 80.29,48.87 81.37,47.79 81.37,47.15
  vias: v2(63.03,47.53) v2(63.03,46.89) v2(63.67,47.53) v2(63.67,46.89) v2(64.3,47.53) v2(64.3,46.89) v2(64.43,48.22) v2(64.36,46.26) v2(64.36,45.62) v2(64.36,44.99) v2(64.36,44.35) v2(65.06,48.22) v2(81.43,45.31) v2(81.69,45.95)
LX_5V: length 11.7
  IN5 w0.762: 81.43,38.9 79.08,36.54 73.64,36.54 71.54,34.45
  vias: v1(63.86,33.49) v2(63.27,39.17) v2(63.27,38.59) v2(63.27,37.95) v2(63.27,37.37) v2(63.27,36.73) v2(63.27,36.03) v2(63.86,39.17) v2(63.86,38.59) v2(63.86,37.95) v2(63.86,37.37) v2(63.86,36.73) v2(63.86,36.03) v2(64.17,35.46) v2(64.56,39.17) v2(64.56,38.59) v2(64.56,37.95) v2(64.56,37.37) v2(64.56,36.73) v2(64.56,36.03) v2(64.87,35.46) v2(70.65,34.76) v2(70.65,34.13) v2(81.31,40.42) v2(81.31,39.79)
LX_+1.35V: length 10.6
  TOP w0.14: v1(259.26,58.52) 259.03,58.3 259.03,57.36
  IN1 w0.762: 241.72,55.27 250.74,55.27 250.99,55.53
  vias: v2(240.07,55.65) v2(240.7,55.65) v2(251.75,55.91) v2(251.75,55.27) v2(251.75,54.64) v2(251.75,54) v2(251.75,53.37) v2(252.13,56.48) v2(252.39,55.91) v2(252.39,55.27) v2(252.39,54.64) v2(252.39,54) v2(252.39,53.37) v2(252.45,56.99) v2(252.77,56.48) v2(253.02,55.91) v2(253.02,55.27) v2(253.02,54.64) v2(253.02,54) v2(253.02,53.37) v2(258.03,57.13) v2(258.03,56.54) v2(257.98,55.91) v2(257.98,55.27) v2(257.98,54.64) v2(257.98,54) v2(257.98,53.37) v2(258.61,57.06) v2(258.61,56.48) v2(258.61,55.84) v2(258.74,54) v2(258.74,53.37) v2(259.25,57.06) v2(259.25,56.48) v2(259.25,55.84) v2(259.37,54) v2(259.37,53.37) v2(259.88,57.06) v2(259.88,56.48) v2(259.88,55.84) v2(260.01,54) v2(260.01,53.37)
LX_CHG: length 10.6
  IN1 w1.016: 47.35,42.38 47.16,42.57 39.16,42.57 38.33,41.75 38.33,40.62
  vias: v1(48.01,44.22) v2(37.82,39.78) v2(46.58,41.14) v2(47.27,41.14) v2(47.89,41.13) v2(48.55,44.54) v2(48.55,43.27) v2(48.55,42.64) v2(48.55,41.94) v2(48.55,41.3) v2(49.06,42.32) v2(49.06,41.62) v2(49.7,42.32)
LX_GPU1: length 1.4
  BOTTOM w0.14: v1(171.08,134.47) 171.49,134.06 PC6102.2
LX_GPU3: length 1.4
  BOTTOM w0.14: v1(172.62,122.48) 173.19,121.91 PC6129.2
LX_GPU_PH1: length 32.3
  TOP w0.14: v2(180.19,131.35) 180.67,130.86 v4(180.67,130.51)
  TOP w0.254: PR6108.1 v2(180.19,131.35) ; PR6027.1 157.77,143.84 v2(157.77,144.34)
  IN1 w0.254: v2(157.77,144.34) 157.77,143.92 158.29,143.4 158.92,143.4 162.68,139.64 166.23,139.64 170.12,135.75 170.58,135.75 173.33,133 173.33,131.22 173.92,130.63 174.57,130.63 174.73,130.46 179.3,130.46 v2(180.19,131.35)
LX_GPU_PH2: length 24
  TOP w0.14: v1(177.46,140.38) 177.69,140.6 PR6115.1
  TOP w0.508: PR6028.1 v2(158.56,144.39)
  IN1 w0.508: v2(179.29,141.48) 178.67,141.48 v2(178.64,141.51) 178.38,141.51 176.78,143.11 170.61,143.11 169.93,143.79 161.28,143.79 161.16,143.68 159.39,143.68 158.67,144.39 v2(158.56,144.39)
LX_GPU_PH3: length 43.6
  TOP w0.14: v2(182.28,120.3) 182.82,120.3 183.27,120.75 v4(183.27,121.1)
  TOP w0.254: PR6029.1 159.64,143.83 v2(159.64,144.34) ; PR6122.1 v2(182.28,120.3)
  IN4 w0.254: v2(180.44,117.95) 176.7,117.95 176.44,118.2 176.44,119.15 176.32,119.28 175.43,119.28 174.85,119.85 174.85,121.76 175.62,122.52 175.62,125.08 174.54,126.15 174.54,126.47 173.47,127.54 173.16,127.54 172.67,128.02 172.67,129.15 172.54,129.28 172.54,134.73 170.94,136.34 169.54,136.34 167.55,138.33 167.55,138.33 163.55,142.33 163.17,142.33 161.16,144.34 v2(159.64,144.34)
LX_VCCIO: length 7.7
  TOP w0.14: v2(124.94,98.69) v4(126.35,98.69)
  IN1 w1.016: 123.42,98.9 122.28,100.04 122.28,104.68
  vias: v2(123.17,104.93) v2(123.17,104.3) v2(124.31,98.71)
MAINPWON: length 7.3
  BOTTOM w0.127: RTH2.2 v1(97.07,65.5)
  BOTTOM w0.14: UTH1.7 98.83,68.28 99.1,68.01 99.1,65.94 98.65,65.5 v1(97.07,65.5)
MASK_SATA_LED#: length 4
  TOP w0.203: UE1.56 310,8.36 v2(309.42,8.94)
  BOTTOM w0.127: RE132.1 v1(309.84,9.81)
  BOTTOM w0.254: v2(309.42,8.94) 308.76,9.6 RE132.1
MAX-Q_DET: length 5.6
  BOTTOM w0.089: UG9.BE4 204.96,81.75 205.27,81.44 205.27,78.89
  BOTTOM w0.14: v1(205.65,77.42) 205.61,77.38 RG579.1 204.8,78.26 205.27,78.73 205.27,78.89
MCARD_PCIE_SATA#: length 48.8
  TOP w0.14: v2(279.64,39) 279.18,39.46 275.46,39.46 274.76,40.17 273.64,40.17 272.75,41.06 v1(271.97,41.06) 271.22,41.81 RH68.1 ; v2(275.07,8.79) RD58.1
  IN2 w0.097: v2(275.07,8.79) 275.3,9.02 275.3,14.24 274.52,15.01 274.52,24.28 273.54,25.27 273.54,26.92 272.69,27.77 272.69,30.3 273.09,30.7 273.09,36.85 273.83,37.58 274.54,37.58 275.2,38.24 275.2,38.53 276.25,39.59 279.13,39.59 279.64,39.08 v2(279.64,39)
  BOTTOM w0.089: UH2.AG36 279.34,39.3 v2(279.64,39)
MCT0: length 3.4
  TOP w0.127: v4(30.95,71.39) v2(30.95,72.37)
  TOP w0.508: v2(30.95,72.37) 30.96,72.39 RL19.1
  BOTTOM w0.508: v2(30.95,72.37) 30.94,72.39 TL2.24
MCT1: length 3.5
  TOP w0.127: v2(27.97,72.29) v4(27.97,71.39)
  TOP w0.508: RL20.1 27.98,72.46 27.97,72.44 v2(27.97,72.29)
  BOTTOM w0.508: TL2.21 v2(27.97,72.29)
MCT2: length 3.2
  TOP w0.127: 24.99,72.43 v4(24.99,71.52)
  TOP w0.508: RL39.1 24.99,72.43 v2(24.98,72.42)
  BOTTOM w0.508: TL2.18 25,72.43 v2(24.98,72.42)
MCT3: length 3.1
  TOP w0.127: v2(22.03,72.48) v1(22.03,71.56)
  TOP w0.508: RL40.1 22.01,72.5 v2(22.03,72.48)
  BOTTOM w0.508: TL2.15 v2(22.03,72.48)
MDI0+: length 20.2
  IN1 w0.089: v2(21.89,62.17) 21.89,55.65 24.09,53.45 24.09,49.73 24.81,49.01 24.81,48.52 24.52,48.22 v2(24.49,48.22)
  BOTTOM w0.112: UL1.1 24.93,47.39 24.93,47.78 v2(24.49,48.22) ; TL2.12 20.05,64.22 20.46,63.81 20.46,63.32 21.02,62.76 21.78,62.76 21.89,62.65 v2(21.89,62.17)
MDI0-: length 20.2
  IN1 w0.089: v2(25.07,48.21) 25.07,49.11 24.35,49.83 24.35,53.55 22.15,55.75 22.15,61.84 v2(22.48,62.17)
  BOTTOM w0.112: UL1.2 25.33,48.1 25.22,48.21 v2(25.07,48.21) ; TL2.11 21.04,64.1 20.74,63.81 20.74,63.44 21.13,63.05 21.9,63.05 22.18,62.77 22.18,62.47 v2(22.48,62.17)
MDI1+: length 19.3
  IN1 w0.089: v2(26.39,49.95) 26.53,50.09 26.53,50.24 25.58,51.2 25.58,57.37 23.41,59.53 23.41,62.32 v2(23.25,62.49)
  BOTTOM w0.112: v2(23.25,62.49) 23.4,62.63 23.4,63.62 23.02,64 TL2.9 ; UL1.4 26.13,47.77 26.23,47.87 26.23,48.84 26.57,49.19 26.57,49.76 v2(26.39,49.95)
MDI1-: length 19.3
  IN1 w0.089: v2(26.97,49.95) 26.97,49.95 26.79,50.12 26.79,50.35 25.84,51.31 25.84,57.48 23.67,59.64 23.67,62.32 v2(23.84,62.49)
  BOTTOM w0.112: v2(23.84,62.49) 23.69,62.63 23.69,63.62 24.01,63.94 TL2.8 ; UL1.5 26.53,47.88 26.44,47.97 26.44,48.76 26.79,49.1 26.79,49.76 v2(26.97,49.95)
MDI2+: length 18.8
  IN1 w0.089: v2(26.2,62.28) 26.4,62.09 26.4,59.2 27.86,57.74 27.86,49.63 27.01,48.78 27.01,48.49 v2(26.86,48.34)
  BOTTOM w0.112: v2(26.86,48.34) 26.96,48.24 26.96,48.04 26.93,48.02 UL1.6 ; TL2.6 25.99,63.97 26.35,63.6 26.35,62.43 v2(26.2,62.28)
MDI2-: length 18.7
  IN1 w0.089: v2(27.45,48.34) 27.27,48.52 27.27,48.67 28.12,49.52 28.12,57.85 26.66,59.31 26.66,62.15 v2(26.79,62.28)
  BOTTOM w0.112: v2(27.45,48.34) 27.33,48.22 UL1.7 ; TL2.5 26.98,63.94 26.64,63.6 26.64,62.43 v2(26.79,62.28)
MDI3+: length 20.4
  IN1 w0.089: v2(29.18,62.33) 29.22,62.29 29.22,62.28 29.51,62 29.51,59.68 30.35,58.84 30.35,50.11 29.52,49.28 29.52,47.89 v2(29.34,47.71)
  BOTTOM w0.112: v2(29.18,62.33) 29.4,62.55 29.4,63.4 28.96,63.84 TL2.3 ; v2(29.34,47.71) 29.58,47.47 29.58,47.16 29.03,46.61 28.9,46.61 28.77,46.74 UL1.9
MDI3-: length 20.4
  IN1 w0.089: v2(29.96,47.74) 29.78,47.92 29.78,49.18 30.61,50 30.61,58.94 29.77,59.78 v2(29.77,62.33)
  BOTTOM w0.112: v2(29.96,47.74) 29.8,47.58 29.8,47.07 29.12,46.39 28.81,46.39 28.76,46.34 UL1.10 ; TL2.2 29.95,63.79 29.68,63.53 29.68,62.42 v2(29.77,62.33)
MDO0+: length 27.1
  IN1 w0.089: JLAN.1 13.71,93.57 13.97,93.57 14.28,93.89 15.07,93.89 16.74,92.21 16.74,90.3 18.51,88.53 18.51,78.31 19.83,77 20.19,77 20.42,77.22 20.42,77.77 v2(20.25,77.94)
  BOTTOM w0.112: TL2.13 20.05,74.68 20.39,75.02 20.39,77.8 v2(20.25,77.94)
MDO0-: length 27.1
  IN1 w0.089: v2(20.83,77.94) 20.68,77.79 20.68,77.12 20.3,76.74 19.72,76.74 18.25,78.21 18.25,88.43 16.49,90.2 16.49,92.1 14.96,93.63 14.39,93.63 13.95,93.19 JLAN.2
  BOTTOM w0.112: TL2.14 21.04,74.66 20.68,75.02 v3(20.68,76.46) 20.68,77.79 v2(20.83,77.94)
MDO1+: length 27.5
  IN5 w0.089: v2(23.27,77.31) 23.47,77.11 23.47,76.63 23.38,76.55 19.39,76.55 18.01,77.93 18.01,88.29 15.72,90.58 15.15,90.58 14.2,91.53 JLAN.3
  BOTTOM w0.112: v2(23.27,77.31) 23.47,77.1 23.47,75.4 23.02,74.95 TL2.16
MDO1-: length 27.5
  IN5 w0.089: JLAN.6 13.95,89.25 15.03,90.33 15.61,90.33 17.75,88.19 17.75,77.82 19.28,76.29 23.48,76.29 23.72,76.53 23.72,77.18 v2(23.85,77.31)
  BOTTOM w0.112: v2(23.85,77.31) 23.76,77.21 23.76,75.4 24.01,75.15 TL2.17
MDO2+: length 29.2
  IN1 w0.089: JLAN.4 13.63,90.19 13.63,89.82 13.82,89.63 15.85,89.63 17.4,88.07 17.4,77.85 19.37,75.89 26.13,75.89 26.39,76.15 26.39,76.39 v2(26.17,76.61)
  BOTTOM w0.112: TL2.19 25.99,75.14 26.55,75.7 26.55,76.23 v2(26.17,76.61)
