# Allegro board Dell_Inspiron_15_7577_Compal_CKA50_CKF50_LA_E992P_Rev_1_0_BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CPU_DDI3_N0: length 194.6
  TOP w0.14: v2(320.89,32.83) 320.73,32.99 320.73,33.44 CVGA11.1
  IN5 w0.104: v2(178.04,101.81) 178.03,102.07 178.4,102.44 179,102.44 180.59,100.84 181.31,100.84 181.49,100.66 182.04,100.66 183.21,99.49 183.21,96.65 185.74,94.12 185.74,74.9 185.33,74.49 185.33,71.43 191.07,65.69 192.75,65.69 193.39,65.05 197.08,65.05 198.54,63.59 209.95,63.59 210.32,63.97 215.15,63.97 215.89,64.71 218.99,64.71 219.55,65.27 222.83,65.27 223.21,65.65 227.01,65.65 227.66,66.3 265.73,66.3 271.4,60.62 284.59,60.62 285.72,59.49 289.82,59.49 290.52,58.79 292.28,58.79 297.59,53.48 299,53.48 299.09,53.39 299.1,53.39 300.51,51.98 300.51,51.98 300.71,51.77 300.71,48.7 305.59,43.82 305.59,43.09 305.59,42.09 312.22,35.45 317.31,35.45 319.08,33.68 320.42,33.68 320.71,33.39 320.71,33.01 v2(320.89,32.83)
  BOTTOM w0.14: UH1.D34 178.04,101.88 v2(178.04,101.81)
CPU_DDI3_N1: length 197.3
  TOP w0.14: CVGA13.1 322.81,31.58 322.33,31.1 322.33,30.79 322.55,30.57 324.1,30.57 324.5,30.97 324.5,31.8 324.15,32.15 v2(324.15,32.67)
  IN5 w0.104: v2(179.95,102.26) 179.95,102.41 180.05,102.52 180.81,102.52 183.72,99.61 183.72,96.83 186.58,93.97 186.58,79.62 192.19,74.01 192.19,70.14 195.04,67.28 196.38,67.28 197.01,66.65 209.58,66.65 210.69,65.53 211.34,65.53 212.43,64.44 214.87,64.44 217,66.58 227.36,66.58 227.59,66.8 265.8,66.8 271.55,61.05 285.96,61.05 286.95,60.07 289.82,60.07 290.69,59.2 292.44,59.2 297.75,53.89 299.18,53.89 300.91,52.15 300.91,52.14 301.28,51.78 301.28,49.65 301.28,49.41 301.28,49.14 301.28,48.78 306.08,43.98 306.08,42.17 312.38,35.88 317.46,35.88 319.25,34.09 321.15,34.09 322.13,33.11 323.12,33.11 323.22,33.01 323.22,32.77 323.36,32.64 323.53,32.64 323.64,32.74 323.64,33.01 323.74,33.11 324.14,33.11 324.29,32.96 324.29,32.81 v2(324.15,32.67)
  BOTTOM w0.14: v2(179.95,102.26) 179.95,102.31 UH1.B34
CPU_DDI3_P0: length 194.6
  TOP w0.14: CVGA10.1 320.48,33.46 320.48,33 v2(320.31,32.83)
  IN5 w0.104: v2(320.31,32.83) 320.52,33.05 320.52,33.31 320.34,33.49 319,33.49 317.23,35.26 312.14,35.26 305.4,42.01 305.4,43.09 305.4,43.74 300.52,48.62 300.52,51.69 300.31,51.9 300.31,51.9 299.02,53.2 299.01,53.2 298.92,53.29 297.51,53.29 292.2,58.6 290.44,58.6 289.74,59.3 285.64,59.3 284.51,60.43 271.32,60.43 265.65,66.1 227.74,66.1 227.09,65.46 223.29,65.46 222.91,65.08 219.63,65.08 219.07,64.52 215.97,64.52 215.23,63.78 210.4,63.78 210.03,63.4 198.46,63.4 197,64.86 193.31,64.86 192.67,65.5 190.99,65.5 185.14,71.35 185.14,74.57 185.55,74.98 185.55,94.04 183.02,96.57 183.02,99.41 181.96,100.47 181.41,100.47 181.23,100.65 180.51,100.65 179.89,101.28 179.74,101.28 179.61,101.15 179.42,101.15 179.3,101.27 179.3,101.42 179.45,101.57 179.45,101.72 178.92,102.25 178.55,102.25 178.42,102.11 178.43,101.96 178.57,101.83 v2(178.7,101.83)
  BOTTOM w0.14: UH1.C34 178.7,101.89 v2(178.7,101.83)
CPU_DDI3_P1: length 197.4
  TOP w0.14: v2(324.75,32.29) 324.75,30.86 324.2,30.31 322.45,30.31 322.08,30.68 322.08,31.1 321.98,31.19 CVGA12.1
  IN5 w0.104: v2(179.95,103.03) 180.27,102.71 180.89,102.71 183.91,99.69 183.91,96.91 186.77,94.05 186.77,79.7 187.59,78.88 192.38,74.09 192.38,73.93 192.38,70.22 195.12,67.48 196.46,67.48 197.09,66.84 209.66,66.84 210.77,65.73 211.42,65.73 212.51,64.64 214.79,64.64 216.92,66.77 227.28,66.77 227.51,67 265.88,67 271.63,61.24 286.04,61.24 287.03,60.26 289.9,60.26 290.77,59.39 292.52,59.39 297.83,54.08 299.26,54.08 301.11,52.23 301.11,52.22 301.47,51.86 301.47,49.57 301.47,49.49 301.47,49.41 301.47,48.86 306.28,44.06 306.28,42.25 312.46,36.07 317.54,36.07 319.33,34.28 321.23,34.28 322.21,33.3 324.25,33.3 324.56,33 324.56,32.48 v2(324.75,32.29)
  BOTTOM w0.14: v2(179.95,103.03) UH1.B36
CPU_DDI3HPD: length 26.5
  TOP w0.14: RVGA9.1 314.54,38.06 v1(314.4,37.93) 314.4,37.02 v2(314.9,36.53)
  IN4 w0.137: v2(314.9,36.53) 314.33,37.1 308.46,37.1 305.16,33.8 302.29,33.8 301.53,33.04 300.28,33.04 299.88,32.65 297.15,32.65 295.81,33.99 294.81,33.99 v2(294.53,34.27)
  BOTTOM w0.076: v2(294.53,34.27) 294.9,33.91 UH2.AV4
CPU_DP1_AUXN_C: length 9.9
  TOP w0.14: v2(355.79,51.27) 356.02,51.04 356.25,51.04 356.57,50.73 356.57,50.23 356.88,49.92 356.88,49.19 356.88,49.18 356.88,48.56 356.88,48.55 356.88,47.71 v3(356.26,47.09) 354.59,45.42 353.39,45.42 353.23,45.25 CT26.2
  BOTTOM w0.14: UT1.W11 v2(355.79,51.27)
CPU_DP1_AUXP_C: length 9.9
  TOP w0.14: CT25.2 352.59,44.95 352.68,45.04 352.91,45.04 352.97,45.1 352.97,45.36 353.29,45.67 354.48,45.67 355.86,47.04 355.86,47.05 356.26,47.46 356.27,47.46 356.62,47.81 v3(356.62,48.89) 356.62,49.81 356.31,50.13 356.31,50.62 356.15,50.79 355.85,50.79 355.79,50.73 v2(355.79,50.6)
  BOTTOM w0.14: UT1.Y11 355.46,50.34 355.56,50.44 355.56,50.5 355.66,50.6 v2(355.79,50.6)
CPU_DP1_N0_C: length 2.7
  BOTTOM w0.076: CT7.2 357.38,47.59 357.38,47.69 357.37,47.7
  BOTTOM w0.089: 357.37,47.7 356.97,48.1 356.97,48.78 356.88,48.87 356.88,49.25 356.97,49.34 357.02,49.34 357.11,49.25 UT1.AC7
CPU_DP1_N1_C: length 2.7
  BOTTOM w0.076: CT9.2 356.08,47.56 356.08,47.7 356.55,48.17 356.55,48.58 356.34,48.8 356.15,48.8 355.96,48.99 355.96,49.1 356.03,49.18 356.15,49.18 UT1.AC9
CPU_DP1_N2_C: length 3
  BOTTOM w0.076: 354.94,47.59 354.94,47.5 355.13,47.31 CT23.2
  BOTTOM w0.089: 354.94,47.59 354.94,47.7 355.03,47.79 355.29,47.79 355.58,48.08 355.58,48.73 355.5,48.81 355.5,49.25 355.41,49.34 355.33,49.34 355.27,49.28 UT1.AC11
CPU_DP1_N3_C: length 3.3
  BOTTOM w0.076: 353.86,47.91 353.65,47.7 353.65,47.5 353.84,47.31 CT24.2
  BOTTOM w0.089: UT1.AC13 354.35,49.26 354.44,49.35 354.5,49.35 354.59,49.26 354.59,48.8 354.62,48.76 354.62,48.16 354.37,47.91 353.86,47.91
CPU_DP1_P0_C: length 2.7
  BOTTOM w0.076: CT6.2 357.54,47.5 357.54,47.63 357.54,47.63 357.54,47.77 357.51,47.81 357.51,47.82 357.5,47.83
  BOTTOM w0.089: UT1.AB7 357.34,49.37 357.34,48.97 357.15,48.78 357.15,48.17 357.5,47.83
CPU_DP1_P1_C: length 2.8
  BOTTOM w0.076: UT1.AB9 356.19,49.58 356.41,49.36 356.41,48.96 356.72,48.65 356.72,48.1 356.25,47.63 356.25,47.53 CT8.2
CPU_DP1_P2_C: length 3
  BOTTOM w0.076: 354.76,47.59 354.76,47.51 CT10.2
  BOTTOM w0.089: UT1.AB11 355.05,49.3 355.05,49.01 355.05,49.01 355.05,48.97 355.18,48.84 355.22,48.84 355.4,48.66 355.4,48.15 355.21,47.97 354.96,47.97 354.76,47.78 354.76,47.59
CPU_DP1_P3_C: length 3.3
  BOTTOM w0.076: 354.13,48.09 354.12,48.09 354.11,48.08 353.78,48.08 353.48,47.78 353.48,47.5 CT11.2
  BOTTOM w0.089: 354.13,48.09 354.3,48.09 354.45,48.23 354.45,48.65 354.13,48.97 354.13,49.37 UT1.AB13
CPU_DP2_AUXN_C: length 10.3
  TOP w0.14: CT36.2 351.32,44.71 351.56,44.95 351.56,45.07 352.54,46.04 352.54,46.44 352.94,46.84 354.21,46.84 v3(354.68,47.31) 355.44,48.07 355.44,48.8 355.09,49.15 355.08,49.15 354.65,49.58 354.65,49.59 354.37,49.87 354.37,50.47 354.51,50.6 354.69,50.82 v2(355.13,51.26)
  BOTTOM w0.14: v2(355.13,51.26) UT1.W12
CPU_DP2_AUXP_C: length 10.2
  TOP w0.14: v2(355.14,50.62) 354.87,50.62 354.62,50.32 354.62,49.98 v3(355.07,49.53) 355.38,49.22 355.51,49.09 355.69,48.91 355.69,47.96 355.15,47.42 355.15,47.41 354.69,46.96 354.68,46.96 354.31,46.59 353.05,46.59 352.79,46.33 352.79,45.94 351.82,44.96 351.82,44.78 CT35.2
  BOTTOM w0.127: v2(355.14,50.62) 355.17,50.59 355.17,50.17 355.05,50.05 354.9,50.05 354.81,50.14 UT1.Y12
CPU_DP2_N0_C: length 3.4
  BOTTOM w0.076: 352.4,47.68 352.4,47.56 CT28.2
  BOTTOM w0.089: UT1.AC15 353.43,49.27 353.5,49.34 353.59,49.34 353.67,49.27 353.67,48.84 353.52,48.69 353.52,48.07 353.3,47.86 352.58,47.86 352.4,47.68
CPU_DP2_N1_C: length 3.5
  BOTTOM w0.076: 351.33,47.72 351.21,47.6 351.21,47.49 CT30.2
  BOTTOM w0.089: 351.33,47.72 351.93,47.72 352.45,48.23 352.45,48.63 352.75,48.93 352.75,49.26 352.66,49.35 352.6,49.35 352.51,49.26 UT1.AC17
CPU_DP2_N2_C: length 3.8
  BOTTOM w0.076: CT32.2 349.76,47.59 349.76,47.77 349.93,47.95 350.85,47.95 351.19,48.29 351.19,48.49 351.35,48.65 351.35,48.7 351.45,48.8 351.45,48.86 351.37,48.94 351.37,49.27 351.45,49.34 351.56,49.34 351.59,49.3 UT1.AC19
CPU_DP2_N3_C: length 3.9
  BOTTOM w0.076: 348.62,47.84 348.62,47.85 ; 348.62,47.83 348.62,47.82 348.62,47.82 348.62,47.76 348.61,47.76 348.61,47.55 CT34.2
  BOTTOM w0.089: UT1.AC21 350.72,49.18 350.82,49.18 350.91,49.09 350.91,48.83 350.83,48.76 350.53,48.76 349.97,48.21 348.95,48.21 348.62,47.88 348.62,47.85 ; 348.62,47.83 348.62,47.84
CPU_DP2_P0_C: length 3.4
  BOTTOM w0.076: CT27.2 352.23,47.52 352.23,47.76 352.32,47.85
  BOTTOM w0.089: UT1.AB15 353.43,49.59 353.2,49.28 353.2,48.91 353.34,48.77 353.34,48.15 353.23,48.03 352.5,48.03 352.32,47.85
CPU_DP2_P1_C: length 3.4
  BOTTOM w0.076: CT29.2 351.04,47.6 351.04,47.67 351.26,47.89 351.54,47.89
  BOTTOM w0.089: 351.54,47.89 351.86,47.89 352.27,48.31 352.27,48.71 352.33,48.77 352.33,48.91 352.29,48.96 352.29,49.28 352.51,49.59 UT1.AB17
CPU_DP2_P2_C: length 3.8
  BOTTOM w0.076: UT1.AB19 351.83,49.36 351.83,48.94 351.51,48.63 351.51,48.58 351.35,48.42 351.35,48.22 350.92,47.78 350,47.78 349.92,47.7 349.92,47.5 CT31.2
CPU_DP2_P3_C: length 3.9
  BOTTOM w0.076: 348.44,47.83 348.44,47.55 CT33.2
  BOTTOM w0.089: 348.44,47.83 348.44,47.95 348.88,48.39 349.9,48.39 350.44,48.93 350.44,49.36 UT1.AB21
CPU_TRIGGER: length 168.1
  TOP w0.14: RH192.1 184.95,97.63 v2(185.02,97.56) ; v1(297.98,37.28) 297.42,37.84 v2(297.42,37.9)
  IN1 w0.097: v2(185.02,97.56) 184.69,97.88 184.69,98.3 185.07,98.68 185.87,98.68 189.42,95.13 189.42,80.51 191.07,78.86 191.07,76.42 193.02,74.47 193.02,70.2 193.61,69.6 193.61,69.09 194.47,68.23 194.47,66.49 198.15,62.81 210.59,62.81 211.56,63.78 216.82,63.78 218.84,65.8 219.73,65.8 220.24,65.29 222.73,65.29 223.52,66.08 229.74,66.08 229.87,65.95 235.11,65.95 265.22,65.95 267.7,63.47 277.04,63.47 284.77,55.73 284.77,51.97 285.5,51.25 285.5,47.15 285.81,46.83 289.31,46.83 290.08,46.05 290.08,44.71 290.96,43.83 290.96,43.16 291.82,42.29 291.82,39.83 291.06,39.07 291.06,38.52 291.42,38.17 292.08,38.17 292.61,37.63 292.61,37.53 292.9,37.24 295.44,37.24 295.49,37.29 295.49,37.31 295.87,37.69 297.2,37.69 297.42,37.9 v2(297.42,37.9)
  BOTTOM w0.076: UH2.AK1 297.42,37.91 v2(297.42,37.9)
CPU_TRIGGER_R: length 9.4
  TOP w0.114: 178.23,96.61 177.51,95.89 177.21,95.89 176.06,94.73 v2(176.06,94.69)
  TOP w0.14: 178.23,96.61 v1(178.97,96.61) 182.09,96.61 183.03,97.55 RH192.2
  BOTTOM w0.076: UH1.J23 175.42,94.69 v2(176.06,94.69)
CPU_XDP_TCK: length 128.1
  TOP w0.14: v2(133.01,106) v4(133.81,106)
  IN3 w0.124: v2(140.01,97.63) 140.01,98.76 139.68,99.09 139.68,104.1 138.98,104.8 138.98,105.93 140.58,107.53 164.36,107.53 164.83,108 179.6,108 181.65,105.94 181.65,104.93 182.11,104.47 183.55,104.47 185,103.02 185,100.69 187.49,98.2 187.49,78.78 187.86,78.41 187.86,77.79 v2(187.81,77.74)
  IN4 w0.137: v2(187.81,77.74) 187.81,77.67 188.85,76.63 190.38,76.63 192.58,74.43 192.58,73.75 192.68,73.66 192.68,70.15 193.02,69.81 193.02,68.8 192.63,68.42 192.63,67.08 193.1,66.62 193.1,64.5 193.34,64.27 193.34,60.52 v2(194.54,59.31)
  IN5 w0.097: v2(133.01,106) 137.9,101.11 137.9,100.7 140.01,98.59 v2(140.01,97.63)
  BOTTOM w0.076: 138.58,97.82 139.29,97.82 139.49,97.63 140,97.63 v2(140.01,97.63) 140.32,97.95 UH1.BR28 ; 137.41,96.02 RH38.2
  BOTTOM w0.102: RH38.2 138.58,97.82
  BOTTOM w0.14: RH61.2 137.41,96.02 ; v2(194.54,59.31) 195.29,60.06 196.31,60.06 196.87,60.63 JXDP1.57
CPU_XDP_TDI: length 7.9
  TOP w0.14: v4(144.04,100.58) v2(143.44,100.58) 142.83,100.58 142.48,100.93 139.04,100.93 138.44,100.33 RH56.2 RH534.2
  BOTTOM w0.114: v2(143.44,100.58) 143.11,100.91 UH1.BL32
CPU_XDP_TDO: length 3.5
  TOP w0.14: RH497.2 RH533.2 138.5,98.55 v2(138.79,98.26) 138.84,98.26 v4(139.24,98.67)
  BOTTOM w0.076: UH1.BT28 139.62,98.07 139.29,98.07 139.1,98.26 v2(138.79,98.26)
CPU_XDP_TMS: length 11.3
  TOP w0.14: v2(140.63,98.4) 141.21,98.99 v4(142.89,98.99)
  BOTTOM w0.102: UH1.BP28 140.97,98.06 v2(140.63,98.4) 140.51,98.52 139.49,98.52 139.28,98.72 138.68,98.72 138.28,98.32 138.28,97.88 137.61,97.21 137.31,97.21
  BOTTOM w0.14: 137.31,97.21 137.25,97.15 135.5,97.15 135.2,96.85 RH496.2 134.58,96.85 134.18,96.45 RH535.2
CPU_XDP_TRST#: length 241.7
  TOP w0.14: v2(275.67,57.96) 275.67,57.9 v4(275.08,57.31)
  IN1 w0.097: v2(275.67,57.96) 275.67,58.47 273.72,60.42 265.73,60.42 263.33,62.81 v2(235.58,62.81)
  IN2 w0.097: v2(275.67,57.96) 282.41,57.96 283.49,56.88 284.06,56.88 286.19,54.75 286.19,53.83 286.35,53.67 286.35,52.88 289.93,49.3 289.93,48.76 290.25,48.44 291.37,48.44 292.04,49.1 293.53,49.1 294.75,47.88 295.38,47.88 296.2,47.06 296.2,46.56 296.4,46.36 296.4,44.79 295.07,43.45 295.07,42.03 295.62,41.47 295.62,40.87 295.07,40.31 295.07,39.77 295.69,39.14 295.69,37.75 294.03,36.1 294.03,34 294.95,33.08 v2(294.95,33.07)
  IN3 w0.124: v2(235.58,62.81) 234.45,63.94 230.03,63.94 228.04,65.93 223.18,65.93 222.04,67.08 219.63,67.08 215.67,71.05 213.24,71.05 210.69,73.6 209.81,73.6 209.66,73.75 208.19,73.75 207.97,73.97 203.16,73.97 202.27,73.08 199.59,73.08 198.48,74.2 198.48,74.73 195.76,77.45 194.13,77.45 191.24,80.34 191.24,100.9 188.28,103.85 188.28,104.23 185.88,106.63 185.88,107.74 184.22,109.4 181.39,109.4 180.54,110.24 176.22,110.24 175.37,111.09 168.11,111.09 167.87,110.86 159.19,110.86 158.28,109.95 139.17,109.95 131.29,102.07 131.29,100.8 131.74,100.36 v2(131.99,100.36)
  BOTTOM w0.089: UH2.AY5 294.95,32.84 v2(294.95,33.07)
  BOTTOM w0.114: 137.31,100.61 137.77,100.61 138.15,100.23 138.34,100.23 138.51,100.06 140.29,100.06 140.75,99.6 UH1.BP30
  BOTTOM w0.14: v2(131.99,100.36) 132.45,100.82 RH536.2 132.78,100.82 133.17,100.42 134.6,100.42 135.07,99.95 RH60.2 135.12,100.27 135.45,100.61 137.31,100.61 137.31,100.61
CPVEE: length 2.8
  TOP w0.203: HDA1.34 347.98,21.46 348.16,21.64 348.6,21.64
  TOP w0.305: 348.6,21.64 349.02,21.64 349.68,20.98 CA15.2
CRT_B: length 8
  TOP w0.14: LVGA3.2 CVGA21.1 372.96,117.09 v1(373.17,117.3) 373.99,118.12 373.99,119.73 374.72,120.46 374.91,120.46 JCRT1.3
CRT_DDCCLK_CON: length 114.5
  TOP w0.14: UVGA1.15 322.83,39.51 323.03,39.7 323.29,39.7 v2(323.63,40.05)
  IN5 w0.097: v2(332.93,53.88) 333.48,53.88 336.4,56.8 337.82,56.8 344.47,63.45 344.47,65.03 356.29,76.86 358.68,76.86 360.53,78.7 360.53,78.87 360.53,78.87 360.53,108.14 369.83,117.44 374.53,117.44 JCRT1.15
  BOTTOM w0.14: JCRT1.15 374.05,116.42 371.72,116.42 RVGA7.1 ; v2(323.63,40.05) 323.48,40.2 323.48,42.22 321.97,43.74 321.97,47.44 329.34,54.82 331.98,54.82 v2(332.93,53.88)
CRT_DDCDATA_CON: length 120.2
  TOP w0.14: UVGA1.16 322.81,39.91 v2(323.03,40.13) ; v2(333.33,54.3) v1(333.33,55)
  IN5 w0.097: JCRT1.12 374.8,123.96 373.23,122.39 373.23,119.6 371.27,117.64 369.74,117.64 360.33,108.22 360.33,108.06 360.33,78.79 358.6,77.05 356.21,77.05 344.27,65.12 344.27,63.53 337.74,57 336.32,57 333.62,54.3 v2(333.33,54.3)
  BOTTOM w0.14: v2(323.03,40.13) 323.22,40.31 323.22,42.1 321.72,43.6 321.72,47.54 329.24,55.06 332.08,55.06 332.85,54.3 v2(333.33,54.3) ; JCRT1.12 374.8,123.25 372.23,120.68 RVGA8.1
CRT_G: length 6.1
  TOP w0.14: LVGA2.2 CVGA20.1 372.96,121.08 v1(373.37,121.49) 374.65,122.77 374.93,122.77 JCRT1.2
CRT_HSYNC_CON: length 6.6
  TOP w0.14: JCRT1.13 374.8,121.16 373.55,119.91 373.55,118.93 373.29,118.67 v1(372.48,118.67) 371.84,118.67 CVGA23.1 RVGA14.1
CRT_PCH_HPD: length 3.1
  TOP w0.14: UVGA1.32 317.31,37.11 v1(317.11,37.32) 316.74,37.32 316.54,37.11 RVGA10.2 RVGA9.2
CRT_R: length 7.2
  TOP w0.14: LVGA1.2 CVGA19.1 v1(372.96,125.3) 372.96,125.81 374.18,127.03 375.5,127.03 JCRT1.1
CRT_VSYNC_CON: length 8
  TOP w0.14: JCRT1.14 374.8,118.3 374.07,117.57 v1(374.07,115.48) 373.34,114.76 CVGA24.1 RVGA15.1
CS1: length 4.9
  TOP w0.14: v1(85.14,39.02) 84.57,39.02 PR305.2
  TOP w0.203: PU300.1 83.49,42.02 83.82,41.7 83.82,40.2 PR305.2
CS2: length 3.5
  TOP w0.203: PU300.5 83.19,43.62 83.41,43.85 83.41,44.17 83.21,44.37 83.21,45.14 v1(83.48,45.41) 83.77,45.69 PR304.2
CS_1.2V: length 3.2
  TOP w0.14: PR201.2 111.51,70.64 v1(110.57,70.64)
  TOP w0.203: PR201.2 111.54,69.96 111.54,69.4 111.59,69.34 PU200.13
CSNSUM: length 4.2
  TOP w0.203: PU6000.21 155.46,139.94 155.33,140.07 155.33,141.46 155.65,141.77 v1(155.7,141.77) 156.16,141.77 156.78,142.4 PR6020.2
CSON_1: length 19.8
  TOP w0.14: v2(35.08,31.21) 35.08,31 v1(35.45,30.64)
  TOP w0.254: v2(35.08,31.21) PC722.1 PC721.2 35.12,32.9 PR726.2
  IN3 w0.254: v2(35.08,31.21) 37.86,33.99 37.86,34.72 39.4,36.26 44.44,36.26 45.56,35.14 45.56,35.02 v2(45.91,34.66)
  BOTTOM w0.254: PR716.3 45.73,36.4 45.48,36.15 45.48,35.09 v2(45.91,34.66)
CSOP_1: length 17.9
  TOP w0.254: PR724.2 35.98,32.87 PC721.1 36.86,32.86 PC720.2 37.42,32.32 v2(37.42,31.21)
  IN3 w0.254: v2(45.16,34.65) 45.16,34.89 44.15,35.91 39.55,35.91 38.22,34.57 38.22,32.01 v2(37.42,31.21)
  BOTTOM w0.254: PR716.2 44.73,36.4 45.01,36.12 45.01,34.8 v2(45.16,34.65)
CSPSUM: length 12.6
  TOP w0.14: PR6007.1 v1(147.44,142.5)
  TOP w0.203: PR6004.2 155.74,142.4 155,141.66 155,139.92 155.38,139.54 PU6000.22
  TOP w0.254: PR6007.1 148.63,142.49 PC6007.1 149.54,142.47 150.41,142.47 PR6011.1 150.72,142.79 153.75,142.79 PR6002.2 154.73,142.57 PR6003.2 PR6004.2
CSSN_1: length 29.4
  TOP w0.254: v2(38.51,47.55) v1(39.22,46.84) 39.22,45.14 38.61,44.53 PR706.2 ; PR703.3 55.41,41.24 55.22,41.05 55.22,40.1 v2(55.41,39.91)
  IN1 w0.254: v2(55.41,39.91) 55.41,40.58 55.07,40.92 55.07,44.06 50.14,48.99 45.95,48.99 45.07,48.11 39.27,48.11 38.71,47.55 v2(38.51,47.55)
CSSN_2: length 5.6
  TOP w0.203: v2(36.23,41.56) 36.12,41.44 36.12,41.25 35.74,40.87 PU700.1
  TOP w0.254: PR706.1 38.24,43.6 PC711.2 v1(37.12,41.62) 36.3,41.62 v2(36.23,41.56)
  BOTTOM w0.254: PC712.1 36.27,41.52 v2(36.23,41.56)
CSSN_B+: length 210.2
  TOP w0.127: v1(119.3,105.62) PR6100.3
  TOP w0.254: PR6100.3 117.75,104.33 117.44,104.02 v2(114.9,104.02)
  IN3 w0.254: v2(124.87,44.65) 126.19,43.32 163.58,43.32 166.36,46.1 190.43,46.1 191.21,46.88 198.55,46.88 199.11,46.32 203.16,46.32 204.91,48.07 209.69,48.07 218.16,56.54 222.07,56.54 222.43,56.9 225.3,56.9 226.04,56.16 226.04,55.3 226.83,54.5 229.76,54.5 232.37,57.11 232.37,59.53 v2(232.49,59.64)
  IN5 w0.254: v2(114.9,104.02) 115.38,103.53 115.38,102.52 115.15,102.29 115.15,98.45 116.6,96.99 116.6,86.74 121.11,82.23 121.11,54.41 126.02,49.49 126.02,44.95 125.72,44.65 v2(124.87,44.65)
  BOTTOM w0.254: v2(232.49,59.64) 232.49,62.91 234.84,65.26 234.84,75.17 234.21,75.8 232.39,75.8 RG59.1
CSSN_NVVDD: length 208.8
  TOP w0.127: v1(119.37,112.99) PR6101.3
  TOP w0.254: PR6101.3 117.75,111.58 117.52,111.35 v2(117.19,111.35)
  IN3 w0.254: v2(122.82,45.48) 123.51,45.48 124.89,46.87 190.14,46.87 191.51,48.24 202.42,48.24 202.94,48.76 203.75,48.76 204.14,49.15 209.77,49.15 218.66,58.04 221.7,58.04 222.29,58.63 225.27,58.63 226.72,57.18 230.37,57.18 230.68,57.5 230.68,58.15 v2(230.2,58.63)
  IN5 w0.254: v2(122.82,45.48) 123.56,45.48 123.93,45.85 123.93,50.58 120.4,54.12 120.4,81.94 115.89,86.44 115.89,96.7 114.36,98.22 114.36,104.63 115.29,105.55 115.29,110.5 115.68,110.89 116.73,110.89 v2(117.19,111.35)
  BOTTOM w0.254: RG64.1 232.26,72.75 233.16,72.75 233.82,72.1 233.82,65.95 231.37,63.49 231.37,60.46 230.2,59.29 v2(230.2,58.63)
CSSP_1: length 27.5
  TOP w0.254: v2(54.71,39.91) 54.84,40.03 54.84,41.05 54.65,41.24 PR703.2 ; PR705.2 37.36,45.15 v1(37.73,45.52) 38.25,45.52 v2(38.47,45.3)
  IN1 w0.254: v2(38.47,45.3) 40.92,47.75 45.22,47.75 46.1,48.63 49.99,48.63 54.71,43.91 v2(54.71,39.91)
CSSP_2: length 6.7
  TOP w0.203: v2(35.65,41.43) 35.65,41.34 35.34,41.03 PU700.2
  TOP w0.254: PR705.1 37.32,43.58 PC711.1 36.65,42.07 36.06,42.07 35.66,41.67 35.66,41.44 v2(35.65,41.43)
  BOTTOM w0.14: v1(36.23,42.32) 35.65,41.74 v2(35.65,41.43)
  BOTTOM w0.254: PC710.2 34.78,40.56 v2(35.65,41.43)
CSSP_B+: length 204.1
  TOP w0.127: PR6100.2 115.35,99.3 v1(114.79,98.74)
  TOP w0.254: v2(114.9,102.9) 115.35,102.45 PR6100.2
  IN3 w0.254: v2(125.36,45.14) 126.83,43.68 163.43,43.68 166.21,46.46 190.29,46.46 191.15,47.33 198.73,47.33 199.31,46.74 203.07,46.74 204.76,48.43 209.55,48.43 218.09,56.98 221.98,56.98 222.26,57.25 225.46,57.25 226.39,56.33 226.39,55.46 226.99,54.86 229.09,54.86 231.99,57.76 231.99,59.56 v2(231.9,59.64)
  IN5 w0.254: v2(125.36,45.14) 125.36,49.65 120.75,54.26 120.75,82.08 116.24,86.59 116.24,96.85 114.79,98.3 114.79,102.8 v2(114.9,102.9)
  BOTTOM w0.254: v2(231.9,59.64) 231.9,59.86 232.07,60.02 232.07,62.99 234.48,65.4 234.48,75.02 234.06,75.44 232.39,75.44 RG62.1
CSSP_NVVDD: length 201.4
  TOP w0.127: v2(229.88,58.14) v1(229.88,57.45)
  TOP w0.254: PR6101.2 115.35,109.83 v2(114.79,110.39)
  IN3 w0.254: v2(229.88,58.14) 229.27,57.53 226.87,57.53 225.42,58.98 222.14,58.98 221.55,58.4 218.44,58.4 209.55,49.51 203.19,49.51 202.27,48.59 191.36,48.59 189.99,47.22 124.55,47.22 v2(123.3,45.98)
  IN5 w0.254: v2(123.3,45.98) 123.3,50.71 120.04,53.97 120.04,81.79 115.53,86.3 115.53,96.55 114.01,98.07 114.01,104.77 114.94,105.7 114.94,110.25 v2(114.79,110.39)
  BOTTOM w0.254: v2(229.88,58.14) 229.71,58.32 229.71,59.3 231.01,60.61 231.01,63.64 233.47,66.09 233.47,71.95 233.02,72.4 232.26,72.4 RG66.1
DAT_SMB: length 16.9
  TOP w0.14: v1(57.57,29.09) 57.84,29.35 v2(58.28,29.35)
  TOP w0.254: v2(58.28,29.35) 58.35,29.42 58.84,29.42 PR10.1
  BOTTOM w0.14: v2(58.28,29.35) 58.08,29.56 49.06,29.56 46.48,32.14 46.48,33.36 46.34,33.5 PBATT1.5
DAT_TP_SIO: length 188.2
  TOP w0.14: v2(313.14,15.26) 313.32,15.26 313.99,14.59 UE1.79 317.29,14.59 RE55.2
  IN4 w0.137: v2(313.14,15.26) 313.05,15.35 307.77,15.35 305.51,17.61 305.51,17.99 303.87,19.62 300.04,19.62 298.35,21.31 293.38,21.31 293.19,21.12 280.79,21.12 279.85,22.06 279.21,22.06 279.21,22.07 278.86,22.07 278.85,22.06 278.63,22.06 278.62,22.07 278.27,22.07 278.27,22.06 278.05,22.06 278.04,22.07 277.69,22.07 277.68,22.06 271.61,22.06 270.2,23.48 270.2,24.06 269.27,24.99 264.85,24.99 264.55,25.29 261.64,25.29 257.3,29.63 255.52,29.63 254.09,31.06 250.8,31.06 249.61,32.25 211.95,32.25 211.61,31.92 159.41,31.92 158.56,32.77 157,32.77 v2(156.45,33.32)
  BOTTOM w0.14: v2(156.45,33.32) 157.9,31.86 157.9,29.48 CE9.1 157.39,28.97 DE4.6 157.39,26.71 157.25,26.57 155.55,26.57 155.01,27.11 155.01,27.3 153.9,28.41 148.72,28.41 148.45,28.68 JTP.2
DDC_SCL_HDMI: length 233.5
  TOP w0.112: UP2.7 337.69,45.44 337.75,45.5 338.11,45.5 338.74,46.13 339.26,46.13 340.39,47.26 340.39,48.46 340.71,48.78 340.83,48.78 v2(340.98,48.63) ; v2(206.22,72.68) 206.14,72.6 205.98,72.6 205.78,72.79 205.78,72.87 205.67,72.98 205.51,72.98 205.4,72.87 205.4,72.42 205.08,72.1 203.75,72.1 203.05,72.8 198.03,72.8 197.59,72.35 197.59,69.03 194.65,66.09 194.65,65.93 194.9,65.69 195,65.69 RG578.2
  IN1 w0.089: v2(206.22,72.68) 206.34,72.8 207.06,72.8 207.5,72.35 210.33,72.35 211.47,71.21 216.5,71.21 217.04,71.75 223.34,71.75 224.05,72.47 249.03,72.47 249.92,71.59 267.33,71.59 269.97,68.94 273.55,68.94 274.42,69.81 281.8,69.81 287.94,63.68 288.67,63.68 293.18,59.17 300.13,59.17 302.65,56.65 305.44,56.65 306.97,55.12 318.33,55.12 320.81,52.64 330.84,52.64 335.05,48.43 339.71,48.43 340.12,48.83 340.78,48.83 v2(340.98,48.63) 341.15,48.8 341.36,48.8 341.89,49.33 341.89,55.36 343.38,56.86 343.38,59.92 344.51,61.05 346.37,61.05 347,61.68 349.4,61.68 350.56,62.84 350.56,69.62 355.89,74.94 359.29,74.94 364.01,79.66 364.47,79.66 367.7,82.9 367.7,85.5 368.02,85.81 368.27,85.81 v2(368.43,85.65)
  BOTTOM w0.112: RM3.2 367.17,85.5 367.47,85.8 368.28,85.8 v2(368.43,85.65) 368.58,85.8 370.1,85.8 371.21,86.91 371.21,89.44 371.22,89.45 371.5,90 JHDMI1.15
DDC_SDA_HDMI: length 233.6
  TOP w0.112: v2(340.98,49.22) 340.83,49.07 340.59,49.07 340.1,48.58 340.1,47.38 339.17,46.45 338.65,46.45 337.99,45.78 337.75,45.78 337.69,45.84 UP2.8 ; RG577.2 194.22,66.06 197.3,69.15 197.3,72.47 197.91,73.08 v3(199.8,73.08) 203.17,73.08 203.87,72.39 204.96,72.39 205.11,72.54 205.11,72.98 205.39,73.26 205.79,73.26 205.79,73.27 v2(206.22,73.27)
  IN1 w0.089: v2(206.22,73.27) 206.35,73.14 207.09,73.14 207.61,72.61 210.43,72.61 211.58,71.47 216.39,71.47 216.94,72.01 223.23,72.01 223.95,72.73 249.14,72.73 250.02,71.85 267.43,71.85 270.08,69.2 273.44,69.2 274.32,70.07 281.91,70.07 288.04,63.94 288.78,63.94 293.28,59.43 300.23,59.43 302.75,56.91 305.54,56.91 307.07,55.38 318.43,55.38 320.91,52.9 330.94,52.9 335.16,48.69 339.61,48.69 340.01,49.09 340.85,49.09 v2(340.98,49.22) 341.13,49.06 341.25,49.06 341.63,49.44 341.63,55.47 343.12,56.97 343.12,60.03 344.4,61.31 346.26,61.31 346.89,61.94 349.29,61.94 350.3,62.94 350.3,69.73 355.78,75.2 359.19,75.2 363.9,79.92 364.36,79.92 367.45,83 367.45,85.61 367.91,86.07 368.26,86.07 v2(368.43,86.24)
  BOTTOM w0.112: JHDMI1.16 370.45,90 370.64,90.06 370.93,89.91 370.93,87.03 369.98,86.09 368.58,86.09 v2(368.43,86.24) 368.28,86.09 367.47,86.09 367.17,86.39 RM4.2
DDI1_AUXN: length 268.6
  TOP w0.14: RT76.1 353.04,42.93 353.04,43.27 v2(353.23,43.46) 353.05,43.64 353.05,43.88 CT26.1
  IN1 w0.102: 181.76,93.38 180.84,94.31 180.55,94.31 178.55,96.29 177.94,96.29 177.56,96.67 177.56,96.81 177.56,96.86 v2(177.39,97.04)
  IN1 w0.104: 181.76,93.38 184.7,90.45 184.7,79.42 183.36,78.08 183.36,69.64 194.77,58.23 208.91,58.23 209.16,58.49 218.5,58.49 219.54,59.53 229.87,59.53 243.34,46.06 244.59,46.06 245.72,44.93 245.72,42.93 248.9,39.75 248.9,38.23 252.6,34.53 259.47,34.53 260.87,35.92 261.94,35.92 261.94,35.92 262.1,35.92 262.1,35.92 262.61,35.92 262.61,35.92 262.77,35.92 262.77,35.92 263.62,36.78 267.83,36.78 269.55,35.05 269.55,32.88 270.07,32.36 270.07,29.89 273.2,26.76 273.2,25.61 274.47,24.34 275.12,24.34 277.4,22.06 279.3,22.06 279.66,21.7 283.54,21.7 284,21.24 296.21,21.24 296.55,21.57 298.32,21.57 298.78,21.11 298.79,21.11 299.24,20.66 302.14,20.66 302.2,20.6 309.22,20.6 310.8,22.18 312.22,22.18 317.8,27.75 323.19,27.75 324.67,29.24 325.54,29.24 327.21,30.91 334.91,30.91 335.79,30.02 346.62,30.02 347.86,28.78 353.15,28.78 354.86,27.08 359.03,27.08 362.75,30.8 362.75,37.32 361.37,38.71 357.57,38.71 354.62,41.65 354.62,41.87 353.8,42.7 353.33,42.7 353.23,42.8 v2(353.23,43.46)
  BOTTOM w0.076: UH1.E27 177.7,97.38 177.39,97.08 v2(177.39,97.04)
DDI1_AUXP: length 268.6
  TOP w0.14: CT25.1 352.79,43.86 352.79,43.66 v2(352.59,43.46) 352.78,43.27 352.78,42.93 RT78.1
  IN1 w0.102: 181.76,93.67 180.92,94.52 180.63,94.52 178.63,96.5 178.02,96.5 177.76,96.76 177.76,96.93 177.87,97.03 v2(178.03,97.03)
  IN1 w0.104: 181.76,93.67 181.85,93.59 181.84,93.58 184.89,90.53 184.89,79.34 183.55,78 183.55,69.72 194.85,58.42 208.83,58.42 209.08,58.68 218.42,58.68 219.46,59.72 229.95,59.72 243.42,46.25 244.67,46.25 245.91,45.01 245.91,43.01 249.09,39.83 249.09,38.31 252.68,34.72 259.39,34.72 260.79,36.12 262.02,36.12 262.69,36.12 263.54,36.97 267.91,36.97 269.74,35.13 269.74,32.96 270.26,32.44 270.26,29.97 273.39,26.84 273.39,25.69 274.55,24.53 275.2,24.53 277.48,22.25 279.38,22.25 279.74,21.89 283.62,21.89 284.08,21.44 296.13,21.44 296.47,21.77 298.4,21.77 298.86,21.3 298.87,21.3 299.32,20.85 302.22,20.85 302.28,20.79 309.14,20.79 310.72,22.37 312.14,22.37 314.5,24.73 317.72,27.95 323.11,27.95 324.59,29.43 325.46,29.43 327.13,31.1 334.99,31.1 335.87,30.21 346.7,30.21 347.94,28.98 353.23,28.98 354.94,27.27 358.95,27.27 362.56,30.88 362.56,37.24 361.29,38.51 357.49,38.51 354.43,41.57 354.43,41.79 353.72,42.5 353.25,42.5 353.03,42.72 353.03,42.91 352.93,43.02 352.56,43.02 352.45,43.12 352.45,43.32 v2(352.59,43.46)
  BOTTOM w0.076: v2(178.03,97.03) 178.02,97.03 178.02,97.14 UH1.D27
DDI1_DDPB_CTRLDAT: length 11.5
  TOP w0.14: v1(296.93,29.53) 297.44,30.05 v2(297.52,30.05)
  IN1 w0.097: v2(295.23,30.86) 295.56,31.19 297.58,31.19 297.86,30.92 297.86,30.37 297.54,30.05 v2(297.52,30.05)
  BOTTOM w0.089: v2(295.23,30.86) 295.28,30.91 UH2.BC4
  BOTTOM w0.14: RH580.1 301.12,26.94 299.91,26.94 297.52,29.33 v2(297.52,30.05)
DDI2_AUXN: length 231.2
  TOP w0.14: CT36.1 351.52,43.86 351.52,43.66 v2(351.32,43.46) 351.48,43.3 351.48,42.9 RT77.1
  IN5 w0.104: v2(351.32,43.46) 351.07,43.46 350.97,43.36 350.97,43.12 351.08,43.01 351.65,43.01 351.76,42.89 351.76,40.38 342.65,31.27 337.13,31.27 335.33,33.06 327.54,33.06 325.74,31.27 316.29,31.27 313.77,33.79 311.9,33.79 304.17,41.51 304.17,43.13 301.37,45.94 299.17,45.94 296.64,48.47 296.64,51.68 294.57,53.75 292.87,53.75 291.82,54.8 291.82,55.49 289.23,58.08 285.14,58.08 284.01,59.21 270.75,59.21 265.1,64.86 229.41,64.86 228.72,64.16 226.46,64.16 225.25,62.95 218.55,62.95 217.89,62.3 210.73,62.3 210.62,62.19 197.79,62.19 196.96,63.02 193.27,63.02 192.75,63.53 190.58,63.53 183.93,70.18 183.93,75.08 184.32,75.47 184.32,91.04 179.24,96.12 177.75,96.12 177.66,96.03 177.49,96.03 177.38,96.13 v2(177.38,96.31)
  BOTTOM w0.076: UH1.E26 177.7,96.56 177.45,96.31 v2(177.38,96.31)
DDI2_AUXP: length 231.2
  TOP w0.14: CT35.1 351.78,43.88 351.78,43.64 v2(351.96,43.46) 351.77,43.27 351.77,42.93 RT79.1
  IN5 w0.104: v2(351.96,43.46) 351.96,40.3 342.73,31.07 337.05,31.07 335.25,32.87 327.62,32.87 325.82,31.07 316.21,31.07 313.69,33.59 311.82,33.59 303.98,41.43 303.98,43.05 301.29,45.75 299.09,45.75 296.45,48.39 296.45,51.6 294.49,53.56 292.79,53.56 291.63,54.72 291.63,55.41 289.15,57.89 285.06,57.89 283.93,59.02 270.67,59.02 265.02,64.67 229.49,64.67 228.8,63.97 226.54,63.97 225.33,62.76 218.63,62.76 217.97,62.1 210.81,62.1 210.7,61.99 197.71,61.99 196.88,62.82 193.19,62.82 192.68,63.33 190.51,63.33 183.73,70.1 183.73,75.16 184.12,75.55 184.12,90.96 179.16,95.93 177.83,95.93 177.74,95.84 177.28,95.84 176.82,96.29 v2(176.7,96.29)
  BOTTOM w0.076: v2(176.7,96.29) 177.05,96.65 UH1.F26
DDI2_DDPC_CTRLDAT: length 9.6
  BOTTOM w0.076: UH2.BD6 294.38,30.87 294.16,30.65 294.16,30.19 294.26,30.09 294.26,29.73 294.77,29.23 295.17,29.23 295.92,28.48
  BOTTOM w0.14: 295.92,28.48 296.14,28.26 297.59,28.26 298.13,27.71 298.8,27.71 299.85,26.66 300.47,26.66 RH579.1
DDI3_AUXN: length 199
  TOP w0.14: CVGA9.1 316.9,30.81 v3(316.9,30.1) 316.9,29.24 v2(317.29,28.86)
  IN1 w0.102: 181.63,94.68 181.57,94.73 181.57,94.73 181.33,94.98 181.33,95.31 181.11,95.53 180.79,95.53 180.78,95.52 180.72,95.58 180.33,95.58 179.33,96.58 v2(179.33,97.03)
  IN1 w0.104: 181.63,94.68 181.69,94.62 181.7,94.62 185.08,91.24 185.08,91.21 185.5,90.79 185.5,79.09 184.16,77.75 184.16,69.98 194.14,60 194.16,60 194.27,59.89 208.51,59.89 209.03,59.37 212.55,59.37 213.03,59.86 215.9,59.86 216.63,60.58 219.75,60.58 219.83,60.66 229.97,60.66 232.12,58.51 232.5,58.51 234.16,56.84 234.16,56.38 243.67,46.86 245.79,46.86 249.7,42.95 249.7,38.57 252.94,35.33 259.14,35.33 260.53,36.73 262.44,36.73 263.29,37.58 268.16,37.58 270.36,35.39 270.36,33.22 270.88,32.7 270.88,30.23 274.05,27.05 274.05,25.91 274.81,25.15 275.45,25.15 277.63,22.96 279.54,22.96 279.99,22.51 284.07,22.51 284.23,22.34 285.43,22.34 285.72,22.05 295.86,22.05 296.22,22.41 298.63,22.41 298.78,22.25 309.73,22.25 310.48,23 311.9,23 317.06,28.16 317.06,28.63 v2(317.29,28.86)
  BOTTOM w0.076: v2(179.33,97.03) 179.33,97.08 179.65,97.4 UH1.B27
DDI3_AUXN_C: length 6.6
  TOP w0.14: RVGA3.1 CVGA9.2 316.84,32.3 316.84,32.56 v3(317.35,33.07) 318.86,34.58 318.86,34.58 319.45,35.16 319.45,35.17 319.53,35.25 319.53,35.89 319.61,35.97 UVGA1.3
DDI3_AUXP: length 199
  TOP w0.14: CVGA4.1 316.65,30.69 316.65,29.09 v2(316.42,28.86)
  IN1 w0.102: 181.76,94.83 181.53,95.06 181.53,95.39 181.19,95.74 180.86,95.74 180.81,95.79 180.41,95.79 179.61,96.59 179.61,96.78 179.87,97.03 v2(179.96,97.03)
  IN1 w0.104: 181.76,94.83 181.83,94.76 181.83,94.76 181.83,94.76 181.85,94.76 185.28,91.33 185.28,91.3 185.71,90.87 185.71,79 184.37,77.67 184.37,77.46 184.36,77.45 184.36,70.06 188.31,66.11 188.33,66.11 194.35,60.09 194.35,60.08 208.59,60.08 209.11,59.57 212.47,59.57 212.95,60.05 215.82,60.05 216.55,60.78 219.67,60.78 219.75,60.85 230.05,60.85 232.2,58.7 232.58,58.7 234.35,56.92 234.35,56.46 243.75,47.06 245.87,47.06 249.9,43.03 249.9,38.65 253.02,35.53 259.06,35.53 260.45,36.92 262.36,36.92 263.21,37.77 268.24,37.77 270.55,35.47 270.55,33.3 271.07,32.78 271.07,30.31 274.24,27.13 274.24,25.99 274.89,25.34 275.53,25.34 277.71,23.15 279.62,23.15 280.07,22.7 284.15,22.7 284.31,22.54 285.51,22.54 285.8,22.24 295.78,22.24 296.14,22.6 298.71,22.6 298.86,22.45 309.65,22.45 310.4,23.2 311.82,23.2 316.86,28.24 316.86,28.89 316.76,28.99 316.56,28.99 v2(316.42,28.86)
  BOTTOM w0.076: v2(179.96,97.03) 179.96,97.08 180.3,97.42 UH1.A27
DDI3_AUXP_C: length 6.6
  TOP w0.14: UVGA1.2 319.21,35.98 319.28,35.91 319.28,35.36 v3(318.94,35.02) 317.35,33.43 317.34,33.43 316.99,33.08 316.99,33.07 316.59,32.67 316.59,32.3 CVGA4.2 RVGA4.1
DDI3_DDPD_CTRLDAT: length 3.3
  TOP w0.14: v2(294.7,29.87) 294.7,30.11 294.98,30.39 v1(295.71,30.39) 295.87,30.39 296.09,30.61 RH141.1
  BOTTOM w0.076: v2(294.7,29.87) 294.7,30.15 UH2.BE6
DDR4_DRAMRST#: length 85.3
  TOP w0.14: v2(206.18,33.4) 206.11,33.48 v1(206.11,34.06) CD97.1
  IN4 w0.137: v2(206.18,33.4) 205.3,34.28 130.43,34.28 v2(129.58,33.43)
  BOTTOM w0.14: JDIMM1.108 v2(129.58,33.43) ; JDIMM2.108 206.08,33.51 v2(206.18,33.4) 206.2,33.39 206.2,33.04 205.61,32.45 204.08,32.45 203.79,32.16 RD31.1
DDR_A_ACT#: length 62.4
  IN2 w0.145: v2(129.31,37.2) 128.89,37.2 128.69,37.4 128.69,38.12 128.68,38.13 128.68,38.66 128.69,38.67 128.69,40.16 128.71,40.18 128.71,40.71 128.68,40.73 128.68,41.15 128.77,41.23 128.77,51.41 147.29,69.94 147.29,70.17 146.89,70.57 146.89,70.8 147.05,70.96 147.28,70.96 147.68,70.56 147.91,70.56 148.07,70.72 148.07,70.95 147.66,71.35 147.66,71.58 147.83,71.74 148.05,71.74 148.46,71.34 148.69,71.34 148.85,71.5 148.85,71.73 148.44,72.13 148.44,72.36 148.61,72.52 148.83,72.52 149.24,72.12 149.47,72.12 149.63,72.28 149.63,72.51 149.22,72.91 149.22,73.14 149.39,73.3 149.61,73.3 150.02,72.9 150.25,72.9 150.66,73.31 150.66,76.71 153.11,79.16 v2(153.33,79.16)
  BOTTOM w0.076: v2(153.33,79.16) 153.33,79.16 153,79.49 UH1.AU3
  BOTTOM w0.213: v2(129.31,37.2) 129.69,37.2 130.63,36.26 130.63,36.21 131.07,35.77 JDIMM1.114
DDR_A_ALERT#: length 57
  IN1 w0.076: 153.17,66.83 153.17,72.96 152.07,74.07 152.07,76.23 v2(151.56,76.74)
  IN1 w0.145: 153.17,66.83 153.17,60.91 135.99,43.73 135.46,43.73 132.18,40.45 132.18,37.43 v2(131.27,36.51)
  BOTTOM w0.076: v2(151.56,76.74) 151.95,76.74 152.36,77.14 152.36,79.54 UH1.AU5
  BOTTOM w0.14: JDIMM1.116 131.58,35.72
  BOTTOM w0.213: 131.58,35.72 131.58,36.21 v2(131.27,36.51)
DDR_A_BG0: length 64.6
  IN1 w0.076: v2(151.51,75.5) 151.63,75.38 151.63,74.1 152.72,73.01 152.72,67.82
  IN1 w0.145: v2(129.33,39.56) 130.66,39.56 135.38,44.29 135.38,44.38 136.42,45.41 136.64,45.41 136.72,45.33 136.95,45.33 137.11,45.49 137.11,45.72 137.03,45.8 137.03,46.03 137.2,46.19 137.42,46.19 137.5,46.11 137.73,46.11 137.89,46.27 137.89,46.5 137.81,46.58 137.81,46.81 137.97,46.97 138.2,46.97 138.28,46.89 138.51,46.89 138.67,47.05 138.67,47.28 138.59,47.36 138.59,47.58 138.75,47.75 138.98,47.75 139.06,47.67 139.29,47.67 139.45,47.83 139.45,48.06 139.37,48.14 139.37,48.36 139.53,48.53 139.76,48.53 139.84,48.45 140.07,48.45 140.23,48.61 140.23,48.84 140.15,48.92 140.15,49.14 140.31,49.31 140.54,49.31 140.62,49.23 140.85,49.23 141.01,49.39 141.01,49.62 140.93,49.7 140.93,49.92 141.09,50.09 141.32,50.09 141.4,50.01 141.63,50.01 141.79,50.17 141.79,50.4 141.71,50.48 141.71,50.7 141.87,50.87 142.1,50.87 142.18,50.79 142.41,50.79 142.57,50.95 142.57,51.18 142.49,51.26 142.49,51.48 142.65,51.65 142.88,51.65 142.96,51.57 143.19,51.57 143.35,51.73 143.35,51.96 143.27,52.03 143.27,52.26 143.43,52.42 143.66,52.42 143.74,52.35 143.97,52.35 144.13,52.51 144.13,52.74 144.05,52.81 144.05,53.04 144.21,53.2 144.44,53.2 144.52,53.13 144.75,53.13 144.91,53.29 144.91,53.52 144.83,53.59 144.83,53.82 144.99,53.98 145.22,53.98 145.3,53.91 145.53,53.91 145.69,54.07 145.69,54.3 145.61,54.37 145.61,54.6 145.77,54.76 146,54.76 146.08,54.69 146.31,54.69 146.47,54.85 146.47,55.08 146.39,55.15 146.39,55.38 146.58,55.58 146.81,55.58 146.89,55.5 147.12,55.5 147.28,55.66 147.28,55.89 147.2,55.97 147.2,56.19 147.36,56.36 147.59,56.36 147.67,56.28 147.9,56.28 148.06,56.44 148.06,56.67 147.98,56.75 147.98,56.97 148.14,57.14 148.37,57.14 148.45,57.06 148.68,57.06 148.84,57.22 148.84,57.45 148.76,57.52 148.76,57.75 148.92,57.91 149.15,57.91 149.23,57.84 149.46,57.84 149.62,58 149.62,58.23 149.54,58.3 149.54,58.53 149.73,58.73 149.96,58.73 150.04,58.65 150.27,58.65 150.43,58.81 150.43,59.04 150.35,59.12 150.35,59.34 150.51,59.51 150.74,59.51 150.82,59.43 151.05,59.43 151.21,59.59 151.21,59.82 151.13,59.9 151.13,60.12 151.29,60.29 151.52,60.29 151.6,60.21 151.83,60.21 151.99,60.37 151.99,60.6 151.91,60.68 151.91,60.9 152.72,61.71 152.72,67.82
  BOTTOM w0.076: v2(151.51,75.5) 153.33,77.32 153.33,77.83 UH1.AU1
  BOTTOM w0.213: v2(129.33,39.56) 129.57,39.56 130.28,40.27 130.28,40.53 131.33,41.58 JDIMM1.115
DDR_A_BG1: length 61.9
  IN1 w0.076: v2(153.33,78.52) 153.63,78.52 153.71,78.44 153.71,78.05 153.63,77.97 152.29,77.97 151.13,76.81 151.13,74.07 152.27,72.93 152.27,67.82
  IN1 w0.145: v2(129.32,40.88) 130.18,40.02 130.39,40.02 130.76,40.39 130.76,40.62 130,41.37 130,41.6 130.16,41.76 130.39,41.76 131.15,41.01 131.38,41.01 131.67,41.3 131.67,41.52 131.01,42.19 131.01,42.41 131.17,42.58 131.4,42.58 132.06,41.91 132.29,41.91 132.45,42.08 132.45,42.3 131.79,42.97 131.79,43.19 131.95,43.36 132.18,43.36 132.84,42.69 133.07,42.69 152.27,61.9 152.27,67.82
  BOTTOM w0.076: UH1.AU2 153.05,78.84 153.3,78.52 153.37,78.52 153.37,78.52 v2(153.33,78.52)
  BOTTOM w0.213: JDIMM1.113 130.82,41.79 129.92,40.88 v2(129.32,40.88)
DDR_A_BS0: length 67.8
  IN1 w0.076: v2(161.7,80.34) 162.05,79.99 162.05,78.84 161.08,77.86 161.08,72.86 158.24,70.03 158.24,66.3
  IN1 w0.145: v2(142.97,38.48) 144.03,39.54 144.03,43.44 144.57,43.97 144.57,44.48 146.41,46.32 146.64,46.32 146.82,46.14 147.05,46.14 147.21,46.3 147.21,46.53 147.03,46.71 147.03,46.94 147.19,47.1 147.42,47.1 147.6,46.92 147.83,46.92 147.99,47.08 147.99,47.31 147.81,47.49 147.81,47.72 147.97,47.88 148.2,47.88 148.38,47.7 148.61,47.7 148.77,47.86 148.77,48.09 148.59,48.27 148.59,48.5 148.75,48.66 148.98,48.66 149.16,48.48 149.39,48.48 149.55,48.64 149.55,48.87 149.37,49.05 149.37,49.28 149.53,49.44 149.76,49.44 149.94,49.26 150.17,49.26 150.33,49.42 150.33,49.65 150.15,49.83 150.15,50.06 150.38,50.29 150.61,50.29 150.79,50.11 151.02,50.11 151.18,50.27 151.18,50.5 151,50.68 151,50.91 151.16,51.07 151.39,51.07 151.57,50.89 151.8,50.89 151.96,51.05 151.96,51.28 151.78,51.46 151.78,51.69 151.94,51.85 152.17,51.85 152.35,51.67 152.58,51.67 152.74,51.83 152.74,52.06 152.56,52.24 152.56,52.47 155.12,55.04 155.12,55.27 154.72,55.67 154.72,55.9 154.88,56.06 155.11,56.06 155.51,55.66 155.74,55.66 155.9,55.82 155.9,56.05 155.5,56.45 155.5,56.68 155.66,56.84 155.89,56.84 156.29,56.44 156.52,56.44 156.68,56.6 156.68,56.82 156.28,57.23 156.28,57.46 156.44,57.62 156.67,57.62 157.07,57.21 157.3,57.21 157.46,57.38 157.46,57.6 157.06,58.01 157.06,58.24 157.22,58.4 157.45,58.4 157.85,57.99 158.08,57.99 158.24,58.16 158.24,66.3
  BOTTOM w0.076: UH1.AH5 160.87,80.43 161.61,80.43 v2(161.7,80.34)
  BOTTOM w0.213: v2(142.97,38.48) 142.29,38.48 142.08,38.26 JDIMM1.150
DDR_A_BS1: length 67.1
  IN1 w0.076: v2(160.24,76.74) 160.2,76.7 160.2,73.6 157.14,70.54
  IN1 w0.145: v2(140.47,40.1) 140.4,40.17 140.4,40.63 140.56,40.79 141.22,40.79 141.39,40.96 141.39,41.18 141.22,41.34 140.56,41.34 140.4,41.51 140.4,41.73 140.56,41.9 141.22,41.9 141.39,42.06 141.39,42.29 141.22,42.45 140.56,42.45 140.4,42.61 140.4,42.88 141.31,43.79 141.31,44.01 141.04,44.28 141.04,44.51 141.2,44.67 141.43,44.67 141.7,44.4 141.92,44.4 142.09,44.57 142.09,44.79 141.82,45.06 141.82,45.29 141.98,45.45 142.21,45.45 142.47,45.18 142.7,45.18 142.86,45.35 142.86,45.57 142.6,45.84 142.6,46.07 142.76,46.23 142.99,46.23 143.25,45.96 143.48,45.96 143.64,46.13 143.64,46.35 143.38,46.62 143.38,46.85 143.54,47.01 143.77,47.01 144.03,46.74 144.26,46.74 144.42,46.91 144.42,47.13 144.16,47.4 144.16,47.63 144.32,47.79 144.55,47.79 144.81,47.52 145.04,47.52 148.8,51.28 148.8,51.51 148.53,51.78 148.53,52.01 148.69,52.17 148.92,52.17 149.19,51.9 149.42,51.9 149.58,52.06 149.58,52.29 149.31,52.56 149.31,52.79 149.47,52.95 149.7,52.95 149.97,52.68 150.2,52.68 150.36,52.84 150.36,53.07 150.09,53.34 150.09,53.57 150.25,53.73 150.48,53.73 150.75,53.46 150.98,53.46 151.14,53.62 151.14,53.85 150.87,54.12 150.87,54.35 151.03,54.51 151.26,54.51 151.53,54.24 151.76,54.24 151.92,54.4 151.92,54.63 151.65,54.9 151.65,55.13 151.81,55.29 152.04,55.29 152.31,55.02 152.54,55.02 152.7,55.18 152.7,55.41 152.43,55.68 152.43,55.91 152.59,56.07 152.82,56.07 153.09,55.8 153.32,55.8 153.48,55.96 153.48,56.19 153.21,56.46 153.21,56.69 153.37,56.85 153.6,56.85 153.87,56.58 154.1,56.58 154.51,56.99 154.51,57.22 154.23,57.49 154.23,57.72 154.39,57.88 154.62,57.88 154.9,57.61 155.12,57.61 155.29,57.77 155.29,58 155.01,58.27 155.01,58.5 155.17,58.66 155.4,58.66 155.68,58.39 155.9,58.39 157.14,59.62 157.14,70.54
  BOTTOM w0.076: UH1.AH1 160.51,77.2 160.24,76.92 v2(160.24,76.74)
  BOTTOM w0.213: JDIMM1.145 140.82,41.93 140.47,41.58 v2(140.47,40.1)
DDR_A_CAS#: length 69.6
  IN2 w0.145: v2(143.22,36.73) 143.61,37.12 143.61,41.52 143.52,41.6 143.52,47.69 145.03,49.19 145.03,49.42 144.3,50.14 144.3,50.37 144.46,50.53 144.69,50.53 145.42,49.81 145.64,49.81 145.81,49.97 145.81,50.2 145.08,50.92 145.08,51.15 145.24,51.31 145.47,51.31 146.2,50.59 146.42,50.59 146.59,50.75 146.59,50.98 145.86,51.7 145.86,51.93 146.02,52.09 146.25,52.09 146.98,51.37 147.2,51.37 147.36,51.53 147.36,51.76 146.64,52.48 146.64,52.71 146.8,52.87 147.03,52.87 147.75,52.15 147.98,52.15 148.61,52.78 148.84,52.78 149.09,52.53 149.31,52.53 149.48,52.69 149.48,52.92 149.23,53.17 149.23,53.4 149.39,53.56 149.62,53.56 149.87,53.31 150.09,53.31 150.26,53.47 150.26,53.7 150.01,53.95 150.01,54.18 150.17,54.34 150.4,54.34 150.65,54.09 150.87,54.09 151.04,54.25 151.04,54.48 150.79,54.73 150.79,54.96 150.95,55.12 151.18,55.12 151.43,54.87 151.65,54.87 151.82,55.03 151.82,55.26 151.57,55.51 151.57,55.74 151.73,55.9 151.96,55.9 152.2,55.65 152.43,55.65 152.59,55.81 152.59,56.04 152.4,56.24 152.4,56.57 152.46,56.63 152.46,56.63 152.65,56.82 152.88,56.82 153.13,56.57 153.36,56.57 153.52,56.73 153.52,56.96 153.27,57.21 153.27,57.44 153.43,57.6 153.66,57.6 153.91,57.35 154.14,57.35 154.3,57.51 154.3,57.74 154.05,57.99 154.05,58.22 154.21,58.38 154.44,58.38 154.69,58.13 154.92,58.13 155.08,58.29 155.08,58.52 154.83,58.77 154.83,59 155.47,59.64 156.25,60.42 158.73,62.9 158.73,71.63 v2(159.84,72.74)
  BOTTOM w0.076: UH1.AD1 163.76,75.85 v1(162.97,75.05)
  BOTTOM w0.213: v2(159.84,72.74) 160.66,72.74 v1(162.97,75.05) ; JDIMM1.156 143.58,35.93 143.59,35.95 143.59,36.35 v2(143.22,36.73)
DDR_A_CKE0: length 62.2
  IN1 w0.076: v2(154.14,78.62) 153.71,79.06 153.71,80.01 153.56,80.17 153.15,80.17 152.12,79.14 152.12,78.49 150.6,76.97 150.6,74.07 151.72,72.94 151.72,70.85
  IN1 w0.145: 151.72,70.85 151.72,62.13 135.7,46.1 135.68,46.1 134.93,45.35 134.93,45.34 133.63,44.03 131.71,44.03 129.16,41.49 129.07,41.49 129.03,41.45 129.02,41.45 128.7,41.14 128.7,39.75 128.07,39.12 128.03,39.12 128.03,39.13 v2(128.03,39.13)
  BOTTOM w0.076: UH1.AT1 v2(154.14,78.62)
  BOTTOM w0.213: v2(128.03,39.13) 128.03,39.13 128.03,39.12 127.39,39.75 127.39,40.69 128.32,41.61 129.46,41.61 129.82,41.97 JDIMM1.109
DDR_A_CKE1: length 59.9
  IN2 w0.145: v2(154.17,79.23) 154.17,79.65 153.58,80.23 152.06,80.23 150.15,78.32 150.15,75.97 128.07,53.89 v2(128.07,40.44)
  BOTTOM w0.076: UH1.AT2 153.71,78.84 154.06,79.2 154.09,79.2 154.12,79.23 v2(154.17,79.23)
  BOTTOM w0.213: JDIMM1.110 130.07,35.67 129.19,36.56 129.04,36.56 128.67,36.94 128.67,37.08 128.61,37.13 128.61,38.8 128.69,38.87 128.69,39.99 128.23,40.44 v2(128.07,40.44)
DDR_A_CLK0: length 65.8
  IN1 w0.076: v2(158.51,74.78) 158.24,74.51 158.11,74.51 154.07,70.47 154.07,66.33 154.06,66.32 154.06,66.3
  IN1 w0.097: v2(137.65,39.34) 137.53,39.46 137.39,39.46 136.96,39.89 136.96,42.75 139.65,45.44 139.65,45.64 139.62,45.67 139.62,45.96 139.95,46.29 140.24,46.29 140.27,46.26 140.47,46.26 140.67,46.46 140.67,46.67 140.52,46.83 140.52,47.19 140.77,47.45 141.13,47.45 141.29,47.29 141.5,47.29 141.65,47.44 141.65,47.64 141.49,47.8 141.49,48.16 141.75,48.42 142.11,48.42 142.27,48.26 142.47,48.26 142.62,48.41 142.62,48.62 142.46,48.78 142.46,49.14 142.72,49.39 143.08,49.39 143.24,49.24 143.45,49.24 143.6,49.39 143.6,49.59 143.44,49.75 143.44,50.11 143.7,50.37 144.06,50.37 144.22,50.21 144.42,50.21 144.57,50.36 144.57,50.57 144.41,50.73 144.41,51.09 144.67,51.34 145.03,51.34 145.19,51.19 145.4,51.19 145.81,51.6 145.81,51.81 145.65,51.96 145.65,52.33 145.91,52.58 146.27,52.58 146.43,52.43 146.64,52.43 146.78,52.57 146.78,52.78 146.63,52.94 146.63,53.3 146.88,53.56 147.25,53.56 147.4,53.4 147.61,53.4 147.76,53.55 147.76,53.76 147.6,53.91 147.6,54.28 147.86,54.53 148.22,54.53 148.38,54.37 148.59,54.37 148.73,54.52 148.73,54.73 148.58,54.89 148.58,55.25 148.83,55.51 149.2,55.51 149.35,55.35 149.56,55.35 149.71,55.5 149.71,55.71 149.55,55.86 149.55,56.22 149.81,56.48 150.17,56.48 150.33,56.32 150.54,56.32 150.73,56.52 150.73,56.72 150.57,56.88 150.57,57.24 150.83,57.5 151.19,57.5 151.35,57.34 151.55,57.34 151.7,57.49 151.7,57.7 151.54,57.86 151.54,58.22 151.8,58.47 152.16,58.47 152.32,58.32 152.53,58.32 152.68,58.46 152.68,58.67 152.52,58.83 152.52,59.19 152.78,59.45 153.14,59.45 153.29,59.29 153.5,59.29 154.06,59.85 154.06,66.3
  BOTTOM w0.076: 161.29,76.09 161.31,76.11 161.39,76.11 161.53,76.25 161.53,78.33 161.43,78.43 161.33,78.43 161.25,78.35 UH1.AG1
  BOTTOM w0.14: v2(137.65,39.34) 137.46,39.53 137.21,39.53 136.82,39.91 JDIMM1.137 ; v2(158.51,74.78) 158.79,74.5 159.09,74.5 159.74,75.15 160.35,75.15 161.29,76.09
DDR_A_CLK1: length 68.4
  IN1 w0.076: 154.75,66.3 154.75,66.32 154.76,66.33 154.76,69.89 159.11,74.24 159.11,76.38 158.18,77.3 158.18,78.02 158.48,78.32 159.07,78.32 159.14,78.4 v2(159.14,78.47)
  IN1 w0.097: 154.75,66.3 154.75,65.73 155,65.48 155.41,65.48 155.56,65.33 155.56,65.12 155.41,64.97 155,64.97 154.75,64.72 154.75,64.35 155,64.1 155.41,64.1 155.56,63.95 155.56,63.74 155.41,63.6 155,63.6 154.75,63.34 154.75,62.98 155,62.72 155.41,62.72 155.56,62.58 155.56,62.37 155.41,62.22 155,62.22 154.75,61.96 154.75,61.6 155,61.35 155.41,61.35 155.56,61.2 155.56,60.99 155.41,60.84 155,60.84 154.75,60.59 154.75,59.56 146.98,51.8 146.98,51.43 147.2,51.22 147.2,51.01 147.05,50.86 146.84,50.86 146.63,51.08 146.26,51.08 146.01,50.82 146.01,50.46 146.22,50.24 146.22,50.04 146.07,49.89 145.87,49.89 145.65,50.1 145.29,50.1 145.03,49.85 145.03,49.49 145.25,49.27 145.25,49.06 145.1,48.91 144.89,48.91 144.68,49.13 144.31,49.13 139.41,44.22 139.41,42.93 139.26,42.79 138.22,42.79 137.96,42.53 137.96,42.17 138.22,41.91 139.26,41.91 139.41,41.76 139.41,41.56 139.26,41.41 138.47,41.41 138.22,41.15 138.22,40.79 138.47,40.53 139.26,40.53 139.41,40.39 139.41,39.8 139.61,39.59 139.61,38.3 139.31,38 137.78,38 137.77,38.01 137.73,38.01 137.63,38.11 v2(137.63,38.15)
  BOTTOM w0.089: UH1.AK2 158.74,78.81 v2(159.14,78.47)
  BOTTOM w0.14: JDIMM1.138 137.08,36.19 136.61,36.66 136.61,37.62 136.87,37.87 137.36,37.87 v2(137.63,38.15)
DDR_A_CLK#0: length 65.8
  IN1 w0.076: 154.24,66.3 154.24,66.32 154.23,66.33 154.23,70.4 158.18,74.35 158.43,74.35 158.51,74.27 v2(158.51,74.15)
  IN1 w0.097: 154.24,66.3 154.24,59.77 153.58,59.11 153.22,59.11 153.06,59.26 152.85,59.26 152.7,59.11 152.7,58.91 152.86,58.75 152.86,58.39 152.6,58.13 152.24,58.13 152.09,58.29 151.88,58.29 151.73,58.14 151.73,57.93 151.89,57.78 151.89,57.41 151.63,57.16 151.27,57.16 151.11,57.31 150.9,57.31 150.75,57.17 150.75,56.96 150.91,56.8 150.91,56.44 150.61,56.14 150.25,56.14 150.09,56.3 149.88,56.3 149.74,56.15 149.74,55.94 149.89,55.78 149.89,55.42 149.64,55.16 149.28,55.16 149.12,55.32 148.91,55.32 148.76,55.17 148.76,54.96 148.92,54.81 148.92,54.45 148.66,54.19 148.3,54.19 148.14,54.35 147.94,54.35 147.79,54.2 147.79,53.99 147.94,53.83 147.94,53.47 147.69,53.21 147.33,53.21 147.17,53.37 146.96,53.37 146.81,53.22 146.81,53.02 146.97,52.86 146.97,52.5 146.71,52.24 146.35,52.24 146.19,52.4 145.99,52.4 145.84,52.25 145.84,52.04 146,51.88 146,51.52 145.47,51 145.11,51 144.96,51.16 144.75,51.16 144.6,51.01 144.6,50.8 144.76,50.65 144.76,50.28 144.5,50.03 144.14,50.03 143.98,50.18 143.77,50.18 143.62,50.04 143.62,49.83 143.78,49.67 143.78,49.31 143.53,49.05 143.16,49.05 143.01,49.21 142.8,49.21 142.65,49.06 142.65,48.85 142.81,48.7 142.81,48.33 142.55,48.08 142.19,48.08 142.03,48.23 141.82,48.23 141.68,48.09 141.68,47.88 141.83,47.72 141.83,47.36 141.58,47.1 141.21,47.1 141.06,47.26 140.85,47.26 140.7,47.11 140.7,46.9 140.86,46.75 140.86,46.38 140.55,46.08 140.19,46.08 140.17,46.1 140.03,46.1 139.81,45.88 139.81,45.75 139.83,45.72 139.83,45.36 137.15,42.67 137.15,39.97 137.37,39.75 137.61,39.75 137.73,39.87 137.73,40.01 v2(137.64,40.11)
  BOTTOM w0.076: 161.49,75.9 161.5,75.91 161.5,75.99 161.7,76.19 161.7,78.4 161.5,78.59 161.33,78.59 161.25,78.67 UH1.AG2
  BOTTOM w0.14: JDIMM1.139 137.33,42.05 137.1,41.83 137.1,40.02 137.3,39.82 137.36,39.82 v2(137.64,40.11) ; v2(158.51,74.15) 158.58,74.22 159.21,74.22 159.86,74.87 160.46,74.87 161.49,75.9
DDR_A_CLK#1: length 68.4
  IN1 w0.076: v2(159.03,77.77) 159.06,77.77 159.14,77.84 159.14,77.98 158.96,78.16 158.55,78.16 158.34,77.95 158.34,77.37 159.27,76.44 159.27,74.18 154.92,69.83 154.92,66.33 154.93,66.32 154.93,66.3
  IN1 w0.097: v2(137.63,37.44) 137.63,37.45 137.63,37.58 137.86,37.81 139.39,37.81 139.8,38.22 139.8,39.67 139.59,39.87 139.59,40.46 139.34,40.72 138.55,40.72 138.4,40.87 138.4,41.08 138.55,41.22 139.34,41.22 139.59,41.48 139.59,41.84 139.34,42.1 138.29,42.1 138.15,42.24 138.15,42.45 138.29,42.6 139.34,42.6 139.59,42.86 139.59,44.15 144.39,48.94 144.6,48.94 144.82,48.73 145.18,48.73 145.43,48.98 145.43,49.35 145.22,49.56 145.22,49.77 145.37,49.92 145.57,49.92 145.79,49.7 146.15,49.7 146.41,49.96 146.41,50.32 146.19,50.54 146.19,50.75 146.34,50.89 146.55,50.89 146.76,50.68 147.13,50.68 147.38,50.93 147.38,51.3 147.17,51.51 147.17,51.72 154.93,59.48 154.93,60.51 155.08,60.66 155.49,60.66 155.75,60.91 155.75,61.28 155.49,61.53 155.08,61.53 154.93,61.68 154.93,61.89 155.08,62.03 155.49,62.03 155.75,62.29 155.75,62.65 155.49,62.91 155.08,62.91 154.93,63.06 154.93,63.26 155.08,63.41 155.49,63.41 155.75,63.67 155.75,64.03 155.49,64.28 155.08,64.28 154.93,64.43 154.93,64.64 155.08,64.79 155.49,64.79 155.75,65.04 155.75,65.41 155.49,65.66 155.08,65.66 154.93,65.81 154.93,66.3
  BOTTOM w0.089: v2(159.03,77.77) 159.01,77.77 158.72,78.19 UH1.AK1
  BOTTOM w0.14: JDIMM1.140 137.58,35.62 137.35,35.85 137.35,36.31 136.89,36.77 136.89,37.5 136.98,37.59 137.48,37.59 v2(137.63,37.44)
